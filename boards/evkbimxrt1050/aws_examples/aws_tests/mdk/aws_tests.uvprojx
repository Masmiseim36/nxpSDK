# Keil uVision project aws_tests.uvprojx, settings and files
target aws_tests flexspi_nor_debug (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: aws_tests.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1052DVL6B, USE_RTOS=1, MBEDTLS_CONFIG_FILE='\"aws_mbedtls_config.h\"', A_LITTLE_ENDIAN, FSL_RTOS_FREE_RTOS, AMAZON_FREERTOS_ENABLE_UNIT_TESTS=1
  c misc: --library_interface=armcc 
--diag_suppress=66,1296,186 
--diag_suppress=1296,186 
--diag_suppress=177
  c include: ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F;../../..;..;../../../../../CMSIS/Include;../../../../../devices;../../../../../rtos/amazon-freertos/lib/include;../../../../../rtos/amazon-freertos/lib/include/private;../../../../../middleware/mbedtls/include;../../../../../middleware/mbedtls/port/ksdk;../config_files;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../middleware/wifi_qca/port/boards/evkbimxrt1050/freertos/gt202;../../../../../rtos/amazon-freertos/lib/third_party/mcu_vendor/nxp/MIMXRT1052/drivers;../../../../../middleware/wifi_qca;../../../../../middleware/wifi_qca/include;../../../../../middleware/wifi_qca/include/AR6002;../../../../../middleware/wifi_qca/include/AR6002/hw2.0/hw;../../../../../middleware/wifi_qca/include/AR6002/hw4.0/hw;../../../../../middleware/wifi_qca/custom_src/stack_custom;../../../../../middleware/wifi_qca/custom_src/include;../../../../../middleware/wifi_qca/common_src/include;../../../../../middleware/wifi_qca/common_src/stack_common;../../../../../middleware/wifi_qca/common_src/hcd;../../../../../middleware/wifi_qca/common_src/wmi;../../../../../middleware/wifi_qca/port;../../../../../rtos/amazon-freertos/lib/include;../../../../../rtos/amazon-freertos/lib/include/private;../../../../../rtos/amazon-freertos/lib/third_party/pkcs11;../../../../../rtos/amazon-freertos/lib/third_party;../../../../../rtos/amazon-freertos/lib/third_party/jsmn;../../../../../rtos/amazon-freertos/lib/include;../../../../../rtos/amazon-freertos/lib/include;../../../../../rtos/amazon-freertos/tests/common/include;../../../../../rtos/amazon-freertos/lib/third_party/unity/src;../../../../../rtos/amazon-freertos/lib/third_party/unity/extras/fixture/src;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052;../../../../../devices/MIMXRT1052/utilities/str;../../../../../devices/MIMXRT1052/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/serial_manager;../../../../../devices/MIMXRT1052/drivers;../../../../../components/lists;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/xip;../../../xip;../../../../../middleware/wifi_qca/port/boards/evkbimxrt1050/freertos;../../../../../middleware/wifi_qca/port/env/freertos;../../../../../middleware/wifi_qca/port/drivers/lpspi_edma_freertos;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../../..;..;../config_files
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: --remove 
--keep=*(.boot_hdr.ivt) 
--keep=*(.boot_hdr.boot_data) 
--keep=*(.boot_hdr.conf) 
--predefine="-D__stack_size__=0x200" 
--predefine="-D__heap_size__=0x200" 
--predefine="-DXIP_IMAGE"
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source
    ../application_code/: main.c
  group configs
    ../config_files/: aws_bufferpool_config.h aws_ggd_config.h aws_mbedtls_config.h aws_mqtt_agent_config.h aws_mqtt_config.h aws_pkcs11_config.h aws_secure_sockets_config.h aws_shadow_config.h aws_test_pkcs11_config.h aws_test_runner_config.h aws_test_tcp_config.h aws_test_wifi_config.h aws_wifi_config.h FreeRTOSConfig.h FreeRTOSIPConfig.h unity_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_trng.c fsl_trng.h fsl_dcp.c fsl_dcp.h fsl_cache.c fsl_cache.h fsl_flexspi.c fsl_flexspi.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.h fsl_lpspi_edma.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c
  group wifi_qca-port-shields-gt202
    ../../../../../middleware/wifi_qca/port/boards/evkbimxrt1050/freertos/gt202/: wifi_shield_gt202.h
  group amazon-freertos-drivers
    ../../../../../rtos/amazon-freertos/lib/third_party/mcu_vendor/nxp/MIMXRT1052/drivers/: mflash_drv.h mflash_drv.c mflash_file.h mflash_file.c
  group amazon-freertos-pkcs11
    ../../../../../rtos/amazon-freertos/lib/pkcs11/mbedtls/: aws_pkcs11_mbedtls.c
    ../../../../../rtos/amazon-freertos/lib/pkcs11/portable/nxp/evkbimxrt1050/: aws_pkcs11_pal.c
  group amazon-freertos-FreeRTOS-portable
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F/: fsl_tickless_systick.c fsl_tickless_generic.h port.c portmacro.h
  group wifi_qca-common_src-wmi
    ../../../../../middleware/wifi_qca/common_src/wmi/: wmi.c wmi_host.h
  group wifi_qca-common_src-stack_common
    ../../../../../middleware/wifi_qca/common_src/storerecall/: dset_api.c
    ../../../../../middleware/wifi_qca/common_src/stack_common/: common_stack_offload.h
  group wifi_qca-common_src-qapi
    ../../../../../middleware/wifi_qca/common_src/stack_common/: api_stack_offload.c
    ../../../../../middleware/wifi_qca/common_src/qapi/: qcom_api.c qcom_dns.c qcom_legacy.c
  group wifi_qca-common_src-include
    ../../../../../middleware/wifi_qca/common_src/include/: dset_api.h driver_cxt.h a_drv_api.h wlan_api.h wmi_api.h hif_internal.h dset.h dbglog_api.h common_api.h bmi.h aggr_recv_api.h a_drv.h a_debug.h spi_hcd_if.h netbuf.h ieee80211.h htc_api.h
  group wifi_qca-common_src-htc
    ../../../../../middleware/wifi_qca/common_src/htc/: htc.c
    ../../../../../middleware/wifi_qca/common_src/hcd/: spi_hcd.c
  group wifi_qca-common_src-driver
    ../../../../../middleware/wifi_qca/common_src/driver/: driver_main.c driver_txrx.c driver_netbuf.c driver_init.c driver_diag.c
  group wifi_qca-common_src-api_interface
    ../../../../../middleware/wifi_qca/common_src/api_interface/: api_wmi_rx.c api_ioctl.c api_txrx.c api_init.c
  group wifi_qca-common_src-hw_interface
    ../../../../../middleware/wifi_qca/common_src/hw_interface/: hw_api.c
  group wifi_qca-common_src-storerecall
    ../../../../../middleware/wifi_qca/common_src/storerecall/: dset.c storerecall.c
  group wifi_qca-common_src-hcd
    ../../../../../middleware/wifi_qca/common_src/hcd/: hcd_api.h
  group wifi_qca-common_src-bmi
    ../../../../../middleware/wifi_qca/common_src/bmi/: bmi.c
  group wifi_qca-common_src-util
    ../../../../../middleware/wifi_qca/common_src/util/: util.c
  group wifi_qca-common_src-reorder
    ../../../../../middleware/wifi_qca/common_src/reorder/: rcv_aggr.c
  group wifi_qca-custom_src-stack_custom
    ../../../../../middleware/wifi_qca/custom_src/stack_custom/: cust_api_stack_offload.c qca_structs.h custom_stack_offload.h cust_api_stack_txrx.c
  group wifi_qca-custom_src-qapi
    ../../../../../middleware/wifi_qca/custom_src/qapi/: custom_qcom_api.c
  group wifi_qca-custom_src-include
    ../../../../../middleware/wifi_qca/custom_src/include/: cust_netbuf.h a_osapi.h a_config.h wlan_config.h custom_wlan_api.h a_types.h
  group wifi_qca-custom_src-api_interface
    ../../../../../middleware/wifi_qca/custom_src/api_interface/: cust_api_wmi_rx.c cust_api_ioctl.c cust_api_txrx.c cust_api_init.c
  group wifi_qca-custom_src-driver
    ../../../../../middleware/wifi_qca/custom_src/driver/: cust_driver_netbuf.c cust_driver_main.c
  group wifi_qca-custom_src-hw_interface
    ../../../../../middleware/wifi_qca/custom_src/hw_interface/: cust_spi_hcd.c
  group wifi_qca-include
    ../../../../../middleware/wifi_qca/include/: wmi.h dbglog.h athdefs.h dbglog_id.h bmi_msg.h wlan_defs.h targaddrs.h pmu.h pkt_log.h p2p.h htc_services.h htc.h
    ../../../../../middleware/wifi_qca/: qcom_api.h atheros_stack_offload.h atheros_wifi_internal.h atheros_wifi_api.h atheros_wifi.h
  group wifi_qca-include-AR6002-hw2.0-hw
    ../../../../../middleware/wifi_qca/include/AR6002/hw2.0/hw/: hw20_gpio_reg.h hw20_apb_map.h hw20_vmc_reg.h hw20_uart_reg.h hw20_si_reg.h hw20_rtc_reg.h hw20_mbox_reg.h hw20_mbox_host_reg.h
  group wifi_qca-include-AR6002
    ../../../../../middleware/wifi_qca/include/AR6002/: AR6K_version.h
  group wifi_qca-include-AR6002-hw4.0-hw
    ../../../../../middleware/wifi_qca/include/AR6002/hw4.0/hw/: hw40_rtc_wlan_reg.h hw40_rtc_reg.h
  group wifi_qca-port
    ../../../../../middleware/wifi_qca/port/: wifi_common.h
  group amazon-freertos-license
    ../../../../../rtos/amazon-freertos/: LICENSE
  group amazon-freertos-include
    ../../../../../rtos/amazon-freertos/lib/include/: event_groups.h FreeRTOS.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h FreeRTOS.h aws_crypto.h aws_greengrass_discovery.h aws_mqtt_agent.h aws_mqtt_lib.h aws_pkcs11.h aws_secure_sockets.h aws_shadow.h aws_system_init.h aws_tls.h aws_wifi.h event_groups.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
    ../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_wrappers.h portable.h projdefs.h stack_macros.h aws_bufferpool.h aws_default_root_certificates.h aws_doubly_linked_list.h aws_ggd_config_defaults.h aws_helper_secure_connect.h aws_lib_init.h aws_mqtt_agent_config_defaults.h aws_mqtt_buffer.h aws_mqtt_config_defaults.h aws_secure_sockets_config_defaults.h aws_shadow_config_defaults.h aws_shadow_json.h deprecated_definitions.h list.h mpu_wrappers.h portable.h projdefs.h stack_macros.h
  group amazon-freertos-FreeRTOS
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group mbedtls-mbedtls_include
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls-mbedtls_source
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c chacha20.c chachapoly.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls-mbedtls_port
    ../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c
  group amazon-freertos-mqtt
    ../../../../../rtos/amazon-freertos/lib/mqtt/: aws_mqtt_agent.c aws_mqtt_lib.c
  group amazon-freertos-tls
    ../../../../../rtos/amazon-freertos/lib/tls/: aws_tls.c
  group amazon-freertos-bufferpool
    ../../../../../rtos/amazon-freertos/lib/bufferpool/: aws_bufferpool_static_thread_safe.c
  group amazon-freertos-crypto
    ../../../../../rtos/amazon-freertos/lib/crypto/: aws_crypto.c
  group amazon-freertos-third_party-pkcs11
    ../../../../../rtos/amazon-freertos/lib/third_party/pkcs11/: pkcs11.h pkcs11f.h pkcs11t.h
  group amazon-freertos-utils
    ../../../../../rtos/amazon-freertos/lib/utils/: aws_system_init.c
  group amazon-freertos-third_party-jsmn
    ../../../../../rtos/amazon-freertos/lib/third_party/jsmn/: jsmn.c jsmn.h
  group amazon-freertos-shadow
    ../../../../../rtos/amazon-freertos/lib/shadow/: aws_shadow.c aws_shadow_json.c
  group amazon-freertos-secure_sockets
    ../../../../../rtos/amazon-freertos/lib/secure_sockets/portable/nxp/wifi_qca/: aws_secure_sockets.c
  group amazon-freertos-wifi
    ../../../../../rtos/amazon-freertos/lib/wifi/portable/nxp/common/: aws_wifi.c
  group common-tests-crypto
    ../../../../../rtos/amazon-freertos/tests/common/crypto/: aws_test_crypto.c
  group common-tests-framework
    ../../../../../rtos/amazon-freertos/tests/common/framework/: aws_test_framework.c
  group common-tests-greengrass
    ../../../../../rtos/amazon-freertos/tests/common/greengrass/: aws_test_greengrass_discovery.c aws_test_helper_secure_connect.c
  group common-tests-include
    ../../../../../rtos/amazon-freertos/tests/common/include/: aws_application_version.h aws_clientcredential.h aws_clientcredential_keys.h aws_dev_mode_key_provisioning.h aws_greengrass_discovery_test_access_declare.h aws_greengrass_discovery_test_access_define.h aws_logging_task.h aws_mqtt_lib_test_access_declare.h aws_mqtt_lib_test_access_define.h aws_test_framework.h aws_test_runner.h aws_test_tcp.h aws_test_tls.h
    ../../../../../rtos/amazon-freertos/lib/include/: aws_appversion32.h
  group common-tests-memory_leak
    ../../../../../rtos/amazon-freertos/tests/common/memory_leak/: aws_memory_leak.c
  group common-tests-mqtt
    ../../../../../rtos/amazon-freertos/tests/common/mqtt/: aws_test_mqtt_agent.c aws_test_mqtt_lib.c
  group common-tests-pkcs11
    ../../../../../rtos/amazon-freertos/tests/common/pkcs11/: aws_test_pkcs11.c
  group common-tests-secure_sockets
    ../../../../../rtos/amazon-freertos/tests/common/secure_sockets/: aws_test_tcp.c
  group common-tests-shadow
    ../../../../../rtos/amazon-freertos/tests/common/shadow/: aws_test_shadow.c
  group common-tests-test_runner
    ../../../../../rtos/amazon-freertos/tests/common/test_runner/: aws_test_runner.c
  group common-tests-tls
    ../../../../../rtos/amazon-freertos/tests/common/tls/: aws_test_tls.c
  group common-tests-wifi
    ../../../../../rtos/amazon-freertos/tests/common/wifi/: aws_test_wifi.c
  group unity
    ../../../../../rtos/amazon-freertos/lib/third_party/unity/src/: unity.c unity.h unity_internals.h
    ../../../../../rtos/amazon-freertos/lib/third_party/unity/extras/fixture/src/: unity_fixture.c unity_fixture.h unity_fixture_internals.h unity_fixture_malloc_overrides.h
  group amazon-freertos-devmode_key_provisioning
    ../../../../../rtos/amazon-freertos/demos/common/devmode_key_provisioning/: aws_dev_mode_key_provisioning.c
  group amazon-freertos-logging
    ../../../../../rtos/amazon-freertos/demos/common/logging/: aws_logging_task_dynamic_buffers.c
  group amazon-freertos-greengrass
    ../../../../../rtos/amazon-freertos/lib/greengrass/: aws_greengrass_discovery.c aws_helper_secure_connect.c
  group device
    ../../../../../devices/MIMXRT1052/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.c system_MIMXRT1052.h
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1052/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: uart.h lpuart_adapter.c
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: generic_list.h generic_list.c
  group startup
    ../../../../../devices/MIMXRT1052/arm/: startup_MIMXRT1052.s
  group xip
    ../../../../../devices/MIMXRT1052/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
  group wifi_qca-port-shields
    ../../../../../middleware/wifi_qca/port/boards/evkbimxrt1050/freertos/: wifi_shield.h wifi_shield.c
  group wifi_qca-port-env-freertos
    ../../../../../middleware/wifi_qca/port/env/freertos/: wifi_port.h wifi_env_port.h wifi_env.c wifi_env.h
  group wifi_qca-port-drivers-lpspi_edma_freertos
    ../../../../../middleware/wifi_qca/port/drivers/lpspi_edma_freertos/: wifi_spi.h wifi_spi.c
target aws_tests flexspi_nor_release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: aws_tests.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1052DVL6B, USE_RTOS=1, MBEDTLS_CONFIG_FILE='\"aws_mbedtls_config.h\"', A_LITTLE_ENDIAN, FSL_RTOS_FREE_RTOS, AMAZON_FREERTOS_ENABLE_UNIT_TESTS=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../../..;..;../config_files
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: as above
