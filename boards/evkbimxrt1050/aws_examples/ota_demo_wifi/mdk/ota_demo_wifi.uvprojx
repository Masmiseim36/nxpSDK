# Keil uVision project ota_demo_wifi.uvprojx, settings and files
target ota_demo_wifi flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ota_demo_wifi.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1052DVL6B, USE_RTOS=1, MBEDTLS_CONFIG_FILE='\"aws_mbedtls_config.h\"', MFLASH_FILE_BASEADDR=64487424, SDK_OS_FREE_RTOS, SDIO_ENABLED, SERIAL_PORT_TYPE_UART=1, MQTT_AGENT_DO_NOT_USE_CUSTOM_CONFIG, MCUXPRESSO_SDK
  c misc: -include ../app_config.h -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../config_files;../../common;../bootutil_port;../bootutil_port/mcuboot_config;../bootutil_port/sysflash;../bootutil_port/board_specific;../../..;../../../../../devices/MIMXRT1052/drivers;../../../../../components/flash/mflash;../../../../../components/flash/mflash/mimxrt1052;../../../../../middleware/mbedtls/include;../../../../../middleware/mbedtls/library;../../../../../middleware/mbedtls/port/ksdk;../../../../../middleware/wifi_nxp/incl;../../../../../middleware/wifi_nxp/incl/port/os;../../../../../middleware/wifi_nxp/incl/wifidriver;../../../../../middleware/wifi_nxp/incl/wlcmgr;../../../../../middleware/wifi_nxp/wifi_bt_firmware;../../../../../middleware/wifi_nxp/wifidriver;../../../../../middleware/wifi_nxp/wifidriver/incl;../../../../../rtos/freertos/freertos-kernel/include;../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F;../../../../../devices/MIMXRT1052/utilities/str;../../../../../devices/MIMXRT1052/utilities/debug_console;../../../../../middleware/wifi_nxp;../../../../../middleware/sdmmc/sdio;../../../../../middleware/sdmmc/common;../../../../../middleware/sdmmc/host/usdhc;../../../../../components/gpio;../../../../../middleware/aws_iot/amazon-freertos/demos/include;../../../../../middleware/aws_iot/amazon-freertos/demos/dev_mode_key_provisioning/include;../../../../../middleware/aws_iot/ota/source/include;../../../../../middleware/aws_iot/amazon-freertos/vendors/nxp/ota;../../../../../middleware/lwip/port;../../../../../middleware/lwip/src;../../../../../middleware/lwip/src/include;../../../../../middleware/wifi_nxp/dhcpd;../../../../../middleware/wifi_nxp/incl/port/lwip;../../../../../middleware/wifi_nxp/port/lwip;../../../../../middleware/aws_iot/amazon-freertos/libraries/abstractions/transport/secure_sockets;../../../../../middleware/aws_iot/amazon-freertos/libraries/abstractions/secure_sockets/include;../../../../../middleware/aws_iot/amazon-freertos/libraries/logging/include;../../../../../rtos/freertos/coremqtt/source/include;../../../../../rtos/freertos/coremqtt/source/interface;../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits;../../../../../components/wifi_bt_module/Murata/tx_pwr_limits;../../../../../middleware/pkcs11;../../../../../rtos/freertos/corepkcs11/source/include;../../../../../devices/MIMXRT1052;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../devices/MIMXRT1052/xip;../../../xip;../../../../../CMSIS/Core/Include;../../../../../middleware/sdmmc/osa;../../../../../components/osa;../../../../../middleware/aws_iot/amazon-freertos/libraries/abstractions/platform/freertos/include/platform;../../../../../middleware/aws_iot/amazon-freertos/libraries/abstractions/platform/include/platform;../../../../../middleware/aws_iot/amazon-freertos/libraries/abstractions/platform/include/types;../../../../../middleware/aws_iot/amazon-freertos/libraries/abstractions/platform/freertos/include;../../../../../middleware/aws_iot/amazon-freertos/libraries/abstractions/platform/include;../../../../../middleware/aws_iot/amazon-freertos/libraries/c_sdk/standard/common/include;../../../../../middleware/aws_iot/amazon-freertos/libraries/c_sdk/standard/common/include/private;../../../../../middleware/aws_iot/amazon-freertos/libraries/c_sdk/standard/common/include/types;../../../../../middleware/aws_iot/amazon-freertos/demos/network_manager;../../../../../rtos/freertos/corejson/source/include;../../../../../middleware/tinycbor/src;../../../../../rtos/freertos/backoffalgorithm/source/include;../../../../../middleware/aws_iot/amazon-freertos/libraries/abstractions/mqtt_agent/include;../../../../../rtos/freertos/coremqtt-agent/source/include;../../../../../middleware/aws_iot/ota/source/portable/os;../../../../../middleware/aws_iot/amazon-freertos/demos/common/pkcs11_helpers;../../../../../middleware/aws_iot/amazon-freertos/demos/common/mqtt_subscription_manager;../../../../../middleware/aws_iot/amazon-freertos/libraries/freertos_plus/standard/tls/include;../../../../../middleware/aws_iot/amazon-freertos/libraries/3rdparty/mbedtls_utils;../../../../../middleware/aws_iot/amazon-freertos/libraries/freertos_plus/standard/crypto/include;../../../../../middleware/aws_iot/amazon-freertos/libraries/freertos_plus/standard/utils/include;../../../../../middleware/aws_iot/amazon-freertos/libraries/abstractions/wifi/include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../config_files;../../..
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ../linker/MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: --remove --entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-D__stack_size__=0x400" --predefine="-D__heap_size__=0x200"
  group board
    ../: sdmmc_config.c sdmmc_config.h wifi_bt_config.c wifi_bt_config.h pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group config_files
    ../config_files/: FreeRTOSConfig.h aws_demo_config.h aws_wifi_config.h core_http_config.h core_mqtt_config.h core_pkcs11_config.h FreeRTOSIPConfig.h iot_config.h iot_secure_sockets_config.h ota_config.h ota_demo_config.h aws_iot_network_config.h
  group source
    ../config_files/: aws_mbedtls_config.h
    ../: main_wifi.c lwipopts.h mcuboot_app_support.c mcuboot_app_support.h app_config.h wifi_config.h
  group bootutil_port/board_specific
    ../bootutil_port/board_specific/: flash_partitioning.h flash_partitioning.c sblconfig.h
  group bootutil_port/mcuboot_config
    ../bootutil_port/mcuboot_config/: mcuboot_config.h mcuboot_logging.h
  group bootutil_port
    ../bootutil_port/: flash_map.h sbldef.h
  group bootutil_port/sysflash
    ../bootutil_port/sysflash/: sysflash.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_cache.c fsl_cache.h fsl_flexspi.c fsl_flexspi.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_dcp.c fsl_dcp.h fsl_trng.c fsl_trng.h fsl_usdhc.c fsl_usdhc.h
  group flash/mflash
    ../../../../../components/flash/mflash/: mflash_file.h mflash_file.c mflash_common.h
  group flash/mflash/mimxrt1052
    ../../../../../components/flash/mflash/mimxrt1052/: mflash_drv.h mflash_drv.c
  group mbedtls/include/mbedtls
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h psa_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/include/psa
    ../../../../../middleware/mbedtls/include/psa/: crypto.h crypto_builtin_composites.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group mbedtls/library
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cmac.c common.h constant_time.c constant_time_internal.h constant_time_invasive.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_invasive.h entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c mps_common.h mps_error.h mps_reader.c mps_reader.h mps_trace.c mps_trace.h net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c ssl_tls13_keys.h threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/port/ksdk
    ../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c ccm_alt.h ecp_alt.h ecp_alt.c ecp_curves_alt.c ecp_alt_ksdk.c threading_alt.h
  group wifi/incl
    ../../../../../middleware/wifi_nxp/incl/: dhcp-server.h WIFI_IW416_BOARD_AW_AM457_CAL_DATA_EXT.h wmstats.h wm_utils.h wmerrno.h wmlog.h wmtypes.h
  group wifi/incl/wlcmgr
    ../../../../../middleware/wifi_nxp/incl/wlcmgr/: wlan.h wlan_11d.h
  group wifi/wifidriver/incl
    ../../../../../middleware/wifi_nxp/wifidriver/incl/: mlan.h mlan_11ac.h mlan_11ax.h mlan_11h.h mlan_11n.h mlan_11n_aggr.h mlan_11n_rxreorder.h mlan_api.h mlan_fw.h mlan_ieee.h mlan_init.h mlan_join.h mlan_main.h mlan_meas.h mlan_remap_mem_operations.h mlan_uap.h mlan_util.h mlan_wmm.h mlan_main_defs.h type_decls.h mlan_sdio_defs.h mlan_sdio.h mlan_decl.h mlan_ioctl.h
  group wifi/wifidriver
    ../../../../../middleware/wifi_nxp/wifidriver/: mlan_11ac.c mlan_11ax.c mlan_11d.c mlan_11h.c mlan_11n.c mlan_11n_aggr.c mlan_11n_rxreorder.c mlan_api.c mlan_cfp.c mlan_cmdevt.c mlan_glue.c mlan_init.c mlan_join.c mlan_misc.c mlan_scan.c mlan_shim.c mlan_sta_cmd.c mlan_sta_cmdresp.c mlan_sta_event.c mlan_sta_ioctl.c mlan_sta_rx.c mlan_txrx.c mlan_uap_cmdevent.c mlan_uap_ioctl.c mlan_wmm.c wifi-debug.c wifi-debug.h wifi-internal.h wifi-mem.c wifi-uap.c wifi.c wifi_common.h wifi_pwrmgr.c wifi-sdio.c sdio.c sdio.h firmware_dnld.c firmware_dnld.h mlan_sdio.c wifi-sdio.h
  group freertos/freertos-kernel
    ../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable/GCC/ARM_CM4F
    ../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable
    ../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1052/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c
  group wifi/wifi_bt_firmware
    ../../../../../middleware/wifi_nxp/wifi_bt_firmware/: sd8801_wlan.h sduartIW416_wlan_bt.h sduart8987_wlan_bt.h wlan_bt_fw.h
  group sdmmc/src
    ../../../../../middleware/sdmmc/sdio/: fsl_sdio.c
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc/sdio/: fsl_sdio.h
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sdio
    ../../../../../middleware/sdmmc/sdio/: ChangeLogKSDK.txt
  group sdmmc/host
    ../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt
    ../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group component/gpio
    ../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group aws_iot/amazon-freertos/demos/demo_runner
    ../../../../../middleware/aws_iot/amazon-freertos/demos/demo_runner/: aws_demo.c iot_demo_freertos.c
  group aws_iot/amazon-freertos/demos/include
    ../../../../../middleware/aws_iot/amazon-freertos/demos/include/: aws_clientcredential.h aws_clientcredential_keys.h aws_demo.h aws_iot_metrics.h iot_config_common.h iot_demo_logging.h iot_demo_runner.h aws_wifi_connect_task.h
  group aws_iot/amazon-freertos/demos/dev_mode_key_provisioning/include
    ../../../../../middleware/aws_iot/amazon-freertos/demos/dev_mode_key_provisioning/include/: aws_dev_mode_key_provisioning.h
  group aws_iot/amazon-freertos/demos/dev_mode_key_provisioning/src
    ../../../../../middleware/aws_iot/amazon-freertos/demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c
  group aws_iot/amazon-freertos/demos/ota/ota_demo_core_mqtt
    ../../../../../middleware/aws_iot/amazon-freertos/demos/ota/ota_demo_core_mqtt/: ota_demo_core_mqtt.c
  group aws_iot/ota/source
    ../../../../../middleware/aws_iot/ota/source/: ota.c ota_base64.c ota_cbor.c ota_http.c ota_interface.c ota_mqtt.c
  group aws_iot/ota/source/include
    ../../../../../middleware/aws_iot/ota/source/include/: ota.h ota_appversion32.h ota_base64_private.h ota_cbor_private.h ota_config_defaults.h ota_http_interface.h ota_http_private.h ota_interface_private.h ota_mqtt_interface.h ota_mqtt_private.h ota_os_interface.h ota_platform_interface.h ota_private.h stdbool.readme stdint.readme
  group aws_iot/amazon-freertos/vendors/nxp/secure_sockets/lwip
    ../../../../../middleware/aws_iot/amazon-freertos/vendors/nxp/secure_sockets/lwip/: iot_secure_sockets.c
  group aws_iot/amazon-freertos/vendors/nxp/wifi/nxp
    ../../../../../middleware/aws_iot/amazon-freertos/vendors/nxp/wifi/nxp/: iot_wifi.c
  group aws_iot/amazon-freertos/vendors/nxp/ota
    ../../../../../middleware/aws_iot/amazon-freertos/vendors/nxp/ota/: ota_pal.c ota_pal.h
  group lwip/port
    ../../../../../middleware/lwip/port/: sys_arch.c
  group lwip/port/arch
    ../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src/api
    ../../../../../middleware/lwip/src/api/: sockets.c netifapi.c netdb.c netbuf.c tcpip.c api_msg.c err.c if_api.c api_lib.c
  group lwip/src/core
    ../../../../../middleware/lwip/src/core/: memp.c def.c ip.c pbuf.c altcp.c tcp_out.c raw.c altcp_tcp.c sys.c init.c inet_chksum.c timeouts.c tcp_in.c netif.c mem.c udp.c tcp.c stats.c dns.c altcp_alloc.c
  group lwip/src/core/ipv6
    ../../../../../middleware/lwip/src/core/ipv6/: ethip6.c dhcp6.c ip6_addr.c nd6.c mld6.c icmp6.c ip6_frag.c ip6.c inet6.c
  group lwip/src/core/ipv4
    ../../../../../middleware/lwip/src/core/ipv4/: dhcp.c ip4.c autoip.c icmp.c acd.c etharp.c ip4_addr.c igmp.c ip4_frag.c
  group lwip/src/include/compat/stdc
    ../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/compat/posix
    ../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/sys
    ../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/posix/net
    ../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/lwip
    ../../../../../middleware/lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/priv
    ../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h mem_priv.h memp_priv.h memp_std.h api_msg.h nd6_priv.h tcpip_priv.h tcp_priv.h raw_priv.h sockets_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../middleware/lwip/src/include/lwip/prot/: ip6.h udp.h mld6.h ip4.h icmp.h igmp.h dhcp.h tcp.h autoip.h iana.h ieee.h dns.h icmp6.h ethernet.h nd6.h ip.h acd.h dhcp6.h etharp.h
  group lwip/src/include/netif
    ../../../../../middleware/lwip/src/include/netif/: bridgeif.h zepif.h lowpan6.h ieee802154.h ethernet.h lowpan6_common.h lowpan6_opts.h bridgeif_opts.h slipif.h lowpan6_ble.h etharp.h
  group lwip/src/include/netif/ppp
    ../../../../../middleware/lwip/src/include/netif/ppp/: ipv6cp.h pppapi.h magic.h ppp.h upap.h mppe.h pppol2tp.h pppoe.h ipcp.h pppdebug.h eap.h pppos.h ppp_opts.h pppcrypt.h vj.h chap-new.h eui64.h chap_ms.h ccp.h ecp.h lcp.h fsm.h ppp_impl.h chap-md5.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: sha1.h des.h md5.h md4.h arc4.h
  group lwip/src/netif
    ../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group wifi/dhcpd
    ../../../../../middleware/wifi_nxp/dhcpd/: dhcp-bootp.h dhcp-priv.h dhcp-server-main.c dhcp-server.c dns-server.c dns.h
  group wifi/incl/port/lwip
    ../../../../../middleware/wifi_nxp/incl/port/lwip/: wm_net.h
  group wifi/port/lwip
    ../../../../../middleware/wifi_nxp/port/lwip/: net.c netif_decl.h wifi_netif.c
  group wifi/wlcmgr
    ../../../../../middleware/wifi_nxp/wlcmgr/: wlan.c wlan_txpwrlimit_cfg.c
  group aws_iot/amazon-freertos/libraries/abstractions/transport/secure_sockets
    ../../../../../middleware/aws_iot/amazon-freertos/libraries/abstractions/transport/secure_sockets/: transport_secure_sockets.c transport_secure_sockets.h
  group aws_iot/amazon-freertos/libraries/abstractions/secure_sockets/include
    ../../../../../middleware/aws_iot/amazon-freertos/libraries/abstractions/secure_sockets/include/: iot_secure_sockets.h iot_secure_sockets_config_defaults.h
  group aws_iot/amazon-freertos/libraries/logging/include
    ../../../../../middleware/aws_iot/amazon-freertos/libraries/logging/include/: iot_logging_task.h logging_levels.h logging_stack.h
  group aws_iot/amazon-freertos/libraries/logging
    ../../../../../middleware/aws_iot/amazon-freertos/libraries/logging/: iot_logging.c iot_logging_task_dynamic_buffers.c README.md
  group freertos/coremqtt/source
    ../../../../../rtos/freertos/coremqtt/source/: core_mqtt.c core_mqtt_serializer.c core_mqtt_state.c
  group freertos/coremqtt/source/include
    ../../../../../rtos/freertos/coremqtt/source/include/: core_mqtt.h core_mqtt_config_defaults.h core_mqtt_default_logging.h core_mqtt_serializer.h core_mqtt_state.h
  group freertos/coremqtt/source/interface
    ../../../../../rtos/freertos/coremqtt/source/interface/: transport_interface.h
  group component/wifi_bt_module/AzureWave/tx_pwr_limits
    ../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits/: wlan_txpwrlimit_cfg_WW.h wlan_txpwrlimit_cfg_WW_rw610.h
  group component/wifi_bt_module/Murata/tx_pwr_limits
    ../../../../../components/wifi_bt_module/Murata/tx_pwr_limits/: wlan_txpwrlimit_cfg_murata_1XK_CA.h wlan_txpwrlimit_cfg_murata_1XK_EU.h wlan_txpwrlimit_cfg_murata_1XK_JP.h wlan_txpwrlimit_cfg_murata_1XK_US.h wlan_txpwrlimit_cfg_murata_1XK_WW.h wlan_txpwrlimit_cfg_murata_1ZM_CA.h wlan_txpwrlimit_cfg_murata_1ZM_EU.h wlan_txpwrlimit_cfg_murata_1ZM_JP.h wlan_txpwrlimit_cfg_murata_1ZM_US.h wlan_txpwrlimit_cfg_murata_1ZM_WW.h wlan_txpwrlimit_cfg_murata_2DS_CA.h wlan_txpwrlimit_cfg_murata_2DS_EU.h wlan_txpwrlimit_cfg_murata_2DS_JP.h wlan_txpwrlimit_cfg_murata_2DS_US.h wlan_txpwrlimit_cfg_murata_2DS_WW.h
  group pkcs11
    ../../../../../middleware/pkcs11/: README.md pkcs11t.h pkcs11f.h pkcs11.h LICENSE.md CONTRIBUTING.md
  group freertos/corepkcs11/source
    ../../../../../rtos/freertos/corepkcs11/source/: core_pkcs11.c core_pki_utils.c
  group freertos/corepkcs11/source/include
    ../../../../../rtos/freertos/corepkcs11/source/include/: core_pkcs11.h core_pkcs11_config_defaults.h core_pkcs11_pal.h core_pki_utils.h
  group freertos/corepkcs11/source/portable/mbedtls
    ../../../../../rtos/freertos/corepkcs11/source/portable/mbedtls/: core_pkcs11_mbedtls.c
  group aws_iot/amazon-freertos/vendors/nxp/pkcs11
    ../../../../../middleware/aws_iot/amazon-freertos/vendors/nxp/pkcs11/: iot_pkcs11_pal.c
  group device
    ../../../../../devices/MIMXRT1052/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.c system_MIMXRT1052.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1052/arm/: startup_MIMXRT1052.S
  group xip
    ../../../../../devices/MIMXRT1052/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
  group wifi/incl/wifidriver
    ../../../../../middleware/wifi_nxp/incl/wifidriver/: mlan_sdio_api.h wifi-decl.h wifi.h wifi_events.h
  group sdmmc/osa
    ../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c
  group wifi/incl/port/os
    ../../../../../middleware/wifi_nxp/incl/port/os/: wm_os.h
  group wifi/port/os
    ../../../../../middleware/wifi_nxp/port/os/: os.c
  group aws_iot/amazon-freertos/libraries/abstractions/platform/freertos/include/platform
    ../../../../../middleware/aws_iot/amazon-freertos/libraries/abstractions/platform/freertos/include/platform/: iot_platform_types_freertos.h
  group aws_iot/amazon-freertos/libraries/abstractions/platform/freertos
    ../../../../../middleware/aws_iot/amazon-freertos/libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_threads_freertos.c
  group aws_iot/amazon-freertos/libraries/abstractions/platform/include/platform
    ../../../../../middleware/aws_iot/amazon-freertos/libraries/abstractions/platform/include/platform/: iot_clock.h iot_network.h iot_threads.h
  group aws_iot/amazon-freertos/libraries/abstractions/platform/include/types
    ../../../../../middleware/aws_iot/amazon-freertos/libraries/abstractions/platform/include/types/: iot_network_types.h iot_platform_types.h
  group aws_iot/amazon-freertos/libraries/c_sdk/standard/common
    ../../../../../middleware/aws_iot/amazon-freertos/libraries/c_sdk/standard/common/: iot_device_metrics.c iot_init.c iot_static_memory_common.c
  group aws_iot/amazon-freertos/libraries/c_sdk/standard/common/taskpool
    ../../../../../middleware/aws_iot/amazon-freertos/libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group aws_iot/amazon-freertos/libraries/c_sdk/standard/common/include
    ../../../../../middleware/aws_iot/amazon-freertos/libraries/c_sdk/standard/common/include/: iot_atomic.h iot_init.h iot_linear_containers.h iot_logging_setup.h iot_taskpool.h
  group aws_iot/amazon-freertos/libraries/c_sdk/standard/common/include/private
    ../../../../../middleware/aws_iot/amazon-freertos/libraries/c_sdk/standard/common/include/private/: iot_default_root_certificates.h iot_doubly_linked_list.h iot_error.h iot_lib_init.h iot_logging.h iot_static_memory.h iot_taskpool_internal.h
  group aws_iot/amazon-freertos/libraries/c_sdk/standard/common/include/types
    ../../../../../middleware/aws_iot/amazon-freertos/libraries/c_sdk/standard/common/include/types/: iot_taskpool_types.h
  group aws_iot/amazon-freertos/demos/network_manager
    ../../../../../middleware/aws_iot/amazon-freertos/demos/network_manager/: aws_iot_network_manager.c iot_network_manager_private.h
  group aws_iot/amazon-freertos/demos/common/ota_demo_helpers
    ../../../../../middleware/aws_iot/amazon-freertos/demos/common/ota_demo_helpers/: ota_application_version.c
  group freertos/corejson/source
    ../../../../../rtos/freertos/corejson/source/: core_json.c
  group freertos/corejson/source/include
    ../../../../../rtos/freertos/corejson/source/include/: core_json.h
  group tinycbor/src
    ../../../../../middleware/tinycbor/src/: cbor.h cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborinternal_p.h cborparser.c cborparser_dup_string.c cborpretty.c cborvalidation.c compilersupport_p.h tinycbor-version.h utf8_p.h
  group freertos/backoffalgorithm/source
    ../../../../../rtos/freertos/backoffalgorithm/source/: backoff_algorithm.c
  group freertos/backoffalgorithm/source/include
    ../../../../../rtos/freertos/backoffalgorithm/source/include/: backoff_algorithm.h
  group aws_iot/amazon-freertos/libraries/abstractions/mqtt_agent
    ../../../../../middleware/aws_iot/amazon-freertos/libraries/abstractions/mqtt_agent/: freertos_agent_message.c freertos_command_pool.c mqtt_agent_interface.cmake
  group aws_iot/amazon-freertos/libraries/abstractions/mqtt_agent/include
    ../../../../../middleware/aws_iot/amazon-freertos/libraries/abstractions/mqtt_agent/include/: freertos_agent_message.h freertos_command_pool.h
  group freertos/coremqtt-agent/source/include
    ../../../../../rtos/freertos/coremqtt-agent/source/include/: core_mqtt_agent.h core_mqtt_agent_command_functions.h core_mqtt_agent_config_defaults.h core_mqtt_agent_default_logging.h core_mqtt_agent_message_interface.h
  group freertos/coremqtt-agent/source
    ../../../../../rtos/freertos/coremqtt-agent/source/: core_mqtt_agent_command_functions.c core_mqtt_agent.c
  group aws_iot/ota/source/portable/os
    ../../../../../middleware/aws_iot/ota/source/portable/os/: ota_os_freertos.c ota_os_freertos.h
  group aws_iot/amazon-freertos/demos/common/pkcs11_helpers
    ../../../../../middleware/aws_iot/amazon-freertos/demos/common/pkcs11_helpers/: pkcs11_helpers.c pkcs11_helpers.h
  group aws_iot/amazon-freertos/demos/common/mqtt_subscription_manager
    ../../../../../middleware/aws_iot/amazon-freertos/demos/common/mqtt_subscription_manager/: mqtt_subscription_manager.c mqtt_subscription_manager.h
  group aws_iot/amazon-freertos/libraries/freertos_plus/standard/tls/include
    ../../../../../middleware/aws_iot/amazon-freertos/libraries/freertos_plus/standard/tls/include/: iot_tls.h
  group aws_iot/amazon-freertos/libraries/freertos_plus/standard/tls/src
    ../../../../../middleware/aws_iot/amazon-freertos/libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group aws_iot/amazon-freertos/libraries/3rdparty/mbedtls_utils
    ../../../../../middleware/aws_iot/amazon-freertos/libraries/3rdparty/mbedtls_utils/: mbedtls_error.c mbedtls_error.h mbedtls_utils.c README.md
  group aws_iot/amazon-freertos/libraries/freertos_plus/standard/crypto/include
    ../../../../../middleware/aws_iot/amazon-freertos/libraries/freertos_plus/standard/crypto/include/: iot_crypto.h
  group aws_iot/amazon-freertos/libraries/freertos_plus/standard/crypto/src
    ../../../../../middleware/aws_iot/amazon-freertos/libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group aws_iot/amazon-freertos/libraries/freertos_plus/standard/utils/include
    ../../../../../middleware/aws_iot/amazon-freertos/libraries/freertos_plus/standard/utils/include/: iot_system_init.h
  group aws_iot/amazon-freertos/libraries/freertos_plus/standard/utils/src
    ../../../../../middleware/aws_iot/amazon-freertos/libraries/freertos_plus/standard/utils/src/: iot_system_init.c
  group aws_iot/amazon-freertos/libraries/abstractions/wifi/include
    ../../../../../middleware/aws_iot/amazon-freertos/libraries/abstractions/wifi/include/: iot_softap_wifi_provisioning.h iot_wifi.h
target ota_demo_wifi flexspi_nor_release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ota_demo_wifi.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1052DVL6B, USE_RTOS=1, MBEDTLS_CONFIG_FILE='\"aws_mbedtls_config.h\"', MFLASH_FILE_BASEADDR=64487424, SDK_OS_FREE_RTOS, SDIO_ENABLED, SERIAL_PORT_TYPE_UART=1, MQTT_AGENT_DO_NOT_USE_CUSTOM_CONFIG, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../config_files;../../..
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ../linker/MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: as above
