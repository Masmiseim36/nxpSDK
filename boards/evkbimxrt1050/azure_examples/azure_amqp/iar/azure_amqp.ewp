# IAR project azure_amqp.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; XIP_BOOT_HEADER_DCD_ENABLE=1; DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; _DLIB_TIME_USES_64=0; CPU_MIMXRT1052DVL6B; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SDK_DEBUGCONSOLE_UART; SDK_DEBUGCONSOLE=0; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; USE_RTOS=1; LWIP_DNS=1; LWIP_DHCP=1; LWIP_NETIF_LINK_CALLBACK=1; LWIP_NETIF_STATUS_CALLBACK=1; MBEDTLS_CONFIG_FILE="azure_mbedtls_config.h"; LWIP_DISABLE_PBUF_POOL_SIZE_SANITY_CHECKS=1; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe1215,Pe191,Pe188,Pe177,Pe767
  ICCARM.IExtraOptions: --diag_suppress Pa167,Pe177,Pe546
  ICCARM.CCIncludePath2: ..; ../../../../../components/phy/mdio/enet; ../../../../../components/phy/device/phyksz8081; ../../../../../devices/MIMXRT1052/drivers; ../../../../../middleware/mbedtls/include; ../../../../../middleware/mbedtls/library; ../../../../../middleware/mbedtls/port/ksdk; ../../../../../middleware/lwip/src/include/lwip/apps; ../../../../../middleware/lwip/port; ../../../../../middleware/lwip/src; ../../../../../middleware/lwip/src/include; ../../../../../devices/MIMXRT1052/utilities/str; ../../../../../devices/MIMXRT1052/utilities/debug_console; ../../../../../components/phy; ../../../../../middleware/azure_iot/iothub_client/inc; ../../../../../middleware/azure_iot/iothub_client/inc/internal; ../../../../../devices/MIMXRT1052; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../devices/MIMXRT1052/xip; ../../../xip; ../../../../../CMSIS/Core/Include; ../../../../../rtos/freertos/freertos_kernel/include; ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F; ../../../../../middleware/azure_iot/c-utility/inc; ../../../../../middleware/azure_iot/uamqp/inc; ../../../../../middleware/azure_iot/c-utility/pal/generic; ../../../../../middleware/azure_iot/c-utility/pal/inc; ../../../../../middleware/azure_iot/c-utility/pal/lwip; ../../../../../middleware/azure_iot/certs; ../../../../../middleware/azure_iot/deps/parson; ../../../../../middleware/azure_iot/deps/umock-c/inc; ../../../../../middleware/azure_iot/deps/azure-macro-utils-c/inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: azure_amqp.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2048; __heap_size__=0x20000; __ram_vector_table__=1
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor_sdram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; DEBUG; _DLIB_TIME_USES_64=0; CPU_MIMXRT1052DVL6B; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SDK_DEBUGCONSOLE_UART; SDK_DEBUGCONSOLE=0; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; USE_RTOS=1; LWIP_DNS=1; LWIP_DHCP=1; LWIP_NETIF_LINK_CALLBACK=1; LWIP_NETIF_STATUS_CALLBACK=1; MBEDTLS_CONFIG_FILE="azure_mbedtls_config.h"; LWIP_DISABLE_PBUF_POOL_SIZE_SANITY_CHECKS=1; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; MCUXPRESSO_SDK
  ILINK.IlinkIcfFile: evkbimxrt1050_lwip_mbedTLS_freertos.icf
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; XIP_BOOT_HEADER_DCD_ENABLE=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; _DLIB_TIME_USES_64=0; CPU_MIMXRT1052DVL6B; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SDK_DEBUGCONSOLE_UART; SDK_DEBUGCONSOLE=0; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; USE_RTOS=1; LWIP_DNS=1; LWIP_DHCP=1; LWIP_NETIF_LINK_CALLBACK=1; LWIP_NETIF_STATUS_CALLBACK=1; MBEDTLS_CONFIG_FILE="azure_mbedtls_config.h"; LWIP_DISABLE_PBUF_POOL_SIZE_SANITY_CHECKS=1; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; _DLIB_TIME_USES_64=0; CPU_MIMXRT1052DVL6B; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SDK_DEBUGCONSOLE_UART; SDK_DEBUGCONSOLE=0; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; USE_RTOS=1; LWIP_DNS=1; LWIP_DHCP=1; LWIP_NETIF_LINK_CALLBACK=1; LWIP_NETIF_STATUS_CALLBACK=1; MBEDTLS_CONFIG_FILE="azure_mbedtls_config.h"; LWIP_DISABLE_PBUF_POOL_SIZE_SANITY_CHECKS=1; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: evkbimxrt1050_lwip_mbedTLS_freertos.icf
  group source
    ../: azure_amqp.c azure_amqp.h lwipopts.h azure_mbedtls_config.h FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.txt
  group mdio
    ../../../../../components/phy/mdio/enet/: fsl_enet_mdio.h fsl_enet_mdio.c
    ../../../../../components/phy/: fsl_mdio.h
  group phy
    ../../../../../components/phy/device/phyksz8081/: fsl_phyksz8081.h fsl_phyksz8081.c
    ../../../../../components/phy/: fsl_phy.h
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_trng.c fsl_trng.h fsl_dcp.c fsl_dcp.h fsl_cache.c fsl_cache.h fsl_clock.h fsl_clock.c fsl_enet.h fsl_enet.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group mbedtls/include/mbedtls
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h config_psa.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h psa_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/include/psa
    ../../../../../middleware/mbedtls/include/psa/: crypto.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_extra.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group mbedtls/library
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c chacha20.c chachapoly.c check_crypto_config.h cmac.c common.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_client.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_service_integration.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_invasive.h ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c ssl_tls13_keys.h threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/port/ksdk
    ../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c ecp_alt.h ecp_alt.c ecp_curves_alt.c ecp_alt_ksdk.c threading_alt.h
  group freertos/freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_3.c ReadMe.url
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/include
    ../../../../../rtos/freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group lwip/src/include/lwip
    ../../../../../middleware/lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/apps
    ../../../../../middleware/lwip/src/include/lwip/apps/: sntp.h sntp_opts.h
  group lwip/src/include/lwip/priv
    ../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h mem_priv.h memp_priv.h memp_std.h api_msg.h nd6_priv.h tcpip_priv.h tcp_priv.h raw_priv.h sockets_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../middleware/lwip/src/include/lwip/prot/: ip6.h udp.h mld6.h ip4.h icmp.h igmp.h dhcp.h tcp.h autoip.h iana.h ieee.h dns.h icmp6.h ethernet.h nd6.h ip.h acd.h dhcp6.h etharp.h
  group lwip/src/include/compat/stdc
    ../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/compat/posix
    ../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/sys
    ../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/posix/net
    ../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/netif
    ../../../../../middleware/lwip/src/include/netif/: bridgeif.h zepif.h lowpan6.h ieee802154.h ethernet.h lowpan6_common.h lowpan6_opts.h bridgeif_opts.h slipif.h lowpan6_ble.h etharp.h
  group lwip/src/include/netif/ppp
    ../../../../../middleware/lwip/src/include/netif/ppp/: ipv6cp.h pppapi.h magic.h ppp.h upap.h mppe.h pppol2tp.h pppoe.h ipcp.h pppdebug.h eap.h pppos.h ppp_opts.h pppcrypt.h vj.h chap-new.h eui64.h chap_ms.h ccp.h ecp.h lcp.h fsm.h ppp_impl.h chap-md5.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: sha1.h des.h md5.h md4.h arc4.h
  group lwip/src/apps/sntp
    ../../../../../middleware/lwip/src/apps/sntp/: sntp.c
  group lwip/src/api
    ../../../../../middleware/lwip/src/api/: sockets.c netifapi.c netdb.c netbuf.c tcpip.c api_msg.c err.c if_api.c api_lib.c
  group lwip/src/core
    ../../../../../middleware/lwip/src/core/: memp.c def.c ip.c pbuf.c altcp.c tcp_out.c raw.c altcp_tcp.c sys.c init.c inet_chksum.c timeouts.c tcp_in.c netif.c mem.c udp.c tcp.c stats.c dns.c altcp_alloc.c
  group lwip/src/core/ipv6
    ../../../../../middleware/lwip/src/core/ipv6/: ethip6.c dhcp6.c ip6_addr.c nd6.c mld6.c icmp6.c ip6_frag.c ip6.c inet6.c
  group lwip/src/core/ipv4
    ../../../../../middleware/lwip/src/core/ipv4/: dhcp.c ip4.c autoip.c icmp.c acd.c etharp.c ip4_addr.c igmp.c ip4_frag.c
  group lwip/src/netif
    ../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lwip/port
    ../../../../../middleware/lwip/port/: sys_arch.c enet_ethernetif.c enet_ethernetif.h enet_ethernetif_priv.h enet_ethernetif_kinetis.c
  group lwip/port/arch
    ../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1052/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c
  group azure_iot/iothub_client/src
    ../../../../../middleware/azure_iot/iothub_client/src/: iothubtransportamqp.c iothubtransportamqp_methods.c iothubtransport_amqp_cbs_auth.c iothubtransport_amqp_common.c iothubtransport_amqp_connection.c iothubtransport_amqp_device.c iothubtransport_amqp_messenger.c iothubtransport_amqp_telemetry_messenger.c iothubtransport_amqp_twin_messenger.c uamqp_messaging.c iothub_client_retry_control.c iothub_transport_ll_private.c blob.c iothub.c iothub_client.c iothub_client_authorization.c iothub_client_core.c iothub_client_core_ll.c iothub_client_diagnostic.c iothub_client_ll.c iothub_client_ll_uploadtoblob.c iothub_message.c iothubtransport.c message_queue.c version_azure.c
  group azure_iot/iothub_client/inc
    ../../../../../middleware/azure_iot/iothub_client/inc/: iothubtransportamqp.h iothub.h iothub_client_core.h iothub_client_core_common.h iothub_client_core_ll.h iothub_device_client.h iothub_device_client_ll.h iothub_client_options.h iothub_client.h iothub_client_ll.h iothub_client_version.h iothub_message.h iothub_transport_ll.h
  group azure_iot/iothub_client/inc/internal
    ../../../../../middleware/azure_iot/iothub_client/inc/internal/: uamqp_messaging.h iothubtransportamqp_methods.h iothubtransport_amqp_cbs_auth.h iothubtransport_amqp_common.h iothubtransport_amqp_connection.h iothubtransport_amqp_device.h iothubtransport_amqp_messenger.h iothubtransport_amqp_telemetry_messenger.h iothubtransport_amqp_twin_messenger.h blob.h iothubtransport.h iothub_client_authorization.h iothub_client_diagnostic.h iothub_client_hsm_ll.h iothub_client_ll_uploadtoblob.h iothub_client_private.h iothub_client_retry_control.h iothub_transport_ll_private.h message_queue.h
  group azure_iot/c-utility/inc/azure_c_shared_utility
    ../../../../../middleware/azure_iot/c-utility/inc/azure_c_shared_utility/: agenttime.h azure_base32.h azure_base64.h buffer_.h condition.h connection_string_parser.h consolelogger.h const_defines.h constbuffer.h constmap.h crt_abstractions.h doublylinkedlist.h etwlogger.h etwlogger_driver.h gballoc.h gbnetwork.h hmac.h hmacsha256.h http_proxy_io.h httpapi.h httpapiex.h httpapiexsas.h httpheaders.h lock.h map.h optimize_size.h optionhandler.h platform.h refcount.h sastoken.h sha-private.h sha.h shared_util_options.h singlylinkedlist.h socketio.h stdint_ce6.h strings.h strings_types.h string_token.h string_tokenizer.h string_tokenizer_types.h threadapi.h tickcounter.h tlsio.h tlsio_options.h uniqueid.h urlencode.h uuid.h uws_client.h uws_frame_encoder.h vector.h vector_types.h vector_types_internal.h wsio.h xio.h xlogging.h tlsio_mbedtls.h
  group azure_iot/c-utility/src
    ../../../../../middleware/azure_iot/c-utility/src/: azure_base32.c azure_base64.c buffer.c connection_string_parser.c consolelogger.c constbuffer.c constmap.c crt_abstractions.c doublylinkedlist.c gballoc.c hmac_azure.c hmacsha256.c http_proxy_io.c httpapiex.c httpapiexsas.c httpheaders.c map.c optionhandler.c sastoken.c sha1_azure.c sha224.c sha384-512.c singlylinkedlist.c strings.c string_tokenizer.c string_token.c urlencode.c usha.c uuid.c vector.c xio.c xlogging.c
  group azure_iot/c-utility/adapters
    ../../../../../middleware/azure_iot/c-utility/adapters/: agenttime_msdk.c platform_msdk.c socketio_berkeley_msdk.c uniqueid_stub.c httpapi_compact.c tlsio_mbedtls.c
  group azure_iot/c-utility/pal
    ../../../../../middleware/azure_iot/c-utility/pal/: tlsio_options.c
  group azure_iot/c-utility/pal/generic
    ../../../../../middleware/azure_iot/c-utility/pal/generic/: refcount_os.h
  group azure_iot/c-utility/pal/inc
    ../../../../../middleware/azure_iot/c-utility/pal/inc/: sntp.h
  group azure_iot/c-utility/pal/lwip
    ../../../../../middleware/azure_iot/c-utility/pal/lwip/: sntp_lwip.c sntp_os.h
  group azure_iot/c-utility/pal/freertos
    ../../../../../middleware/azure_iot/c-utility/pal/freertos/: tickcounter.c threadapi.c lock.c
  group azure_iot/uamqp
    ../../../../../middleware/azure_iot/uamqp/: contribute.md LICENSE readme.md version.txt
  group azure_iot/uamqp/inc/azure_uamqp_c
    ../../../../../middleware/azure_iot/uamqp/inc/azure_uamqp_c/: amqpvalue.h amqpvalue_to_string.h amqp_definitions.h amqp_definitions_accepted.h amqp_definitions_address_string.h amqp_definitions_amqp_error.h amqp_definitions_amqp_sequence.h amqp_definitions_amqp_value.h amqp_definitions_annotations.h amqp_definitions_application_properties.h amqp_definitions_attach.h amqp_definitions_begin.h amqp_definitions_close.h amqp_definitions_connection_error.h amqp_definitions_data.h amqp_definitions_delivery_annotations.h amqp_definitions_delivery_number.h amqp_definitions_delivery_tag.h amqp_definitions_detach.h amqp_definitions_disposition.h amqp_definitions_end.h amqp_definitions_error.h amqp_definitions_fields.h amqp_definitions_filter_set.h amqp_definitions_flow.h amqp_definitions_footer.h amqp_definitions_handle.h amqp_definitions_header.h amqp_definitions_ietf_language_tag.h amqp_definitions_link_error.h amqp_definitions_message_annotations.h amqp_definitions_message_format.h amqp_definitions_message_id_binary.h amqp_definitions_message_id_string.h amqp_definitions_message_id_ulong.h amqp_definitions_message_id_uuid.h amqp_definitions_milliseconds.h amqp_definitions_modified.h amqp_definitions_node_properties.h amqp_definitions_open.h amqp_definitions_properties.h amqp_definitions_received.h amqp_definitions_receiver_settle_mode.h amqp_definitions_rejected.h amqp_definitions_released.h amqp_definitions_role.h amqp_definitions_sasl_challenge.h amqp_definitions_sasl_code.h amqp_definitions_sasl_init.h amqp_definitions_sasl_mechanisms.h amqp_definitions_sasl_outcome.h amqp_definitions_sasl_response.h amqp_definitions_seconds.h amqp_definitions_sender_settle_mode.h amqp_definitions_sequence_no.h amqp_definitions_session_error.h amqp_definitions_source.h amqp_definitions_target.h amqp_definitions_terminus_durability.h amqp_definitions_terminus_expiry_policy.h amqp_definitions_transfer.h amqp_definitions_transfer_number.h amqp_frame_codec.h amqp_management.h amqp_types.h async_operation.h cbs.h connection.h frame_codec.h header_detect_io.h link.h message.h message_receiver.h message_sender.h messaging.h saslclientio.h sasl_anonymous.h sasl_frame_codec.h sasl_mechanism.h sasl_mssbcbs.h sasl_plain.h sasl_server_io.h sasl_server_mechanism.h server_protocol_io.h session.h socket_listener.h uamqp.h
  group azure_iot/uamqp/src
    ../../../../../middleware/azure_iot/uamqp/src/: amqpvalue.c amqpvalue_to_string.c amqp_definitions.c amqp_frame_codec.c amqp_management.c async_operation.c cbs.c connection.c frame_codec.c header_detect_io.c link.c message.c message_receiver.c message_sender.c messaging.c saslclientio.c sasl_anonymous.c sasl_frame_codec.c sasl_mechanism.c sasl_mssbcbs.c sasl_plain.c sasl_server_mechanism.c session.c socket_listener_berkeley.c
  group azure_iot/certs
    ../../../../../middleware/azure_iot/certs/: certs_azure.c certs_azure.h
  group azure_iot/deps/parson
    ../../../../../middleware/azure_iot/deps/parson/: parson.h parson.c
  group azure_iot/deps/umock-c/inc/umock_c
    ../../../../../middleware/azure_iot/deps/umock-c/inc/umock_c/: umock_c_prod.h
  group azure_iot/deps/azure-macro-utils-c/inc/azure_macro_utils
    ../../../../../middleware/azure_iot/deps/azure-macro-utils-c/inc/azure_macro_utils/: macro_utils.h
  group device
    ../../../../../devices/MIMXRT1052/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.c system_MIMXRT1052.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1052/iar/: startup_MIMXRT1052.s
  group xip
    ../../../../../devices/MIMXRT1052/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
