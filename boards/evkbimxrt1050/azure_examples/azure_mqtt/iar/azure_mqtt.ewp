# IAR project azure_mqtt.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; XIP_BOOT_HEADER_DCD_ENABLE=1; DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1052DVL6B; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SDK_DEBUGCONSOLE_UART; SDK_DEBUGCONSOLE=0; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; USE_RTOS=1; LWIP_DNS=1; LWIP_DHCP=1; LWIP_NETIF_LINK_CALLBACK=1; LWIP_NETIF_STATUS_CALLBACK=1; MBEDTLS_CONFIG_FILE="azure_mbedtls_config.h"; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe1215,Pe191,Pe188,Pe177,Pe767
  ICCARM.IExtraOptions: --diag_suppress Pa084
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F; ..; ../../..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../middleware/mbedtls/include; ../../../../../middleware/mbedtls/port/ksdk; ../../../../../rtos/freertos/freertos_kernel/include; ../../../../../components/phy/mdio/enet; ../../../../../components/phy/device/phyksz8081; ../../../../../devices/MIMXRT1052/drivers; ../../../../../middleware/lwip/src/include; ../../../../../middleware/lwip/port; ../../../../../middleware/lwip/src; ../../../../../devices/MIMXRT1052/utilities/str; ../../../../../devices/MIMXRT1052/utilities/debug_console; ../../../../../middleware/azure_iot/c-utility/inc; ../../../../../middleware/azure_iot/umqtt/inc; ../../../../../middleware/azure_iot/c-utility/adapters; ../../../../../middleware/azure_iot/c-utility/pal; ../../../../../middleware/azure_iot/c-utility/pal/generic; ../../../../../middleware/azure_iot/c-utility/pal/inc; ../../../../../middleware/azure_iot/c-utility/pal/lwip; ../../../../../middleware/azure_iot/iothub_client/inc; ../../../../../middleware/azure_iot/iothub_client/inc/internal; ../../../../../middleware/azure_iot/certs; ../../../../../middleware/azure_iot/deps/parson; ../../../../../middleware/azure_iot/deps/umock-c/inc; ../../../../../middleware/azure_iot/deps/azure-macro-utils-c/inc; ../../../../../devices/MIMXRT1052; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../devices/MIMXRT1052/xip; ../../../xip; ../../../../../components/phy; ../../../../../devices/MIMXRT1052/utilities
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ../../../../src/azure_examples/azure_mqtt; ..; ../../..
  ILINK.IlinkOutputFile: azure_mqtt.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2048; __heap_size__=0x20000; __ram_vector_table__=1
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor_sdram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; DEBUG; CPU_MIMXRT1052DVL6B; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SDK_DEBUGCONSOLE_UART; SDK_DEBUGCONSOLE=0; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; USE_RTOS=1; LWIP_DNS=1; LWIP_DHCP=1; LWIP_NETIF_LINK_CALLBACK=1; LWIP_NETIF_STATUS_CALLBACK=1; MBEDTLS_CONFIG_FILE="azure_mbedtls_config.h"; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ILINK.IlinkIcfFile: evkbimxrt1050_lwip_mbedTLS_freertos.icf
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; XIP_BOOT_HEADER_DCD_ENABLE=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1052DVL6B; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SDK_DEBUGCONSOLE_UART; SDK_DEBUGCONSOLE=0; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; USE_RTOS=1; LWIP_DNS=1; LWIP_DHCP=1; LWIP_NETIF_LINK_CALLBACK=1; LWIP_NETIF_STATUS_CALLBACK=1; MBEDTLS_CONFIG_FILE="azure_mbedtls_config.h"; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1052DVL6B; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SDK_DEBUGCONSOLE_UART; SDK_DEBUGCONSOLE=0; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; USE_RTOS=1; LWIP_DNS=1; LWIP_DHCP=1; LWIP_NETIF_LINK_CALLBACK=1; LWIP_NETIF_STATUS_CALLBACK=1; MBEDTLS_CONFIG_FILE="azure_mbedtls_config.h"; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: evkbimxrt1050_lwip_mbedTLS_freertos.icf
  group source
    ../: azure_mqtt.c azure_mqtt.h lwipopts.h azure_mbedtls_config.h FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.txt
  group mdio
    ../../../../../components/phy/mdio/enet/: fsl_enet_mdio.c fsl_enet_mdio.h
    ../../../../../components/phy/: fsl_mdio.h
  group phy
    ../../../../../components/phy/device/phyksz8081/: fsl_phyksz8081.c fsl_phyksz8081.h
    ../../../../../components/phy/: fsl_phy.h
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_trng.c fsl_trng.h fsl_dcp.c fsl_dcp.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h fsl_gpio.c fsl_gpio.h fsl_enet.c fsl_enet.h
  group freertos/freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_3.c ReadMe.url
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/include
    ../../../../../rtos/freertos/freertos_kernel/include/: FreeRTOS.h StackMacros.h atomic.h croutine.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group mbedtls/include/mbedtls
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/library
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/port/ksdk
    ../../../../../middleware/mbedtls/port/ksdk/: aes_alt.c aes_alt.h des_alt.c des_alt.h ecp_alt.c ecp_alt.h ecp_alt_ksdk.c ecp_curves_alt.c ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h
  group lwip/src/apps/sntp
    ../../../../../middleware/lwip/src/apps/sntp/: sntp.c
  group lwip/src/include/lwip
    ../../../../../middleware/lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/apps
    ../../../../../middleware/lwip/src/include/lwip/apps/: sntp.h sntp_opts.h
  group lwip/src/include/lwip/priv
    ../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../middleware/lwip/src/include/lwip/prot/: acd.h autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip/src/include/compat/posix
    ../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/compat/posix/net
    ../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/sys
    ../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/stdc
    ../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/netif
    ../../../../../middleware/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lwip/src/include/netif/ppp
    ../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip/src/api
    ../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/core
    ../../../../../middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/src/core/ipv4
    ../../../../../middleware/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/src/core/ipv6
    ../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip/src/netif
    ../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lwip/port
    ../../../../../middleware/lwip/port/: sys_arch.c enet_ethernetif.c enet_ethernetif.h enet_ethernetif_kinetis.c enet_ethernetif_priv.h
  group lwip/port/arch
    ../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c
  group azure_iot/c-utility/inc/azure_c_shared_utility
    ../../../../../middleware/azure_iot/c-utility/inc/azure_c_shared_utility/: agenttime.h azure_base32.h azure_base64.h buffer_.h condition.h connection_string_parser.h consolelogger.h const_defines.h constbuffer.h constmap.h crt_abstractions.h doublylinkedlist.h etwlogger.h etwlogger_driver.h gballoc.h gbnetwork.h hmac.h hmacsha256.h http_proxy_io.h httpapi.h httpapiex.h httpapiexsas.h httpheaders.h lock.h map.h optimize_size.h optionhandler.h platform.h refcount.h sastoken.h sha-private.h sha.h shared_util_options.h singlylinkedlist.h socketio.h stdint_ce6.h string_token.h string_tokenizer.h string_tokenizer_types.h strings.h strings_types.h threadapi.h tickcounter.h tlsio.h tlsio_options.h uniqueid.h urlencode.h uuid.h uws_client.h uws_frame_encoder.h vector.h vector_types.h vector_types_internal.h wsio.h xio.h xlogging.h tlsio_mbedtls.h
  group azure_iot/c-utility/src
    ../../../../../middleware/azure_iot/c-utility/src/: azure_base32.c azure_base64.c buffer.c connection_string_parser.c consolelogger.c constbuffer.c constmap.c crt_abstractions.c doublylinkedlist.c gballoc.c hmac_azure.c hmacsha256.c http_proxy_io.c httpapiex.c httpapiexsas.c httpheaders.c map.c optionhandler.c sastoken.c sha1_azure.c sha224.c sha384-512.c singlylinkedlist.c string_token.c string_tokenizer.c strings.c urlencode.c usha.c uuid.c vector.c xio.c xlogging.c
  group azure_iot/c-utility/adapters
    ../../../../../middleware/azure_iot/c-utility/adapters/: agenttime_msdk.c httpapi_compact.c platform_msdk.c socketio_berkeley_msdk.c uniqueid_stub.c tlsio_mbedtls.c
  group azure_iot/c-utility/pal
    ../../../../../middleware/azure_iot/c-utility/pal/: tlsio_options.c
  group azure_iot/c-utility/pal/generic
    ../../../../../middleware/azure_iot/c-utility/pal/generic/: refcount_os.h
  group azure_iot/c-utility/pal/inc
    ../../../../../middleware/azure_iot/c-utility/pal/inc/: sntp.h
  group azure_iot/c-utility/pal/lwip
    ../../../../../middleware/azure_iot/c-utility/pal/lwip/: sntp_lwip.c sntp_os.h
  group azure_iot/c-utility/pal/freertos
    ../../../../../middleware/azure_iot/c-utility/pal/freertos/: lock.c threadapi.c tickcounter.c
  group azure_iot/umqtt/inc/azure_umqtt_c
    ../../../../../middleware/azure_iot/umqtt/inc/azure_umqtt_c/: mqtt_client.h mqtt_codec.h mqtt_message.h mqttconst.h
  group azure_iot/umqtt/src
    ../../../../../middleware/azure_iot/umqtt/src/: mqtt_client.c mqtt_codec.c mqtt_message.c
  group azure_iot/iothub_client/inc
    ../../../../../middleware/azure_iot/iothub_client/inc/: iothub.h iothub_client.h iothub_client_core.h iothub_client_core_common.h iothub_client_core_ll.h iothub_client_ll.h iothub_client_options.h iothub_client_version.h iothub_device_client.h iothub_device_client_ll.h iothub_message.h iothub_transport_ll.h iothubtransportmqtt.h
  group azure_iot/iothub_client/inc/internal
    ../../../../../middleware/azure_iot/iothub_client/inc/internal/: blob.h iothub_client_authorization.h iothub_client_diagnostic.h iothub_client_hsm_ll.h iothub_client_ll_uploadtoblob.h iothub_client_private.h iothub_client_retry_control.h iothub_transport_ll_private.h iothubtransport.h message_queue.h iothubtransport_mqtt_common.h
  group azure_iot/iothub_client/src
    ../../../../../middleware/azure_iot/iothub_client/src/: blob.c iothub.c iothub_client.c iothub_client_authorization.c iothub_client_core.c iothub_client_core_ll.c iothub_client_diagnostic.c iothub_client_ll.c iothub_client_ll_uploadtoblob.c iothub_client_retry_control.c iothub_message.c iothub_transport_ll_private.c iothubtransport.c message_queue.c version_azure.c iothubtransport_mqtt_common.c iothubtransportmqtt.c
  group azure_iot/certs
    ../../../../../middleware/azure_iot/certs/: certs_azure.c certs_azure.h
  group azure_iot/deps/parson
    ../../../../../middleware/azure_iot/deps/parson/: parson.c parson.h
  group azure_iot/deps/umock-c/inc/umock_c
    ../../../../../middleware/azure_iot/deps/umock-c/inc/umock_c/: umock_c_prod.h
  group azure_iot/deps/azure-macro-utils-c/inc/azure_macro_utils
    ../../../../../middleware/azure_iot/deps/azure-macro-utils-c/inc/azure_macro_utils/: macro_utils.h
  group device
    ../../../../../devices/MIMXRT1052/: MIMXRT1052.h MIMXRT1052_features.h fsl_device_registers.h system_MIMXRT1052.c system_MIMXRT1052.h
  group component/uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MIMXRT1052/iar/: startup_MIMXRT1052.s
  group xip
    ../../../../../devices/MIMXRT1052/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
