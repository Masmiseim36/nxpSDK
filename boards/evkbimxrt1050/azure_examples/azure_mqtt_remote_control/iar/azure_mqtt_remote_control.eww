<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>azure_mqtt_remote_control</project>
        <configuration>sdram_debug</configuration>
      </member>
      <member>
        <project>azure_mqtt_remote_control</project>
        <configuration>sdram_release</configuration>
      </member>
      <member>
        <project>azure_mqtt_remote_control</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
      <member>
        <project>azure_mqtt_remote_control</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdram_debug</name>
      <member>
        <project>azure_mqtt_remote_control</project>
        <configuration>sdram_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdram_release</name>
      <member>
        <project>azure_mqtt_remote_control</project>
        <configuration>sdram_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_debug</name>
      <member>
        <project>azure_mqtt_remote_control</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_release</name>
      <member>
        <project>azure_mqtt_remote_control</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/azure_mqtt_remote_control.ewp</path>
  </project>
</workspace>
