# Keil uVision project azure_mqtt_remote_control.uvprojx, settings and files
target azure_mqtt_remote_control flexspi_nor_debug (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: azure_mqtt_remote_control.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: SKIP_SYSCLK_INIT, XIP_BOOT_HEADER_DCD_ENABLE=1, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, CPU_MIMXRT1052DVL6B, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SDK_DEBUGCONSOLE_UART, SDK_DEBUGCONSOLE=0, PRINTF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, USE_RTOS=1, LWIP_DNS=1, LWIP_DHCP=1, LWIP_NETIF_LINK_CALLBACK=1, LWIP_NETIF_STATUS_CALLBACK=1, MBEDTLS_CONFIG_FILE='\"azure_mbedtls_config.h\"', FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc 
--diag_suppress=66,1296,186 
--diag_suppress=1296,186,177,66,191 
--diag_suppress=177
  c include: ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F;../../../../../middleware/azure_iot/c-utility/inc;..;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../rtos/amazon-freertos/lib/include;../../../../../rtos/amazon-freertos/lib/include/private;../../../../../middleware/mbedtls/include;../../../../../middleware/mbedtls/port/ksdk;../../../../../components/phyksz8081;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../middleware/lwip/port;../../../../../middleware/lwip/src;../../../../../middleware/lwip/src/include;../../../../../middleware/lwip/src/include;../../../../../middleware/azure_iot/c-utility/inc;../../../../../middleware/azure_iot/umqtt/inc;../../../../../middleware/azure_iot/c-utility/adapters;../../../../../middleware/azure_iot/c-utility/pal;../../../../../middleware/azure_iot/c-utility/pal/freertos;../../../../../middleware/azure_iot/c-utility/pal/generic;../../../../../middleware/azure_iot/c-utility/pal/inc;../../../../../middleware/azure_iot/c-utility/pal/lwip;../../../../../middleware/azure_iot/iothub_client/inc;../../../../../middleware/azure_iot/iothub_client/inc/internal;../../../../../middleware/azure_iot/certs;../../../../../middleware/azure_iot/deps/parson;../../../../../middleware/azure_iot/c-utility/inc;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052;../../../../../devices/MIMXRT1052/utilities/str;../../../../../devices/MIMXRT1052/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/serial_manager;../../../../../devices/MIMXRT1052/drivers;../../../../../components/lists;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/xip;../../../xip;../../../../../devices/MIMXRT1052/utilities
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../../../../src/azure_examples/azure_mqtt_remote_control;..;../../..
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: --keep=*(.boot_hdr.dcd_data) 
--predefine="-D__stack_size__=0x2048" 
--predefine="-D__heap_size__=0x20000" 
--predefine="-D__ram_vector_table__=1" 
--predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group source
    ../: remote_control_mqtt.c remote_control_mqtt.h lwipopts.h azure_mbedtls_config.h FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
    ../../../../../components/phyksz8081/: fsl_phy.h fsl_phy.c
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_trng.c fsl_trng.h fsl_dcp.c fsl_dcp.h fsl_cache.c fsl_cache.h fsl_clock.h fsl_clock.c fsl_enet.h fsl_enet.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group amazon-freertos-license
    ../../../../../rtos/amazon-freertos/: LICENSE
  group amazon-freertos-include
    ../../../../../rtos/amazon-freertos/lib/include/: event_groups.h FreeRTOS.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
    ../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_wrappers.h portable.h projdefs.h stack_macros.h
  group amazon-freertos-FreeRTOS
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos-FreeRTOS-portable
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F/: fsl_tickless_systick.c fsl_tickless_generic.h port.c portmacro.h
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_3.c
  group lwip-port
    ../../../../../middleware/lwip/port/: sys_arch.c ethernetif.c ethernetif.h
  group lwip-port-arch
    ../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip-src-api
    ../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-src-core
    ../../../../../middleware/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip-src-core-ipv4
    ../../../../../middleware/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip-src-core-ipv6
    ../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip-src-include-lwip
    ../../../../../middleware/lwip/src/include/lwip/: api.h arch.h debug.h dhcp.h dns.h errno.h ethip6.h icmp6.h inet.h init.h ip_addr.h ip4_addr.h ip6.h ip6_frag.h memp.h nd6.h netdb.h netifapi.h pbuf.h sio.h sockets.h sys.h tcpip.h udp.h autoip.h def.h dhcp6.h err.h etharp.h icmp.h igmp.h inet_chksum.h ip.h ip4.h ip4_frag.h ip6_addr.h mem.h mld6.h netbuf.h netif.h opt.h raw.h snmp.h stats.h tcp.h timeouts.h
  group lwip-src-include-lwip-priv
    ../../../../../middleware/lwip/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h nd6_priv.h tcp_priv.h tcpip_priv.h
  group lwip-src-include-lwip-prot
    ../../../../../middleware/lwip/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h ethernet.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip-src-include-netif
    ../../../../../middleware/lwip/src/include/netif/: etharp.h ethernet.h lowpan6.h lowpan6_opts.h slipif.h
  group lwip-src-include-netif-ppp
    ../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap_ms.h chap-md5.h chap-new.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip-src-include-netif-ppp-polarssl
    ../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip-src-include-posix
    ../../../../../middleware/lwip/src/include/posix/: errno.h netdb.h
  group lwip-src-include-posix-sys
    ../../../../../middleware/lwip/src/include/posix/sys/: socket.h
  group lwip-src-netif
    ../../../../../middleware/lwip/src/netif/: ethernet.c lowpan6.c slipif.c
  group lwip-src-netif-ppp
    ../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group mbedtls-mbedtls_include
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls-mbedtls_source
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c chacha20.c chachapoly.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls-mbedtls_port
    ../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c
  group lwip-src-include-lwip-apps
    ../../../../../middleware/lwip/src/include/lwip/apps/: sntp.h sntp_opts.h
  group lwip-src-apps-sntp
    ../../../../../middleware/lwip/src/apps/sntp/: sntp.c
  group azure_iot-c-utility-inc-azure_c_shared_utility
    ../../../../../middleware/azure_iot/c-utility/inc/azure_c_shared_utility/: agenttime.h base32.h base64.h buffer_.h condition.h connection_string_parser.h consolelogger.h const_defines.h constbuffer.h constmap.h crt_abstractions.h doublylinkedlist.h etwlogger.h etwlogger_driver.h gballoc.h gbnetwork.h hmac.h hmacsha256.h http_proxy_io.h httpapi.h httpapiex.h httpapiexsas.h httpheaders.h lock.h macro_utils.h map.h optimize_size.h optionhandler.h platform.h refcount.h sastoken.h sha-private.h sha.h shared_util_options.h singlylinkedlist.h socketio.h stdint_ce6.h strings.h strings_types.h string_tokenizer.h string_tokenizer_types.h threadapi.h tickcounter.h tlsio.h tlsio_options.h umock_c_prod.h uniqueid.h urlencode.h uuid.h uws_client.h uws_frame_encoder.h vector.h vector_types.h vector_types_internal.h wsio.h xio.h xlogging.h tlsio_mbedtls.h
  group azure_iot-src
    ../../../../../middleware/azure_iot/c-utility/src/: base32.c base64_azure.c buffer.c connection_string_parser.c consolelogger.c constbuffer.c constmap.c crt_abstractions.c doublylinkedlist.c gballoc.c hmac_azure.c hmacsha256.c http_proxy_io.c httpapiex.c httpapiexsas.c httpheaders.c map.c optionhandler.c sastoken.c sha1_azure.c sha224.c sha384-512.c singlylinkedlist.c strings.c string_tokenizer.c urlencode.c usha.c uuid.c vector.c xio.c xlogging.c
  group azure_iot-azure_umqtt
    ../../../../../middleware/azure_iot/umqtt/inc/azure_umqtt_c/: mqtt_client.h mqtt_codec.h mqtt_message.h mqttconst.h
    ../../../../../middleware/azure_iot/umqtt/src/: mqtt_client.c mqtt_codec.c mqtt_message.c
  group iothub_client
    ../../../../../middleware/azure_iot/iothub_client/inc/: iothubtransportmqtt.h iothub.h iothub_client_core.h iothub_client_core_common.h iothub_client_core_ll.h iothub_device_client.h iothub_device_client_ll.h iothub_client_options.h iothub_client.h iothub_client_ll.h iothub_client_version.h iothub_message.h iothub_transport_ll.h
    ../../../../../middleware/azure_iot/iothub_client/src/: iothub_client_retry_control.c iothubtransportmqtt.c iothubtransport_mqtt_common.c blob.c iothub.c iothub_client.c iothub_client_authorization.c iothub_client_core.c iothub_client_core_ll.c iothub_client_diagnostic.c iothub_client_ll.c iothub_client_ll_uploadtoblob.c iothub_message.c iothubtransport.c message_queue.c version_azure.c
    ../../../../../middleware/azure_iot/iothub_client/inc/internal/: blob.h iothubtransport.h iothubtransportamqp_methods.h iothubtransport_amqp_cbs_auth.h iothubtransport_amqp_common.h iothubtransport_amqp_connection.h iothubtransport_amqp_device.h iothubtransport_amqp_messenger.h iothubtransport_amqp_telemetry_messenger.h iothubtransport_amqp_twin_messenger.h iothubtransport_mqtt_common.h iothub_client_authorization.h iothub_client_diagnostic.h iothub_client_hsm_ll.h iothub_client_ll_uploadtoblob.h iothub_client_private.h iothub_client_retry_control.h iothub_transport_ll_private.h message_queue.h uamqp_messaging.h
  group azure_iot-adapters
    ../../../../../middleware/azure_iot/c-utility/adapters/: agenttime_msdk.c platform_msdk.c socketio_berkeley_msdk.c uniqueid_stub.c httpapi_compact.c tlsio_mbedtls.c
    ../../../../../middleware/azure_iot/c-utility/pal/freertos/: tickcounter.c threadapi.c lock.c
    ../../../../../middleware/azure_iot/c-utility/pal/generic/: refcount_os.h
    ../../../../../middleware/azure_iot/c-utility/pal/inc/: sntp.h
    ../../../../../middleware/azure_iot/c-utility/pal/lwip/: sntp_lwip.c sntp_os.h
    ../../../../../middleware/azure_iot/c-utility/pal/: tlsio_options.c
  group azure_iot-certs
    ../../../../../middleware/azure_iot/certs/: certs_azure.c certs_azure.h
  group azure_iot-parson
    ../../../../../middleware/azure_iot/deps/parson/: parson.h parson.c
  group device
    ../../../../../devices/MIMXRT1052/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.c system_MIMXRT1052.h
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1052/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: uart.h lpuart_adapter.c
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: generic_list.h generic_list.c
  group startup
    ../../../../../devices/MIMXRT1052/arm/: startup_MIMXRT1052.s
  group xip
    ../../../../../devices/MIMXRT1052/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
target azure_mqtt_remote_control sdram_debug (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: azure_mqtt_remote_control.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SKIP_SYSCLK_INIT, DEBUG, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, CPU_MIMXRT1052DVL6B, SDK_DEBUGCONSOLE_UART, SDK_DEBUGCONSOLE=0, PRINTF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, USE_RTOS=1, LWIP_DNS=1, LWIP_DHCP=1, LWIP_NETIF_LINK_CALLBACK=1, LWIP_NETIF_STATUS_CALLBACK=1, MBEDTLS_CONFIG_FILE='\"azure_mbedtls_config.h\"', FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: as above
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: evkbimxrt1050_lwip_httpscli_mbedTLS_freertos.scf
  link misc: --remove 
--predefine="-D__stack_size__=0x2048" 
--predefine="-D__heap_size__=0x20000" 
--predefine="-D__ram_vector_table__=1"
target azure_mqtt_remote_control flexspi_nor_release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: azure_mqtt_remote_control.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: SKIP_SYSCLK_INIT, XIP_BOOT_HEADER_DCD_ENABLE=1, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, CPU_MIMXRT1052DVL6B, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SDK_DEBUGCONSOLE_UART, SDK_DEBUGCONSOLE=0, PRINTF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, USE_RTOS=1, LWIP_DNS=1, LWIP_DHCP=1, LWIP_NETIF_LINK_CALLBACK=1, LWIP_NETIF_STATUS_CALLBACK=1, MBEDTLS_CONFIG_FILE='\"azure_mbedtls_config.h\"', FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: as above
target azure_mqtt_remote_control sdram_release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: azure_mqtt_remote_control.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SKIP_SYSCLK_INIT, NDEBUG, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, CPU_MIMXRT1052DVL6B, SDK_DEBUGCONSOLE_UART, SDK_DEBUGCONSOLE=0, PRINTF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, USE_RTOS=1, LWIP_DNS=1, LWIP_DHCP=1, LWIP_NETIF_LINK_CALLBACK=1, LWIP_NETIF_STATUS_CALLBACK=1, MBEDTLS_CONFIG_FILE='\"azure_mbedtls_config.h\"', FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: as above
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: evkbimxrt1050_lwip_httpscli_mbedTLS_freertos.scf
  link misc: as above
