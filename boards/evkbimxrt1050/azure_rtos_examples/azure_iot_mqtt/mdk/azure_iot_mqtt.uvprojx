# Keil uVision project azure_iot_mqtt.uvprojx, settings and files
target azure_iot_mqtt sdram_debug (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: azure_iot_mqtt.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, DEBUG, __CLANG_ARM, CPU_MIMXRT1052DVL6B, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, NX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../components/phyksz8081;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052;../../../../../devices/MIMXRT1052/utilities/str;../../../../../devices/MIMXRT1052/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../devices/MIMXRT1052/xip;../../../xip;../../../../../rtos/azure-rtos/netxduo/addons/auto_ip;../../../../../rtos/azure-rtos/netxduo/addons/cloud;../../../../../rtos/azure-rtos/netxduo/addons/BSD;../../../../../rtos/azure-rtos/netxduo/addons/dhcp;../../../../../rtos/azure-rtos/netxduo/addons/dns;../../../../../rtos/azure-rtos/netxduo/addons/ftp;../../../../../rtos/azure-rtos/netxduo/addons/http;../../../../../rtos/azure-rtos/netxduo/addons/mdns;../../../../../rtos/azure-rtos/netxduo/addons/mqtt;../../../../../rtos/azure-rtos/netxduo/addons/nat;../../../../../rtos/azure-rtos/netxduo/addons/pop3;../../../../../rtos/azure-rtos/netxduo/addons/ppp;../../../../../rtos/azure-rtos/netxduo/addons/pppoe;../../../../../rtos/azure-rtos/netxduo/addons/smtp;../../../../../rtos/azure-rtos/netxduo/addons/snmp;../../../../../rtos/azure-rtos/netxduo/addons/sntp;../../../../../rtos/azure-rtos/netxduo/addons/telnet;../../../../../rtos/azure-rtos/netxduo/addons/tftp;../../../../../rtos/azure-rtos/netxduo/addons/web;../../../../../rtos/azure-rtos/netxduo/common/inc;../../../../../rtos/azure-rtos/netxduo/crypto_libraries/inc;../../../../../rtos/azure-rtos/netxduo/nx_secure/inc;../../../../../rtos/azure-rtos/netxduo/nx_secure/ports;../../../../../rtos/azure-rtos/netxduo/ports/cortex_m7/ac6/inc;../../../../../rtos/azure-rtos/filex/common/inc;../../../../../rtos/azure-rtos/filex/ports/cortex_m7/ac6/inc;../../../../../rtos/azure-rtos/threadx/common/inc;../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc;../../../../../CMSIS/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA, TX_ENABLE_FPU_SUPPORT
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_sdram.scf
  link misc: ../../../../../rtos/azure-rtos/binary/netxduo/mdk/libnetxduo.lib ../../../../../rtos/azure-rtos/binary/filex/mdk/libfilex.lib ../../../../../rtos/azure-rtos/binary/threadx/mdk/libthreadx.lib --remove
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
    ../../../../../components/phyksz8081/: fsl_phy.h fsl_phy.c
  group source
    ../: main.c sample_azure_iot.c
  group ports
    ../: tx_user.h nx_driver_imxrt_irq.c nx_driver_imxrt.c nx_driver_imxrt.h nx_user.h fx_user.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_trng.c fsl_trng.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_enet.h fsl_enet.c
  group device
    ../../../../../devices/MIMXRT1052/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.c system_MIMXRT1052.h
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1052/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1052/arm/: startup_MIMXRT1052.S
  group xip
    ../../../../../devices/MIMXRT1052/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h
  group azure-rtos/netxduo/addons/auto_ip
    ../../../../../rtos/azure-rtos/netxduo/addons/auto_ip/: nx_auto_ip.h
  group azure-rtos/netxduo/addons/cloud
    ../../../../../rtos/azure-rtos/netxduo/addons/cloud/: nx_cloud.h
  group azure-rtos/netxduo/addons/BSD
    ../../../../../rtos/azure-rtos/netxduo/addons/BSD/: nxd_bsd.h
  group azure-rtos/netxduo/addons/dhcp
    ../../../../../rtos/azure-rtos/netxduo/addons/dhcp/: nxd_dhcp_server.h nxd_dhcpv6_server.h nxd_dhcpv6_client.h nxd_dhcp_client.h
  group azure-rtos/netxduo/addons/dns
    ../../../../../rtos/azure-rtos/netxduo/addons/dns/: nxd_dns.h
  group azure-rtos/netxduo/addons/ftp
    ../../../../../rtos/azure-rtos/netxduo/addons/ftp/: nxd_ftp_client.h nxd_ftp_server.h
  group azure-rtos/netxduo/addons/http
    ../../../../../rtos/azure-rtos/netxduo/addons/http/: nxd_http_server.h nxd_http_client.h
  group azure-rtos/netxduo/addons/mdns
    ../../../../../rtos/azure-rtos/netxduo/addons/mdns/: nxd_mdns.h
  group azure-rtos/netxduo/addons/mqtt
    ../../../../../rtos/azure-rtos/netxduo/addons/mqtt/: nxd_mqtt_client.h
  group azure-rtos/netxduo/addons/nat
    ../../../../../rtos/azure-rtos/netxduo/addons/nat/: nx_nat.h
  group azure-rtos/netxduo/addons/pop3
    ../../../../../rtos/azure-rtos/netxduo/addons/pop3/: nxd_pop3_client.h
  group azure-rtos/netxduo/addons/ppp
    ../../../../../rtos/azure-rtos/netxduo/addons/ppp/: nx_ppp.h
  group azure-rtos/netxduo/addons/pppoe
    ../../../../../rtos/azure-rtos/netxduo/addons/pppoe/: nx_pppoe_server.h nx_pppoe_client.h
  group azure-rtos/netxduo/addons/smtp
    ../../../../../rtos/azure-rtos/netxduo/addons/smtp/: nxd_smtp_client.h
  group azure-rtos/netxduo/addons/snmp
    ../../../../../rtos/azure-rtos/netxduo/addons/snmp/: nxd_snmp.h nx_des.h nx_sha1.h
  group azure-rtos/netxduo/addons/sntp
    ../../../../../rtos/azure-rtos/netxduo/addons/sntp/: nxd_sntp_client.h
  group azure-rtos/netxduo/addons/telnet
    ../../../../../rtos/azure-rtos/netxduo/addons/telnet/: nxd_telnet_server.h nxd_telnet_client.h
  group azure-rtos/netxduo/addons/tftp
    ../../../../../rtos/azure-rtos/netxduo/addons/tftp/: nxd_tftp_server.h nxd_tftp_client.h
  group azure-rtos/netxduo/addons/web
    ../../../../../rtos/azure-rtos/netxduo/addons/web/: nx_web_http_server.h nx_tcpserver.h nx_web_http_common.h nx_web_http_client.h
  group azure-rtos/netxduo/common/inc
    ../../../../../rtos/azure-rtos/netxduo/common/inc/: nx_igmp.h nx_ipv4.h nx_packet.h nx_nd_cache.h nx_md5.h nx_icmpv6.h nx_icmp.h nx_user_sample.h nx_tcp.h nx_icmpv4.h nx_arp.h nx_ipv6.h nx_system.h nx_api.h nx_rarp.h nx_mld.h nx_ip.h nx_udp.h
  group azure-rtos/netxduo/crypto_libraries/inc
    ../../../../../rtos/azure-rtos/netxduo/crypto_libraries/inc/: nx_crypto_sha1.h nx_crypto_hmac_md5.h nx_crypto_xcbc_mac.h nx_crypto_hmac.h nx_crypto_ccm.h nx_crypto_dh.h nx_crypto_tls_prf_1.h nx_crypto_const.h nx_crypto_cbc.h nx_crypto_ec.h nx_crypto_md5.h nx_crypto_tls_prf_sha384.h nx_crypto.h nx_crypto_sha5.h nx_crypto_rsa.h nx_crypto_ecdh.h nx_crypto_ecdsa.h nx_crypto_hmac_sha2.h nx_crypto_3des.h nx_crypto_null.h nx_crypto_drbg.h nx_crypto_phash.h nx_crypto_hmac_sha1.h nx_crypto_gcm.h nx_crypto_tls_prf_sha256.h nx_crypto_sha2.h nx_crypto_pkcs1_v1.5.h nx_crypto_tls_prf_sha512.h nx_crypto_huge_number.h nx_crypto_hmac_sha5.h nx_crypto_ecjpake.h nx_crypto_des.h nx_crypto_ctr.h nx_crypto_aes.h nx_crypto_method_self_test.h nx_crypto_hkdf.h
  group azure-rtos/netxduo/nx_secure/inc
    ../../../../../rtos/azure-rtos/netxduo/nx_secure/inc/: nx_secure_tls_api.h nx_secure_dtls_api.h nx_secure_user_sample.h nx_secure_x509.h nx_secure_dtls.h nx_secure_crypto_table_self_test.h nx_secure_tls.h
  group azure-rtos/netxduo/nx_secure/ports
    ../../../../../rtos/azure-rtos/netxduo/nx_secure/ports/: nx_secure_port.h
  group azure-rtos/netxduo/samples
    ../../../../../rtos/azure-rtos/netxduo/samples/: demo_snmp_helper.h
  group azure-rtos/netxduo/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/netxduo/ports/cortex_m7/ac6/inc/: nx_port.h
  group azure-rtos/filex/common/inc
    ../../../../../rtos/azure-rtos/filex/common/inc/: fx_media.h fx_unicode.h fx_api.h fx_directory_exFAT.h fx_utility.h fx_file.h fx_system.h fx_directory.h fx_user_sample.h fx_fault_tolerant.h
  group azure-rtos/filex/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/filex/ports/cortex_m7/ac6/inc/: fx_port.h
  group azure-rtos/threadx/common/inc
    ../../../../../rtos/azure-rtos/threadx/common/inc/: tx_byte_pool.h tx_event_flags.h tx_timer.h tx_queue.h tx_thread.h tx_mutex.h tx_trace.h tx_initialize.h tx_api.h tx_user_sample.h tx_block_pool.h tx_semaphore.h
  group azure-rtos/threadx/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc/: tx_port.h
  group azure-rtos/threadx/ports/cortex_m7/ac6/src
    ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/src/: tx_initialize_low_level.S
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
target azure_iot_mqtt flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: azure_iot_mqtt.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, __CLANG_ARM, CPU_MIMXRT1052DVL6B, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, NX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE
  c misc: as above
  c include: as above
  asm define: as above
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: ../../../../../rtos/azure-rtos/binary/netxduo/mdk/libnetxduo.lib ../../../../../rtos/azure-rtos/binary/filex/mdk/libfilex.lib ../../../../../rtos/azure-rtos/binary/threadx/mdk/libthreadx.lib --remove --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
target azure_iot_mqtt sdram_release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: azure_iot_mqtt.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, __CLANG_ARM, CPU_MIMXRT1052DVL6B, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, NX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA, TX_ENABLE_FPU_SUPPORT
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_sdram.scf
  link misc: as above
target azure_iot_mqtt flexspi_nor_release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: azure_iot_mqtt.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, __CLANG_ARM, CPU_MIMXRT1052DVL6B, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, NX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE
  c misc: as above
  c include: as above
  asm define: as above
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: as above
