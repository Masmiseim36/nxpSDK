# IAR project guix_washing_machine.ewp, settings and files
configuration sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; DEBUG; CPU_MIMXRT1052DVL6B; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; GX_INCLUDE_USER_DEFINE_FILE; TX_INCLUDE_USER_DEFINE_FILE; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../rtos/azure-rtos/guix/common/inc; ../../../../../rtos/azure-rtos/guix/ports/cortex_m7/iar/inc; ../../../../../components/ft5406_rt; ../../../../../devices/MIMXRT1052/drivers; ../../../../../devices/MIMXRT1052; ../../../../../devices/MIMXRT1052/utilities/str; ../../../../../devices/MIMXRT1052/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../devices/MIMXRT1052/xip; ../../../xip; ../../../../../rtos/azure-rtos/threadx/common/inc; ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/iar/inc; ../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA; TX_ENABLE_FPU_SUPPORT=1
  ILINK.IlinkOutputFile: guix_washing_machine.out
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../rtos/azure-rtos/binary/guix/cortex_m7/iar/libguix.a; ../../../../../rtos/azure-rtos/binary/threadx/cortex_m7/iar/libthreadx.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1052DVL6B; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; GX_INCLUDE_USER_DEFINE_FILE; TX_INCLUDE_USER_DEFINE_FILE; MCUXPRESSO_SDK
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor_sdram.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1052DVL6B; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; GX_INCLUDE_USER_DEFINE_FILE; TX_INCLUDE_USER_DEFINE_FILE; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA; TX_ENABLE_FPU_SUPPORT=1
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1052DVL6B; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; GX_INCLUDE_USER_DEFINE_FILE; TX_INCLUDE_USER_DEFINE_FILE; MCUXPRESSO_SDK
  AARM.ADefines: as above
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor_sdram.icf
  group azure-rtos/config
    ../: tx_user.h gx_user.h
  group azure-rtos/guix/common/inc
    ../../../../../rtos/azure-rtos/guix/common/inc/: gx_animation.h gx_api.h gx_binres_loader.h gx_button.h gx_canvas.h gx_circular_gauge.h gx_context.h gx_display.h gx_drop_list.h gx_icon.h gx_image_reader.h gx_line_chart.h gx_menu.h gx_multi_line_text_input.h gx_multi_line_text_view.h gx_numeric_pixelmap_prompt.h gx_numeric_prompt.h gx_pixelmap_prompt.h gx_progress_bar.h gx_prompt.h gx_radial_progress_bar.h gx_radial_slider.h gx_rich_text_view.h gx_screen_stack.h gx_scroll_wheel.h gx_scrollbar.h gx_single_line_text_input.h gx_slider.h gx_sprite.h gx_system.h gx_system_rtos_bind.h gx_text_input_cursor.h gx_tree_view.h gx_user_sample.h gx_utility.h gx_widget.h gx_window.h
  group azure-rtos/guix/ports/cortex_m7/iar/inc
    ../../../../../rtos/azure-rtos/guix/ports/cortex_m7/iar/inc/: gx_port.h
  group azure-rtos/threadx/common/inc
    ../../../../../rtos/azure-rtos/threadx/common/inc/: tx_api.h tx_block_pool.h tx_byte_pool.h tx_event_flags.h tx_initialize.h tx_mutex.h tx_queue.h tx_semaphore.h tx_thread.h tx_timer.h tx_trace.h tx_user_sample.h
  group azure-rtos/threadx/ports/cortex_m7/iar/inc
    ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/iar/inc/: tx_port.h
  group azure-rtos/threadx/ports/cortex_m7/iar/src
    ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/iar/src/: tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_schedule.s tx_thread_stack_build.s tx_thread_system_return.s tx_timer_interrupt.s
  group azure-rtos/threadx/ports/common
    ../../../../../rtos/azure-rtos/threadx/ports/common/: tx_initialize_low_level.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group source
    ../: guix_washing_machine.c guix_washing_machine.h garments.c sample_guix_washing_machine_resources.c sample_guix_washing_machine_resources.h sample_guix_washing_machine_specifications.c sample_guix_washing_machine_specifications.h temperature.c washer_on.c water_level.c gx_touch_driver_imxrt10xx_capacitive.c gx_display_driver_imxrt10xx_565rgb.c gx_driver_imxrt10xx_irq.c
  group doc
    ../: readme.txt
  group touchpanel
    ../../../../../components/ft5406_rt/: fsl_ft5406_rt.h fsl_ft5406_rt.c
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_elcdif.c fsl_elcdif.h fsl_lpi2c.c fsl_lpi2c.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group device
    ../../../../../devices/MIMXRT1052/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.c system_MIMXRT1052.h
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1052/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1052/iar/: startup_MIMXRT1052.s
  group xip
    ../../../../../devices/MIMXRT1052/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
