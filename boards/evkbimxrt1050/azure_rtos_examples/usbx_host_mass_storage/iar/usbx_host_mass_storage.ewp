# IAR project usbx_host_mass_storage.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1052DVL6B; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; MIMXRT; UX_OTG_SUPPORT; TX_INCLUDE_USER_DEFINE_FILE; FX_INCLUDE_USER_DEFINE_FILE; UX_INCLUDE_USER_DEFINE_FILE
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/azure-rtos/usbx/ports/cortex_m7/iar/inc; ../../../../../rtos/azure-rtos/filex/ports/cortex_m7/iar/inc; ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/iar/inc; ../../../../../rtos/azure-rtos/netxduo/ports/cortex_m7/iar/inc; ../../../../../middleware/usb/include; ../../../../../middleware/usb/phy; ../../../../../components/osa; ..; ../../..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../rtos/azure-rtos/usbx/common/core/inc; ../../../../../rtos/azure-rtos/usbx/common/usbx_device_classes/inc; ../../../../../rtos/azure-rtos/usbx/common/usbx_host_classes/inc; ../../../../../rtos/azure-rtos/usbx/common/usbx_host_controllers/inc; ../../../../../rtos/azure-rtos/usbx/common/usbx_network/inc; ../../../../../rtos/azure-rtos/usbx/common/usbx_pictbridge/inc; ../../../../../rtos/azure-rtos/filex/common/inc; ../../../../../rtos/azure-rtos/threadx/common/inc; ../../../../../rtos/azure-rtos/netxduo/addons/auto_ip; ../../../../../rtos/azure-rtos/netxduo/addons/BSD; ../../../../../rtos/azure-rtos/netxduo/addons/dhcp; ../../../../../rtos/azure-rtos/netxduo/addons/dns; ../../../../../rtos/azure-rtos/netxduo/addons/ftp; ../../../../../rtos/azure-rtos/netxduo/addons/http; ../../../../../rtos/azure-rtos/netxduo/addons/mdns; ../../../../../rtos/azure-rtos/netxduo/addons/mqtt; ../../../../../rtos/azure-rtos/netxduo/addons/nat; ../../../../../rtos/azure-rtos/netxduo/addons/pop3; ../../../../../rtos/azure-rtos/netxduo/addons/ppp; ../../../../../rtos/azure-rtos/netxduo/addons/pppoe; ../../../../../rtos/azure-rtos/netxduo/addons/smtp; ../../../../../rtos/azure-rtos/netxduo/addons/snmp; ../../../../../rtos/azure-rtos/netxduo/addons/sntp; ../../../../../rtos/azure-rtos/netxduo/addons/telnet; ../../../../../rtos/azure-rtos/netxduo/addons/tftp; ../../../../../rtos/azure-rtos/netxduo/addons/web; ../../../../../rtos/azure-rtos/netxduo/common/inc; ../../../../../rtos/azure-rtos/netxduo/crypto_libraries/inc; ../../../../../rtos/azure-rtos/netxduo/nx_secure/inc; ../../../../../rtos/azure-rtos/netxduo/nx_secure/ports; ../../../../../devices/MIMXRT1052/drivers; ../../../../../devices/MIMXRT1052; ../../../../../devices/MIMXRT1052/utilities/str; ../../../../../devices/MIMXRT1052/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../devices/MIMXRT1052/xip; ../../../xip; ../../../../../devices/MIMXRT1052/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: usbx_host_mass_storage.out
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_ram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../rtos/azure-rtos/binary/usbx/iar/libusbx.a; ../../../../../rtos/azure-rtos/binary/filex/iar/libfilex.a; ../../../../../rtos/azure-rtos/binary/threadx/iar/libthreadx.a; ../../../../../rtos/azure-rtos/binary/netxduo/iar/libnetxduo.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1052DVL6B; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; MIMXRT; UX_OTG_SUPPORT; TX_INCLUDE_USER_DEFINE_FILE; FX_INCLUDE_USER_DEFINE_FILE; UX_INCLUDE_USER_DEFINE_FILE
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1052DVL6B; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; MIMXRT; UX_OTG_SUPPORT; TX_INCLUDE_USER_DEFINE_FILE; FX_INCLUDE_USER_DEFINE_FILE; UX_INCLUDE_USER_DEFINE_FILE
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1052DVL6B; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; MIMXRT; UX_OTG_SUPPORT; TX_INCLUDE_USER_DEFINE_FILE; FX_INCLUDE_USER_DEFINE_FILE; UX_INCLUDE_USER_DEFINE_FILE
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor.icf
  group board
    ../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
    ../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
    ../: pin_mux.c pin_mux.h board_setup.c board_setup.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group source
    ../: usbx_host_mass_storage.c
  group ports
    ../: tx_user.h tx_initialize_low_level_iar.s fx_user.h ux_hcd_interrupt_handler.c ux_user.h
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h fsl_gpio.c fsl_gpio.h
  group device
    ../../../../../devices/MIMXRT1052/: MIMXRT1052.h MIMXRT1052_features.h fsl_device_registers.h system_MIMXRT1052.c system_MIMXRT1052.h
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MIMXRT1052/iar/: startup_MIMXRT1052.s
  group xip
    ../../../../../devices/MIMXRT1052/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
