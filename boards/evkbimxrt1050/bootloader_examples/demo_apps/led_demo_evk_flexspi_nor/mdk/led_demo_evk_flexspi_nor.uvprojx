# Keil uVision project led_demo_evk_flexspi_nor.uvprojx, settings and files
target led_demo_evk_flexspi_nor release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7")
  output: led_demo_evk_flexspi_nor.out
  AfterMake: fromelf --bincombined -o "$L@L.bin" "#L"
  AfterMake: fromelf --m32combined -o "$L@L.srec" "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1052DVL6B, CPU_IS_ARM_CORTEX_M7=1, MIMXRT1052
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -Wno-null-dereference  -Wno-unknown-attributes  -Wno-expansion-to-defined  -Wno-invalid-noreturn
  c include: ../../../../../../CMSIS/Include;../../../../../../devices/MIMXRT1052;../../../../../../middleware/mcu-boot/targets/MIMXRT1052/src;../../../../../../middleware/mcu-boot/src/startup;../../../../../../middleware/mcu-boot/src/include;../../../../../../middleware/mcu-boot/apps/led_demo/src;..;../../../../../../devices/MIMXRT1052
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=1
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052_application_0x60002000.scf
  link misc: --remove --datacompressor off --predefine="-D__ram_vector_table__=1"
  group MIMXRT1052
    ../: main.c
  group device
    ../../../../../../devices/MIMXRT1052/: MIMXRT1052.h MIMXRT1052_features.h fsl_device_registers.h system_MIMXRT1052.h
    ../../../../../../middleware/mcu-boot/targets/MIMXRT1052/src/startup/: system_MIMXRT1052.c
  group startup
    ../../../../../../middleware/mcu-boot/targets/MIMXRT1052/src/startup/arm/: startup_MIMXRT1052.s
    ../../../../../../middleware/mcu-boot/src/startup/: startup.c
  group source-include
    ../../../../../../middleware/mcu-boot/src/include/: bootloader_core.h
  group source
    ../../../../../../middleware/mcu-boot/apps/led_demo/src/: milliseconds_delay.c milliseconds_delay.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
