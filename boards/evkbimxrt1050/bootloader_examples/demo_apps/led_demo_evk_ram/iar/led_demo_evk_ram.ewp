# IAR project led_demo_evk_ram.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1052DVL6B; CPU_IS_ARM_CORTEX_M7=1; MIMXRT1052
  ICCARM.CCDiagSuppress: Pa082,Pe177,Pe186,Ms014,Pa182
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MIMXRT1052; ../../../../../../devices/MIMXRT1052/drivers; ../../../../../../middleware/mcu-boot/src/include; ../../../../../../middleware/mcu-boot/src/startup; ../../../../../../middleware/mcu-boot/apps/led_demo/src; ../../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG; BL_HAS_BOOTLOADER_CONFIG
  ILINK.IlinkOutputFile: led_demo_evk_ram.out
  ILINK.IlinkIcfFile: ../../../../../../middleware/mcu-boot/targets/common/linker/iar/MIMXRT1052/MIMXRT1052_application_0xa000.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group board
    ../: pin_mux.c pin_mux.h
  group MIMXRT1052
    ../: main.c
  group doc
    ../: readme.txt
  group device
    ../../../../../../devices/MIMXRT1052/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.h
    ../../../../../../middleware/mcu-boot/targets/MIMXRT1052/src/startup/: system_MIMXRT1052.c
  group drivers
    ../../../../../../devices/MIMXRT1052/drivers/: fsl_common.h fsl_common.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c
  group startup
    ../../../../../../middleware/mcu-boot/targets/MIMXRT1052/src/startup/iar/: startup_MIMXRT1052.s
    ../../../../../../middleware/mcu-boot/src/startup/: startup.c
  group source
    ../../../../../../middleware/mcu-boot/apps/led_demo/src/: milliseconds_delay.h milliseconds_delay.c
  group source/include
    ../../../../../../middleware/mcu-boot/src/include/: bootloader_core.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
