# Keil uVision project led_demo_evk_ram.uvprojx, settings and files
target led_demo_evk_ram release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7")
  output: led_demo_evk_ram.out
  AfterMake: fromelf.exe --output "$L@L.srec" --m32combined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1052DVL6B, CPU_IS_ARM_CORTEX_M7=1, MIMXRT1052
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -Wno-null-dereference  -Wno-unknown-attributes  -Wno-expansion-to-defined  -Wno-invalid-noreturn
  c include: ..;../../../../../../devices/MIMXRT1052;../../../../../../devices/MIMXRT1052/drivers;../../../../../../middleware/mcu-boot/src/include;../../../../../../middleware/mcu-boot/src/startup;../../../../../../middleware/mcu-boot/apps/led_demo/src;../../../../../../CMSIS/Core/Include
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=1
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052_application_0xa000.scf
  link misc: --remove --datacompressor off
  group board
    ../: pin_mux.c pin_mux.h
  group MIMXRT1052
    ../: main.c
  group doc
    ../: readme.txt
  group device
    ../../../../../../devices/MIMXRT1052/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.h
    ../../../../../../middleware/mcu-boot/targets/MIMXRT1052/src/startup/: system_MIMXRT1052.c
  group drivers
    ../../../../../../devices/MIMXRT1052/drivers/: fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c
  group startup
    ../../../../../../middleware/mcu-boot/targets/MIMXRT1052/src/startup/arm/: startup_MIMXRT1052.s
    ../../../../../../middleware/mcu-boot/src/startup/: startup.c
  group source/include
    ../../../../../../middleware/mcu-boot/src/include/: bootloader_core.h
  group source
    ../../../../../../middleware/mcu-boot/apps/led_demo/src/: milliseconds_delay.h milliseconds_delay.c
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
