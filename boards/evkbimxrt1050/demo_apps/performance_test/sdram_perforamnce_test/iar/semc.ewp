# IAR project semc.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1052DVL6B; XIP_EXTERNAL_FLASH
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MIMXRT1052/drivers; ../../../../../../devices/MIMXRT1052/drivers; ../../../../../../devices/MIMXRT1052/drivers; ../../../../../../devices/MIMXRT1052; ../../../../../../devices/MIMXRT1052/utilities/str; ../../../../../../devices/MIMXRT1052/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/serial_manager; ../../../../../../devices/MIMXRT1052/drivers; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1052/drivers; ../../../../../../devices/MIMXRT1052/drivers; ../../../../../../devices/MIMXRT1052/xip; ../../../../xip
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: semc.srec
  ILINK.IlinkOutputFile: semc.out
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    ../../../../../../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm7.h mpu_armv7.h mpu_armv8.h
  group component/lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_uart.c serial_port_uart.h
  group component/uart
    ../../../../../../components/uart/: lpuart_adapter.c uart.h
  group device
    ../../../../../../devices/MIMXRT1052/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.c system_MIMXRT1052.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MIMXRT1052/drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h fsl_semc.c fsl_semc.h
  group source
    ../: semc_sdram.c
  group startup
    ../../../../../../devices/MIMXRT1052/iar/: startup_MIMXRT1052.s
  group utilities
    ../../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c
    ../../../../../../devices/MIMXRT1052/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
  group xip
    ../../../../xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h
    ../../../../../../devices/MIMXRT1052/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
