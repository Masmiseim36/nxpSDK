# IAR project safety_iec60730b.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1052DVL6B; XIP_BOOT_HEADER_DCD_ENABLE=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; SKIP_SYSCLK_INIT; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../middleware/safety_iec60730b/boards/common/cm4_cm7/startup/cm7; ..; ../../../../../middleware/safety_iec60730b/boards/evkbimxrt1050/xip; ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/register; ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/ram; ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/flash; ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/stack; ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/programCounter; ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7; ../../../../../middleware/safety_iec60730b/safety/v4_1; ../../../../../middleware/safety_iec60730b/safety/v4_1/compiler; ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/wdog; ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/tsi; ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/dio; ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/clock; ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/aio; ../../../../../devices/MIMXRT1052; ../../../../../devices/MIMXRT1052/drivers; ../../../../../devices/MIMXRT1052/utilities/str; ../../../../../devices/MIMXRT1052/utilities/debug_console; ../../../../../middleware/freemaster/src/common; ../../../../../middleware/freemaster/src/platforms/gen32le; ../../../../../middleware/freemaster/src/drivers/mcuxsdk/can; ../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../components/uart; ../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ../../../../../middleware/safety_iec60730b/boards/common/cm4_cm7/startup/cm7; ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/register; ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/ram; ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/flash; ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/stack; ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/programCounter; ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7; ../../../../../middleware/safety_iec60730b/safety/v4_1; ../../../../../middleware/safety_iec60730b/safety/v4_1/compiler; ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/wdog; ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/tsi; ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/dio; ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/clock; ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/aio; ../../../../../devices/MIMXRT1052
  postbuild: ielftool --fill 0xFF;c_checksumStart-c_checksumEnd+3 --checksum __checksum:4,crc32:i,0xFFFFFFFF;c_checksumStart-c_checksumEnd+3  --verbose "$TARGET_PATH$" "$TARGET_PATH$"
  ILINK.IlinkOutputFile: safety_iec60730b.out
  ILINK.IlinkIcfFile: linker/evkbimxrt1050_safety_flash.icf
  ILINK.IlinkExtraOptions: --place_holder __checksum,4,.checksum,4; --keep=__checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group source
    ../: freemaster_cfg.h safety_test_items.h safety_test_items.c isr.h safety_config.h project_setup_evkbimxrt1050.h project_setup_evkbimxrt1050.c safety_cm7_imxrt.c safety_cm7_imxrt.h main_imxrt.c
  group doc
    ../: readme.txt
  group board
    ../: pin_mux.c pin_mux.h clock_config.c clock_config.h board.c board.h
  group tools/srecord
    ../../../../../tools/srecord/: srecord-1.64.zip
  group startup
    ../../../../../middleware/safety_iec60730b/boards/common/cm4_cm7/startup/cm7/: start.c startup_iar.c vectors_iar.h vectors_iar.c
  group linker
    linker/: evkbimxrt1050_safety_flash.icf
  group device
    ../../../../../middleware/safety_iec60730b/boards/evkbimxrt1050/xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h
    ../../../../../devices/MIMXRT1052/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h
  group GUI
    ../GUI/: safety.pmp
  group safety/v4_1
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/: iec60730b_core.h
    ../../../../../middleware/safety_iec60730b/safety/v4_1/: iec60730b.h iec60730b_types.h IEC60730B_M4_M7_IAR_v4_1.a IEC60730B_M4_M7_COM_IAR_v4_1.a
  group safety/v4_1/register
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/register/: iec60730b_cm4_cm7_reg.h
  group safety/v4_1/ram
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/ram/: iec60730b_cm4_cm7_ram.h
  group safety/v4_1/flash
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/flash/: iec60730b_cm4_cm7_flash.h
  group safety/v4_1/stack
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/stack/: iec60730b_cm4_cm7_stack.h
  group safety/v4_1/programCounter
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/programCounter/: iec60730b_cm4_cm7_pc.h iec60730b_cm4_cm7_pc_object.S
  group safety/v4_1/compiler
    ../../../../../middleware/safety_iec60730b/safety/v4_1/compiler/: asm_mac_common.h
  group safety/v4_1/wdog
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/wdog/: iec60730b_wdog.c iec60730b_wdog.h
  group safety/v4_1/tsi
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/tsi/: iec60730b_tsi.h
  group safety/v4_1/dio
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/dio/: iec60730b_dio_ext.h iec60730b_dio.h
  group safety/v4_1/clock
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/clock/: iec60730b_clock.h
  group safety/v4_1/aio
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/aio/: iec60730b_aio.h
  group MIMXRT1052
    ../../../../../devices/MIMXRT1052/: system_MIMXRT1052.c system_MIMXRT1052.h
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_iomuxc.h
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1052/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group freemaster
    ../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_defcfg.h freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h freemaster_can.c freemaster_can.h freemaster_sha.c freemaster_pdbdm.c freemaster_serial.c freemaster_serial.h
  group freemaster/platforms
    ../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group freemaster/drivers
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mscan.c freemaster_mscan.h freemaster_mcan.c freemaster_mcan.h
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_usb.c freemaster_serial_usb.h
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
