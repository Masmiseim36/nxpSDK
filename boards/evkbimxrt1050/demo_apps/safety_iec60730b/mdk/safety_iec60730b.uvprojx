# Keil uVision project safety_iec60730b.uvprojx, settings and files
target safety_iec60730b debug (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.0.0
  cpu: IRAM(0x00000000,0x020000) IRAM2(0x20000000,0x020000) IROM(0x60000000,0x4000000) XRAM(0x20200000,0x040000) XRAM2(0x80000000,0x02000000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: safety_iec60730b.out +hex
  c flags: Optim=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT1052DVL6B, SERIAL_PORT_TYPE_UART=1
  c misc: -U__GNUC__  -gdwarf-3
  c include: ../../../../../middleware/safety_iec60730b/boards/evkbimxrt1050;../../..;../../../../../CMSIS/Include;../../../../../devices;linker;..;..;../../../../../middleware/safety_iec60730b/dev/evkbimxrt1050;../../../../../middleware/safety_iec60730b/boards/evkbimxrt1050/xip;../../../../../middleware/safety_iec60730b/safety/core_test/cm4_cm7/register;../../../../../middleware/safety_iec60730b/safety/core_test/cm4_cm7/ram;../../../../../middleware/safety_iec60730b/safety/core_test/cm4_cm7/flash;../../../../../middleware/safety_iec60730b/safety/core_test/cm4_cm7/stack;../../../../../middleware/safety_iec60730b/safety/core_test/cm4_cm7/programCounter;../../../../../middleware/safety_iec60730b/safety/core_test/cm4_cm7;../../../../../middleware/safety_iec60730b/safety;../../../../../middleware/safety_iec60730b/safety/compiler;../../../../../middleware/safety_iec60730b/safety/compiler/mdk;../../../../../middleware/safety_iec60730b/safety/common_test/wdog;../../../../../middleware/safety_iec60730b/safety/common_test/dio;../../../../../middleware/safety_iec60730b/safety/common_test/clock;../../../../../middleware/safety_iec60730b/safety/common_test/aio;../../../../../middleware/safety_iec60730b/boards/common/cm4_cm7/startup/cm7;../../../../../devices/MIMXRT1052;../../../../../devices/MIMXRT1052/arm;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/utilities/str;../../../../../devices/MIMXRT1052/utilities/debug_console;../../../../../middleware/freemaster/src/common;../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial;../../../../../middleware/freemaster/src/drivers/mcuxsdk/can;../../../../../middleware/freemaster/src/platforms/gen32le;../../../../../components/serial_manager;../../../../../components/lists;../../../../../components/serial_manager;../../../../../components/uart;../../../../../devices/MIMXRT1052/utilities;../../../../../devices/MIMXRT1052
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm misc: --cpreproc
  asm include: ../../../../../middleware/safety_iec60730b/safety/compiler;../../../../../middleware/safety_iec60730b/safety;../../../../../middleware/safety_iec60730b/safety/core_test/cm4_cm7;../../../../../middleware/safety_iec60730b/safety/core_test/cm4_cm7/register;../../../../../middleware/safety_iec60730b/safety/core_test/cm4_cm7/ram;../../../../../middleware/safety_iec60730b/safety/core_test/cm4_cm7/flash;../../../../../middleware/safety_iec60730b/safety/core_test/cm4_cm7/stack;../../../../../middleware/safety_iec60730b/safety/core_test/cm4_cm7/programCounter;../../../../../middleware/safety_iec60730b/safety/compiler/mdk;../../../../../middleware/safety_iec60730b/safety/common_test/wdog;../../../../../middleware/safety_iec60730b/safety/common_test/dio;../../../../../middleware/safety_iec60730b/safety/common_test/clock;../../../../../middleware/safety_iec60730b/safety/common_test/aio
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: linker/evkbimxrt1050_safety_ram.sct
  link misc: ../../../../../middleware/safety_iec60730b/safety/IEC60730_CM4_CM7_Class_B_KEIL_v4_0.lib --remove --library_type=standardlib
  group source
    ../: freemaster_cfg.h main_imxrt.c safety_test_items.h safety_test_items.c isr.h safety_config.h project_setup_evkbimxrt1050.h project_setup_evkbimxrt1050.c safety_cm7_imxrt.c safety_cm7_imxrt.h
  group doc
    ../: readme.txt
  group board
    ../: pin_mux.c pin_mux.h clock_config.c clock_config.h board.c board.h
  group linker
    linker/: evkbimxrt1050_safety_ram.sct evkbimxrt1050_safety.sct linker_config.h
  group device
    ../../../../../middleware/safety_iec60730b/boards/evkbimxrt1050/xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h
    ../../../../../devices/MIMXRT1052/: system_MIMXRT1052.c system_MIMXRT1052.h MIMXRT1052.h MIMXRT1052_features.h fsl_device_registers.h
  group GUI
    ../GUI/: safety_debug.pmp safety_release.pmp
  group cpu
    ../../../../../middleware/safety_iec60730b/boards/common/cm4_cm7/startup/cm7/: start.c startup_mdk.c vectors_mdk.c vectors_mdk.h
  group IEC60730_Class_B/aio
    ../../../../../middleware/safety_iec60730b/safety/common_test/aio/: iec60730b_aio.h
  group IEC60730_Class_B/clock
    ../../../../../middleware/safety_iec60730b/safety/common_test/clock/: iec60730b_clock.h
  group IEC60730_Class_B/dio
    ../../../../../middleware/safety_iec60730b/safety/common_test/dio/: iec60730b_dio.h iec60730b_dio_ext.h
  group IEC60730_Class_B/watchdog
    ../../../../../middleware/safety_iec60730b/safety/common_test/wdog/: iec60730b_wdog.c iec60730b_wdog.h
  group IEC60730_Class_B/compiler
    ../../../../../middleware/safety_iec60730b/safety/compiler/: asm_mac_common.h
    ../../../../../middleware/safety_iec60730b/safety/compiler/mdk/: linker_symbols.S
  group IEC60730_Class_B/flash
    ../../../../../middleware/safety_iec60730b/safety/core_test/cm4_cm7/flash/: iec60730b_cm4_cm7_flash.h
  group IEC60730_Class_B
    ../../../../../middleware/safety_iec60730b/safety/core_test/cm4_cm7/: iec60730b_core.h
    ../../../../../middleware/safety_iec60730b/safety/: iec60730b.h
  group IEC60730_Class_B/programCounter
    ../../../../../middleware/safety_iec60730b/safety/core_test/cm4_cm7/programCounter/: iec60730b_cm4_cm7_pc.h iec60730b_cm4_cm7_pc_object.S
  group IEC60730_Class_B/ram
    ../../../../../middleware/safety_iec60730b/safety/core_test/cm4_cm7/ram/: iec60730b_cm4_cm7_ram.h
  group IEC60730_Class_B/register
    ../../../../../middleware/safety_iec60730b/safety/core_test/cm4_cm7/register/: iec60730b_cm4_cm7_reg.h
  group IEC60730_Class_B/stack
    ../../../../../middleware/safety_iec60730b/safety/core_test/cm4_cm7/stack/: iec60730b_cm4_cm7_stack.h
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c
    ../../../../../devices/MIMXRT1052/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
  group freemaster
    ../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_can.c freemaster_can.h freemaster_defcfg.h freemaster_pdbdm.c freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_serial.c freemaster_serial.h freemaster_sha.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h
  group freemaster/drivers/mcuxsdk/can
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mcan.c freemaster_mcan.h freemaster_mscan.c freemaster_mscan.h
  group freemaster/drivers/mcuxsdk/serial
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_usb.c freemaster_serial_usb.h
  group freemaster/platforms
    ../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group component-uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
target safety_iec60730b release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.0.0
  cpu: as above
  output: safety_iec60730b.out +hex
  c flags: Optim=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: XIP_BOOT_HEADER_DCD_ENABLE=1, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, CPU_MIMXRT1052DVL6B, SKIP_SYSCLK_INIT, NDEBUG, SERIAL_PORT_TYPE_UART=1
  c misc: -U__GNUC__  -gdwarf-3
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm misc: --cpreproc
  asm include: as above
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: linker/evkbimxrt1050_safety.sct
  link misc: as above
