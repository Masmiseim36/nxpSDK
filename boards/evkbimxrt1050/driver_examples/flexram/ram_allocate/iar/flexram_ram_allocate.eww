<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>flexram_ram_allocate</project>
        <configuration>sdram_txt_debug</configuration>
      </member>
      <member>
        <project>flexram_ram_allocate</project>
        <configuration>sdram_txt_release</configuration>
      </member>
      <member>
        <project>flexram_ram_allocate</project>
        <configuration>flexspi_nor_sdram_debug</configuration>
      </member>
      <member>
        <project>flexram_ram_allocate</project>
        <configuration>flexspi_nor_sdram_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdram_txt_debug</name>
      <member>
        <project>flexram_ram_allocate</project>
        <configuration>sdram_txt_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdram_txt_release</name>
      <member>
        <project>flexram_ram_allocate</project>
        <configuration>sdram_txt_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_sdram_debug</name>
      <member>
        <project>flexram_ram_allocate</project>
        <configuration>flexspi_nor_sdram_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_sdram_release</name>
      <member>
        <project>flexram_ram_allocate</project>
        <configuration>flexspi_nor_sdram_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/flexram_ram_allocate.ewp</path>
  </project>
</workspace>
