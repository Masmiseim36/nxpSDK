# IAR project cmsis_nn_kws.ewp, settings and files
configuration flexspi_nor_sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1052DVL6B; BOARD_USE_CODEC=1; ARM_MATH_CM7; __FPU_PRESENT=1; SDK_I2C_BASED_COMPONENT_USED=1; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa093
  ICCARM.IExtraOptions: --enable_restrict  --diag_suppress Pe167  --diag_suppress Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../middleware/eiq/cmsis-nn/Examples/kws; ../../../../../middleware/eiq/cmsis-nn/Examples/kws/KWS; ../../../../../middleware/eiq/cmsis-nn/Examples/kws/KWS_NN; ../../../../../middleware/eiq/cmsis-nn/Examples/kws/local_NN; ../../../../../middleware/eiq/cmsis-nn/Examples/kws/MFCC; ..; ../../../../../middleware/eiq/cmsis-nn/Examples/common/source; ../../../../../components/codec/wm8960; ../../../../../components/codec; ../../../../../devices/MIMXRT1052/drivers; ../../../../../components/codec/port/wm8960; ../../../../../components/codec/i2c; ../../../../../components/i2c; ../../../../../middleware/eiq/cmsis-nn/Include; ../../../../../components/lists; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../devices/MIMXRT1052; ../../../../../devices/MIMXRT1052/xip; ../../../xip; ../../../../../devices/MIMXRT1052/utilities/str; ../../../../../devices/MIMXRT1052/utilities/debug_console; ../../../../../devices/MIMXRT1052/utilities
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: cmsis_nn_kws.out
  ILINK.IlinkConfigDefines: __stack_size__=0x10000; __heap_size__=0x800000
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor_sdram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1052DVL6B; BOARD_USE_CODEC=1; ARM_MATH_CM7; __FPU_PRESENT=1; SDK_I2C_BASED_COMPONENT_USED=1; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group doc
    ../../../../../middleware/eiq/cmsis-nn/Examples/kws/: off.wav right.wav
    ../: readme.txt
  group KWS
    ../../../../../middleware/eiq/cmsis-nn/Examples/kws/KWS/: kws.cpp kws.h kws_dnn.cpp kws_dnn.h kws_ds_cnn.cpp kws_ds_cnn.h
  group KWS_NN
    ../../../../../middleware/eiq/cmsis-nn/Examples/kws/KWS_NN/: dnn.cpp dnn.h dnn_weights.h ds_cnn.cpp ds_cnn.h ds_cnn_weights.h nn.cpp nn.h
  group local_NN
    ../../../../../middleware/eiq/cmsis-nn/Examples/kws/local_NN/: arm_avepool_q7_HWC_nonsquare.c local_NN.h
  group MFCC
    ../../../../../middleware/eiq/cmsis-nn/Examples/kws/MFCC/: mfcc.cpp mfcc.h
  group source
    ../../../../../middleware/eiq/cmsis-nn/Examples/kws/: commands.h main.cpp
    ../../../../../middleware/eiq/cmsis-nn/Examples/common/source/: timer.h timer.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group codec
    ../../../../../components/codec/wm8960/: fsl_wm8960.c fsl_wm8960.h
    ../../../../../components/codec/: fsl_codec_common.c fsl_codec_common.h
    ../../../../../components/codec/port/wm8960/: fsl_codec_adapter.c fsl_codec_adapter.h
    ../../../../../components/codec/i2c/: fsl_codec_i2c.c fsl_codec_i2c.h
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_common.c fsl_common.h fsl_sai.c fsl_sai.h fsl_lpuart.c fsl_lpuart.h fsl_clock.c fsl_clock.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h
  group component/i2c
    ../../../../../components/i2c/: i2c.h lpi2c_adapter.c
  group component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group component/uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group eiq/cmsis-nn
    ../../../../../middleware/eiq/cmsis-nn/: ChangeLogKSDK.txt
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
  group CMSIS/NN
    ../../../../../middleware/eiq/cmsis-nn/: LICENSE.txt readme.txt
  group CMSIS/NN/Include
    ../../../../../middleware/eiq/cmsis-nn/Include/: arm_nn_tables.h arm_nnfunctions.h arm_nnsupportfunctions.h
  group CMSIS/NN/ActivationFunctions
    ../../../../../middleware/eiq/cmsis-nn/Source/ActivationFunctions/: arm_nn_activations_q15.c arm_nn_activations_q7.c arm_relu_q15.c arm_relu_q7.c
  group CMSIS/NN/ConvolutionFunctions
    ../../../../../middleware/eiq/cmsis-nn/Source/ConvolutionFunctions/: arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_depthwise_conv_u8_basic_ver1.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c
  group CMSIS/NN/FullyConnectedFunctions
    ../../../../../middleware/eiq/cmsis-nn/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c
  group CMSIS/NN/NNSupportFunctions
    ../../../../../middleware/eiq/cmsis-nn/Source/NNSupportFunctions/: arm_nn_mult_q15.c arm_nn_mult_q7.c arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c
  group CMSIS/NN/PoolingFunctions
    ../../../../../middleware/eiq/cmsis-nn/Source/PoolingFunctions/: arm_pool_q7_HWC.c
  group CMSIS/NN/SoftmaxFunctions
    ../../../../../middleware/eiq/cmsis-nn/Source/SoftmaxFunctions/: arm_softmax_q15.c arm_softmax_q7.c
  group device
    ../../../../../devices/MIMXRT1052/: MIMXRT1052.h MIMXRT1052_features.h fsl_device_registers.h system_MIMXRT1052.c system_MIMXRT1052.h
  group startup
    ../../../../../devices/MIMXRT1052/iar/: startup_MIMXRT1052.s
  group xip
    ../../../../../devices/MIMXRT1052/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c
    ../../../../../devices/MIMXRT1052/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
