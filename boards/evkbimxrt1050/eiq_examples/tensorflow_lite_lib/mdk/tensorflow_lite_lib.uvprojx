# Keil uVision project tensorflow_lite_lib.uvprojx, settings and files
target tensorflow_lite_lib Debug (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: tensorflow-lite.lib (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=4 wLevel=2
  c define: DEBUG, __STDC_CONSTANT_MACROS, CPU_MIMXRT1052DVL6B, EIGEN_MPL2_ONLY, EIGEN_STACK_ALLOCATION_LIMIT=16384, FARMHASH_MCU, FARMHASH_LITTLE_ENDIAN, FARMHASH_NO_BUILTIN_EXPECT, FLATBUFFERS_LITTLEENDIAN, GEMMLOWP_MCU, TFLITE_MCU
  c misc: -Wno-c++98-compat-pedantic  -Wno-c++98-compat  -Wno-c99-extensions  -Wno-cast-qual  -Wno-comment  -Wno-conditional-uninitialized  -Wno-conversion  -Wno-covered-switch-default  -Wno-declaration-after-statement  -Wno-deprecated  -Wno-double-promotion  -Wno-exit-time-destructors  -Wno-extern-c-compat  -Wno-extra-semi  -Wno-extra-semi-stmt  -Wno-float-conversion  -Wno-float-equal  -Wno-format-nonliteral  -Wno-global-constructors  -Wno-inconsistent-missing-destructor-override  -Wno-missing-field-initializers  -Wno-missing-noreturn  -Wno-missing-prototypes  -Wno-missing-variable-declarations  -Wno-old-style-cast  -Wno-padded  -Wno-shadow  -Wno-shorten-64-to-32  -Wno-sign-compare  -Wno-sign-conversion  -Wno-switch-enum  -Wno-switch  -Wno-tautological-unsigned-enum-zero-compare  -Wno-typedef-redefinition  -Wno-undef  -Wno-undefined-func-template  -Wno-unknown-warning-option  -Wno-unreachable-code-break  -Wno-unreachable-code-return  -Wno-unreachable-code  -Wno-unused-local-typedef  -Wno-unused-parameter  -Wno-unused-private-field  -Wno-unused-variable  -Wno-used-but-marked-unused  -Wno-weak-vtables  -Wno-zero-as-null-pointer-constant
  c include: ../../../../../middleware/eiq/tensorflow-lite;../../../../../middleware/eiq/tensorflow-lite/third_party/eigen;../../../../../middleware/eiq/tensorflow-lite/third_party/farmhash;../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers;../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include;../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp
  asm define: DEBUG
  asm misc: --cpreproc_opts '-DDEBUG,-D__STARTUP_INITIALIZE_NONCACHEDATA'
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group tensorflow-lite
    ../../../../../middleware/eiq/tensorflow-lite/: AUTHORS LICENSE readme.txt
  group tensorflow-lite-tensorflow-contrib-lite
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/contrib/lite/: _string.h allocation.cc allocation.h arena_planner.cc arena_planner.h builtin_op_data.h builtin_ops.h context.c context.h context_util.h error_reporter.cc error_reporter.h graph_info.cc graph_info.h interpreter.cc interpreter.h memory_planner.h mmap_allocation_disabled.cc model.cc model.h nnapi_delegate.h nnapi_delegate_disabled.cc op_resolver.cc op_resolver.h optional_debug_tools.cc optional_debug_tools.h simple_memory_arena.cc simple_memory_arena.h string_util.cc string_util.h util.cc util.h version.h
  group tensorflow-lite-tensorflow-contrib-lite-kernels
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/contrib/lite/kernels/: activation_functor.h activations.cc add.cc arg_min_max.cc audio_spectrogram.cc basic_rnn.cc batch_to_space_nd.cc bidirectional_sequence_lstm.cc bidirectional_sequence_rnn.cc cast.cc comparisons.cc concatenation.cc conv.cc depthwise_conv.cc dequantize.cc detection_postprocess.cc div.cc eigen_support.cc eigen_support.h elementwise.cc embedding_lookup.cc embedding_lookup_sparse.cc exp.cc expand_dims.cc fake_quant.cc floor.cc floor_div.cc fully_connected.cc gather.cc gemm_support.cc gemm_support.h hashtable_lookup.cc kernel_util.cc kernel_util.h l2norm.cc local_response_norm.cc logical.cc lsh_projection.cc lstm.cc maximum_minimum.cc mfcc.cc mul.cc neg.cc one_hot.cc op_macros.h pack.cc pad.cc padding.h pooling.cc pow.cc reduce.cc register.cc register.h reshape.cc resize_bilinear.cc select.cc shape.cc skip_gram.cc slice.cc space_to_batch_nd.cc space_to_depth.cc sparse_to_dense.cc split.cc squeeze.cc strided_slice.cc sub.cc svdf.cc test_util.h tile.cc topk_v2.cc transpose.cc transpose_conv.cc unidirectional_sequence_lstm.cc unidirectional_sequence_rnn.cc unpack.cc
  group tensorflow-lite-tensorflow-contrib-lite-kernels-internal
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/contrib/lite/kernels/internal/: common.h compatibility.h kernel_utils.cc kernel_utils.h mfcc.h mfcc_dct.cc mfcc_dct.h mfcc_internal.cc mfcc_mel_filterbank.cc mfcc_mel_filterbank.h quantization_util.cc quantization_util.h round.h spectrogram.cc spectrogram.h strided_slice_logic.h tensor.h tensor_utils.cc tensor_utils.h test_util.h types.h
  group tensorflow-lite-tensorflow-contrib-lite-kernels-internal-optimized
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/contrib/lite/kernels/internal/optimized/: cblas_conv.h cblas_reference.h cpu_check.h depthwiseconv_float.h depthwiseconv_uint8.h depthwiseconv_uint8_3x3_filter.h eigen_spatial_convolutions.h eigen_tensor_reduced_instantiations_google.h eigen_tensor_reduced_instantiations_oss.h legacy_optimized_ops.h multithreaded_conv.h neon_tensor_utils.cc neon_tensor_utils.h optimized_ops.h tensor_utils_impl.h
  group tensorflow-lite-tensorflow-contrib-lite-kernels-internal-reference
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/contrib/lite/kernels/internal/reference/: depthwiseconv_float.h depthwiseconv_uint8.h legacy_reference_ops.h portable_tensor_utils.cc portable_tensor_utils.h reference_ops.h
  group tensorflow-lite-tensorflow-contrib-lite-nnapi
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/contrib/lite/nnapi/: NeuralNetworksShim.h
  group tensorflow-lite-tensorflow-contrib-lite-profiling
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/contrib/lite/profiling/: _time.h profile_buffer.h profile_summarizer.cc profile_summarizer.h profiler.h time.cc
  group tensorflow-lite-tensorflow-contrib-lite-schema
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/contrib/lite/schema/: schema_generated.h
  group tensorflow-lite-tensorflow-core-util
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/core/util/: stat_summarizer_options.h stats_calculator.h
  group tensorflow-lite-third_party-eigen
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/: COPYING.BSD COPYING.LGPL COPYING.MINPACK COPYING.MPL2 COPYING.README Empty.h README.md
  group tensorflow-lite-third_party-eigen-Eigen
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/: Cholesky CholmodSupport Core Dense Eigen Eigenvalues Geometry Householder IterativeLinearSolvers Jacobi KLUSupport LU MetisSupport OrderingMethods PaStiXSupport PardisoSupport QR QtAlignedMalloc SPQRSupport SVD Sparse SparseCholesky SparseCore SparseLU SparseQR StdDeque StdList StdVector SuperLUSupport UmfPackSupport
  group tensorflow-lite-third_party-eigen-Eigen-src-Cholesky
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Cholesky/: LDLT.h LLT.h LLT_LAPACKE.h
  group tensorflow-lite-third_party-eigen-Eigen-src-CholmodSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/CholmodSupport/: CholmodSupport.h
  group tensorflow-lite-third_party-eigen-Eigen-src-Core
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/: ArithmeticSequence.h Array.h ArrayBase.h ArrayWrapper.h Assign.h AssignEvaluator.h Assign_MKL.h BandMatrix.h Block.h BooleanRedux.h CommaInitializer.h ConditionEstimator.h CoreEvaluators.h CoreIterators.h CwiseBinaryOp.h CwiseNullaryOp.h CwiseTernaryOp.h CwiseUnaryOp.h CwiseUnaryView.h DenseBase.h DenseCoeffsBase.h DenseStorage.h Diagonal.h DiagonalMatrix.h DiagonalProduct.h Dot.h EigenBase.h ForceAlignedAccess.h Fuzzy.h GeneralProduct.h GenericPacketMath.h GlobalFunctions.h IO.h IndexedView.h Inverse.h Map.h MapBase.h MathFunctions.h MathFunctionsImpl.h Matrix.h MatrixBase.h NestByValue.h NoAlias.h NumTraits.h PermutationMatrix.h PlainObjectBase.h Product.h ProductEvaluators.h Random.h Redux.h Ref.h Replicate.h ReturnByValue.h Reverse.h Select.h SelfAdjointView.h SelfCwiseBinaryOp.h Solve.h SolveTriangular.h SolverBase.h StableNorm.h Stride.h Swap.h Transpose.h Transpositions.h TriangularMatrix.h VectorBlock.h VectorwiseOp.h Visitor.h
  group tensorflow-lite-third_party-eigen-Eigen-src-Core-arch-AVX
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/AVX/: Complex.h MathFunctions.h PacketMath.h TypeCasting.h
  group tensorflow-lite-third_party-eigen-Eigen-src-Core-arch-AVX512
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/AVX512/: MathFunctions.h PacketMath.h
  group tensorflow-lite-third_party-eigen-Eigen-src-Core-arch-AltiVec
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/AltiVec/: Complex.h MathFunctions.h PacketMath.h
  group tensorflow-lite-third_party-eigen-Eigen-src-Core-arch-CUDA
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/CUDA/: Complex.h Half.h MathFunctions.h PacketMath.h PacketMathHalf.h TypeCasting.h
  group tensorflow-lite-third_party-eigen-Eigen-src-Core-arch-Default
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/Default/: ConjHelper.h Settings.h
  group tensorflow-lite-third_party-eigen-Eigen-src-Core-arch-NEON
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/NEON/: Complex.h MathFunctions.h PacketMath.h
  group tensorflow-lite-third_party-eigen-Eigen-src-Core-arch-SSE
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/SSE/: Complex.h MathFunctions.h PacketMath.h TypeCasting.h
  group tensorflow-lite-third_party-eigen-Eigen-src-Core-arch-ZVector
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/ZVector/: Complex.h MathFunctions.h PacketMath.h
  group tensorflow-lite-third_party-eigen-Eigen-src-Core-functors
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/functors/: AssignmentFunctors.h BinaryFunctors.h NullaryFunctors.h StlFunctors.h TernaryFunctors.h UnaryFunctors.h
  group tensorflow-lite-third_party-eigen-Eigen-src-Core-products
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/products/: GeneralBlockPanelKernel.h GeneralMatrixMatrix.h GeneralMatrixMatrixTriangular.h GeneralMatrixMatrixTriangular_BLAS.h GeneralMatrixMatrix_BLAS.h GeneralMatrixVector.h GeneralMatrixVector_BLAS.h Parallelizer.h SelfadjointMatrixMatrix.h SelfadjointMatrixMatrix_BLAS.h SelfadjointMatrixVector.h SelfadjointMatrixVector_BLAS.h SelfadjointProduct.h SelfadjointRank2Update.h TriangularMatrixMatrix.h TriangularMatrixMatrix_BLAS.h TriangularMatrixVector.h TriangularMatrixVector_BLAS.h TriangularSolverMatrix.h TriangularSolverMatrix_BLAS.h TriangularSolverVector.h
  group tensorflow-lite-third_party-eigen-Eigen-src-Core-util
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/util/: BlasUtil.h Constants.h DisableStupidWarnings.h ForwardDeclarations.h IndexedViewHelper.h IntegralConstant.h MKL_support.h Macros.h Memory.h Meta.h NonMPL2.h ReenableStupidWarnings.h StaticAssert.h SymbolicIndex.h XprHelper.h
  group tensorflow-lite-third_party-eigen-Eigen-src-Eigenvalues
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Eigenvalues/: ComplexEigenSolver.h ComplexSchur.h ComplexSchur_LAPACKE.h EigenSolver.h GeneralizedEigenSolver.h GeneralizedSelfAdjointEigenSolver.h HessenbergDecomposition.h MatrixBaseEigenvalues.h RealQZ.h RealSchur.h RealSchur_LAPACKE.h SelfAdjointEigenSolver.h SelfAdjointEigenSolver_LAPACKE.h Tridiagonalization.h
  group tensorflow-lite-third_party-eigen-Eigen-src-Geometry
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Geometry/: AlignedBox.h AngleAxis.h EulerAngles.h Homogeneous.h Hyperplane.h OrthoMethods.h ParametrizedLine.h Quaternion.h Rotation2D.h RotationBase.h Scaling.h Transform.h Translation.h Umeyama.h
  group tensorflow-lite-third_party-eigen-Eigen-src-Geometry-arch
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Geometry/arch/: Geometry_SSE.h
  group tensorflow-lite-third_party-eigen-Eigen-src-Householder
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Householder/: BlockHouseholder.h Householder.h HouseholderSequence.h
  group tensorflow-lite-third_party-eigen-Eigen-src-IterativeLinearSolvers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/IterativeLinearSolvers/: BasicPreconditioners.h BiCGSTAB.h ConjugateGradient.h IncompleteCholesky.h IterativeSolverBase.h LeastSquareConjugateGradient.h SolveWithGuess.h
  group tensorflow-lite-third_party-eigen-Eigen-src-Jacobi
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Jacobi/: Jacobi.h
  group tensorflow-lite-third_party-eigen-Eigen-src-KLUSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/KLUSupport/: KLUSupport.h
  group tensorflow-lite-third_party-eigen-Eigen-src-LU
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/LU/: Determinant.h FullPivLU.h InverseImpl.h PartialPivLU.h PartialPivLU_LAPACKE.h
  group tensorflow-lite-third_party-eigen-Eigen-src-LU-arch
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/LU/arch/: Inverse_SSE.h
  group tensorflow-lite-third_party-eigen-Eigen-src-MetisSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/MetisSupport/: MetisSupport.h
  group tensorflow-lite-third_party-eigen-Eigen-src-OrderingMethods
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/OrderingMethods/: Eigen_Colamd.h Ordering.h
  group tensorflow-lite-third_party-eigen-Eigen-src-PaStiXSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/PaStiXSupport/: PaStiXSupport.h
  group tensorflow-lite-third_party-eigen-Eigen-src-PardisoSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/PardisoSupport/: PardisoSupport.h
  group tensorflow-lite-third_party-eigen-Eigen-src-QR
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/QR/: ColPivHouseholderQR.h ColPivHouseholderQR_LAPACKE.h CompleteOrthogonalDecomposition.h FullPivHouseholderQR.h HouseholderQR.h HouseholderQR_LAPACKE.h
  group tensorflow-lite-third_party-eigen-Eigen-src-SPQRSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/SPQRSupport/: SuiteSparseQRSupport.h
  group tensorflow-lite-third_party-eigen-Eigen-src-SVD
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/SVD/: BDCSVD.h JacobiSVD.h JacobiSVD_LAPACKE.h SVDBase.h UpperBidiagonalization.h
  group tensorflow-lite-third_party-eigen-Eigen-src-SparseCholesky
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/SparseCholesky/: SimplicialCholesky.h
  group tensorflow-lite-third_party-eigen-Eigen-src-SparseCore
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/SparseCore/: AmbiVector.h CompressedStorage.h ConservativeSparseSparseProduct.h MappedSparseMatrix.h SparseAssign.h SparseBlock.h SparseColEtree.h SparseCompressedBase.h SparseCwiseBinaryOp.h SparseCwiseUnaryOp.h SparseDenseProduct.h SparseDiagonalProduct.h SparseDot.h SparseFuzzy.h SparseMap.h SparseMatrix.h SparseMatrixBase.h SparsePermutation.h SparseProduct.h SparseRedux.h SparseRef.h SparseSelfAdjointView.h SparseSolverBase.h SparseSparseProductWithPruning.h SparseTranspose.h SparseTriangularView.h SparseUtil.h SparseVector.h SparseView.h TriangularSolver.h
  group tensorflow-lite-third_party-eigen-Eigen-src-SparseLU
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/SparseLU/: SparseLU.h SparseLUImpl.h SparseLU_Memory.h SparseLU_Structs.h SparseLU_SupernodalMatrix.h SparseLU_Utils.h SparseLU_column_bmod.h SparseLU_column_dfs.h SparseLU_copy_to_ucol.h SparseLU_gemm_kernel.h SparseLU_heap_relax_snode.h SparseLU_kernel_bmod.h SparseLU_panel_bmod.h SparseLU_panel_dfs.h SparseLU_pivotL.h SparseLU_pruneL.h SparseLU_relax_snode.h
  group tensorflow-lite-third_party-eigen-Eigen-src-SparseQR
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/SparseQR/: SparseQR.h
  group tensorflow-lite-third_party-eigen-Eigen-src-StlSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/StlSupport/: StdDeque.h StdList.h StdVector.h details.h
  group tensorflow-lite-third_party-eigen-Eigen-src-SuperLUSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/SuperLUSupport/: SuperLUSupport.h
  group tensorflow-lite-third_party-eigen-Eigen-src-UmfPackSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/UmfPackSupport/: UmfPackSupport.h
  group tensorflow-lite-third_party-eigen-Eigen-src-misc
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/misc/: Image.h Kernel.h RealSvd2x2.h blas.h lapack.h lapacke.h lapacke_mangling.h
  group tensorflow-lite-third_party-eigen-Eigen-src-plugins
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/plugins/: ArrayCwiseBinaryOps.h ArrayCwiseUnaryOps.h BlockMethods.h CommonCwiseBinaryOps.h CommonCwiseUnaryOps.h IndexedViewMethods.h MatrixCwiseBinaryOps.h MatrixCwiseUnaryOps.h
  group tensorflow-lite-third_party-eigen-blas
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/blas/: BandTriangularSolver.h GeneralRank1Update.h PackedSelfadjointProduct.h PackedTriangularMatrixVector.h PackedTriangularSolverVector.h Rank2Update.h common.h level1_cplx_impl.h level1_impl.h level1_real_impl.h level2_cplx_impl.h level2_impl.h level2_real_impl.h level3_impl.h
  group tensorflow-lite-third_party-eigen-blas-f2c
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/blas/f2c/: datatypes.h
  group tensorflow-lite-third_party-eigen-unsupported-Eigen
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/: AdolcForward AlignedVector3 ArpackSupport AutoDiff BVH EulerAngles IterativeSolvers KroneckerProduct LevenbergMarquardt MatrixFunctions MoreVectorization NonLinearOptimization NumericalDiff OpenGLSupport Polynomials Skyline SparseExtra SpecialFunctions Splines
  group tensorflow-lite-third_party-eigen-unsupported-Eigen-CXX11
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/: Tensor TensorSymmetry ThreadPool
  group tensorflow-lite-third_party-eigen-unsupported-Eigen-CXX11-src-Tensor
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/Tensor/: Tensor.h TensorArgMax.h TensorArgMaxSycl.h TensorAssign.h TensorBase.h TensorBroadcasting.h TensorChipping.h TensorConcatenation.h TensorContraction.h TensorContractionBlocking.h TensorContractionCuda.h TensorContractionMapper.h TensorContractionSycl.h TensorContractionThreadPool.h TensorConversion.h TensorConvolution.h TensorConvolutionSycl.h TensorCostModel.h TensorCustomOp.h TensorDevice.h TensorDeviceCuda.h TensorDeviceDefault.h TensorDeviceSycl.h TensorDeviceThreadPool.h TensorDimensionList.h TensorDimensions.h TensorEvalTo.h TensorEvaluator.h TensorExecutor.h TensorExpr.h TensorFFT.h TensorFixedSize.h TensorForcedEval.h TensorForwardDeclarations.h TensorFunctors.h TensorGenerator.h TensorGlobalFunctions.h TensorIO.h TensorImagePatch.h TensorIndexList.h TensorInflation.h TensorInitializer.h TensorIntDiv.h TensorLayoutSwap.h TensorMacros.h TensorMap.h TensorMeta.h TensorMorphing.h TensorPadding.h TensorPatch.h TensorRandom.h TensorReduction.h TensorReductionCuda.h TensorReductionSycl.h TensorRef.h TensorReverse.h TensorScan.h TensorShuffling.h TensorStorage.h TensorStriding.h TensorSycl.h TensorSyclConvertToDeviceExpression.h TensorSyclExprConstructor.h TensorSyclExtractAccessor.h TensorSyclExtractFunctors.h TensorSyclFunctors.h TensorSyclLeafCount.h TensorSyclPlaceHolderExpr.h TensorSyclRun.h TensorSyclTuple.h TensorTrace.h TensorTraits.h TensorUInt128.h TensorVolumePatch.h
  group tensorflow-lite-third_party-eigen-unsupported-Eigen-CXX11-src-TensorSymmetry
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/TensorSymmetry/: DynamicSymmetry.h StaticSymmetry.h Symmetry.h
  group tensorflow-lite-third_party-eigen-unsupported-Eigen-CXX11-src-TensorSymmetry-util
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/TensorSymmetry/util/: TemplateGroupTheory.h
  group tensorflow-lite-third_party-eigen-unsupported-Eigen-CXX11-src-ThreadPool
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/ThreadPool/: EventCount.h NonBlockingThreadPool.h RunQueue.h SimpleThreadPool.h ThreadCancel.h ThreadEnvironment.h ThreadLocal.h ThreadPoolInterface.h ThreadYield.h
  group tensorflow-lite-third_party-eigen-unsupported-Eigen-CXX11-src-util
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/util/: CXX11Meta.h CXX11Workarounds.h EmulateArray.h EmulateCXX11Meta.h MaxSizeVector.h
  group tensorflow-lite-third_party-eigen-unsupported-Eigen-src-AutoDiff
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/AutoDiff/: AutoDiffJacobian.h AutoDiffScalar.h AutoDiffVector.h
  group tensorflow-lite-third_party-eigen-unsupported-Eigen-src-BVH
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/BVH/: BVAlgorithms.h KdBVH.h
  group tensorflow-lite-third_party-eigen-unsupported-Eigen-src-EulerAngles
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/EulerAngles/: EulerAngles.h EulerSystem.h
  group tensorflow-lite-third_party-eigen-unsupported-Eigen-src-FFT
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/FFT/: ei_fftw_impl.h ei_kissfft_impl.h
  group tensorflow-lite-third_party-eigen-unsupported-Eigen-src-IterativeSolvers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/IterativeSolvers/: DGMRES.h GMRES.h IncompleteLU.h MINRES.h Scaling.h
  group tensorflow-lite-third_party-eigen-unsupported-Eigen-src-KroneckerProduct
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/KroneckerProduct/: KroneckerTensorProduct.h
  group tensorflow-lite-third_party-eigen-unsupported-Eigen-src-LevenbergMarquardt
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/LevenbergMarquardt/: LMcovar.h LMonestep.h LMpar.h LMqrsolv.h LevenbergMarquardt.h
  group tensorflow-lite-third_party-eigen-unsupported-Eigen-src-MatrixFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/MatrixFunctions/: MatrixExponential.h MatrixFunction.h MatrixLogarithm.h MatrixPower.h MatrixSquareRoot.h StemFunction.h
  group tensorflow-lite-third_party-eigen-unsupported-Eigen-src-MoreVectorization
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/MoreVectorization/: MathFunctions.h
  group tensorflow-lite-third_party-eigen-unsupported-Eigen-src-NonLinearOptimization
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/NonLinearOptimization/: HybridNonLinearSolver.h LevenbergMarquardt.h chkder.h covar.h dogleg.h fdjac1.h lmpar.h qrsolv.h r1mpyq.h r1updt.h rwupdt.h
  group tensorflow-lite-third_party-eigen-unsupported-Eigen-src-NumericalDiff
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/NumericalDiff/: NumericalDiff.h
  group tensorflow-lite-third_party-eigen-unsupported-Eigen-src-Polynomials
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/Polynomials/: Companion.h PolynomialSolver.h PolynomialUtils.h
  group tensorflow-lite-third_party-eigen-unsupported-Eigen-src-Skyline
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/Skyline/: SkylineInplaceLU.h SkylineMatrix.h SkylineMatrixBase.h SkylineProduct.h SkylineStorage.h SkylineUtil.h
  group tensorflow-lite-third_party-eigen-unsupported-Eigen-src-SparseExtra
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/SparseExtra/: BlockOfDynamicSparseMatrix.h BlockSparseMatrix.h DynamicSparseMatrix.h MarketIO.h MatrixMarketIterator.h RandomSetter.h
  group tensorflow-lite-third_party-eigen-unsupported-Eigen-src-SpecialFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/SpecialFunctions/: SpecialFunctionsArrayAPI.h SpecialFunctionsFunctors.h SpecialFunctionsHalf.h SpecialFunctionsImpl.h SpecialFunctionsPacketMath.h
  group tensorflow-lite-third_party-eigen-unsupported-Eigen-src-SpecialFunctions-arch-CUDA
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/SpecialFunctions/arch/CUDA/: CudaSpecialFunctions.h
  group tensorflow-lite-third_party-eigen-unsupported-Eigen-src-Splines
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/Splines/: Spline.h SplineFitting.h SplineFwd.h
  group tensorflow-lite-third_party-eigen3-Eigen
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen3/Eigen/: Cholesky Core Eigenvalues LU QR SVD
  group tensorflow-lite-third_party-eigen3
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen3/: LICENSE
  group tensorflow-lite-third_party-eigen3-unsupported-Eigen-CXX11
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen3/unsupported/Eigen/CXX11/: Core FixedPoint NeuralNetworks Tensor ThreadPool
  group tensorflow-lite-third_party-eigen3-unsupported-Eigen-CXX11-src-FixedPoint
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen3/unsupported/Eigen/CXX11/src/FixedPoint/: FixedPointTypes.h MatMatProduct.h MatMatProductAVX2.h MatMatProductNEON.h MatVecProduct.h PacketMathAVX2.h PacketMathAVX512.h TypeCastingAVX2.h TypeCastingAVX512.h
  group tensorflow-lite-third_party-eigen3-unsupported-Eigen-CXX11-src-NeuralNetworks
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen3/unsupported/Eigen/CXX11/src/NeuralNetworks/: Activations.h Attention.h BackwardCuboidConvolutions.h BackwardSpatialConvolutions.h CuboidConvolution.h Patch3d.h Pooling.h SoftMax.h SpatialConvolutions.h TensorConvolutionByFFT.h
  group tensorflow-lite-third_party-eigen3-unsupported-Eigen
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen3/unsupported/Eigen/: MatrixFunctions SpecialFunctions
  group tensorflow-lite-third_party-farmhash
    ../../../../../middleware/eiq/tensorflow-lite/third_party/farmhash/: COPYING farmhash.cc farmhash.h
  group tensorflow-lite-third_party-fft2d
    ../../../../../middleware/eiq/tensorflow-lite/third_party/fft2d/: fft.h fftsg.c readme.txt
  group tensorflow-lite-third_party-flatbuffers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/: LICENSE.txt readme.md
  group tensorflow-lite-third_party-flatbuffers-include-flatbuffers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/: base.h code_generators.h flatbuffers.h flexbuffers.h hash.h idl.h minireflect.h reflection.h reflection_generated.h registry.h stl_emulation.h util.h
  group tensorflow-lite-third_party-gemmlowp
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/: AUTHORS CONTRIBUTORS LICENSE README.md
  group tensorflow-lite-third_party-gemmlowp-eight_bit_int_gemm
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/eight_bit_int_gemm/: eight_bit_int_gemm.h
  group tensorflow-lite-third_party-gemmlowp-fixedpoint
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint/: fixedpoint.h fixedpoint_msa.h fixedpoint_neon.h fixedpoint_sse.h
  group tensorflow-lite-third_party-gemmlowp-internal
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/internal/: allocator.h block_params.h common.h compute.h dispatch_gemm_shape.h kernel.h kernel_default.h kernel_dsp.h kernel_msa.h kernel_neon.h kernel_reference.h kernel_sse.h multi_thread_gemm.h output.h output_msa.h output_neon.h output_sse.h pack.h pack_msa.h pack_neon.h pack_sse.h platform.h simd_wrappers.h simd_wrappers_common_neon_sse.h simd_wrappers_msa.h simd_wrappers_neon.h simd_wrappers_sse.h single_thread_gemm.h unpack.h
  group tensorflow-lite-third_party-gemmlowp-meta
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/meta/: base.h legacy_multi_thread_common.h legacy_multi_thread_gemm.h legacy_multi_thread_gemv.h legacy_operations_common.h legacy_single_thread_gemm.h multi_thread_common.h multi_thread_gemm.h multi_thread_transform.h quantized_mul_kernels.h quantized_mul_kernels_arm_32.h quantized_mul_kernels_arm_64.h single_thread_gemm.h single_thread_transform.h streams.h streams_arm_32.h streams_arm_64.h transform_kernels.h transform_kernels_arm_32.h transform_kernels_arm_64.h
  group tensorflow-lite-third_party-gemmlowp-profiling
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/profiling/: instrumentation.h profiler.h pthread_everywhere.h
  group tensorflow-lite-third_party-gemmlowp-public
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/public/: bit_depth.h gemmlowp.h map.h output_stages.h
target tensorflow_lite_lib Release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: tensorflow-lite.lib (library)
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=4
  c define: NDEBUG, __STDC_CONSTANT_MACROS, CPU_MIMXRT1052DVL6B, EIGEN_MPL2_ONLY, EIGEN_STACK_ALLOCATION_LIMIT=16384, FARMHASH_MCU, FARMHASH_LITTLE_ENDIAN, FARMHASH_NO_BUILTIN_EXPECT, FLATBUFFERS_LITTLEENDIAN, GEMMLOWP_MCU, TFLITE_MCU
  c misc: -fno-exceptions  -Wno-c++98-compat-pedantic  -Wno-c++98-compat  -Wno-c99-extensions  -Wno-cast-qual  -Wno-comment  -Wno-conditional-uninitialized  -Wno-conversion  -Wno-covered-switch-default  -Wno-declaration-after-statement  -Wno-deprecated  -Wno-double-promotion  -Wno-exit-time-destructors  -Wno-extern-c-compat  -Wno-extra-semi  -Wno-extra-semi-stmt  -Wno-float-conversion  -Wno-float-equal  -Wno-format-nonliteral  -Wno-global-constructors  -Wno-inconsistent-missing-destructor-override  -Wno-missing-field-initializers  -Wno-missing-noreturn  -Wno-missing-prototypes  -Wno-missing-variable-declarations  -Wno-old-style-cast  -Wno-padded  -Wno-shadow  -Wno-shorten-64-to-32  -Wno-sign-compare  -Wno-sign-conversion  -Wno-switch-enum  -Wno-switch  -Wno-tautological-unsigned-enum-zero-compare  -Wno-typedef-redefinition  -Wno-undef  -Wno-undefined-func-template  -Wno-unknown-warning-option  -Wno-unreachable-code-break  -Wno-unreachable-code-return  -Wno-unreachable-code  -Wno-unused-local-typedef  -Wno-unused-parameter  -Wno-unused-private-field  -Wno-unused-variable  -Wno-used-but-marked-unused  -Wno-weak-vtables  -Wno-zero-as-null-pointer-constant
  c include: as above
  asm define: NDEBUG
  asm misc: --cpreproc_opts '-DNDEBUG,-D__STARTUP_INITIALIZE_NONCACHEDATA'
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
