# Keil uVision project tensorflow_lite_micro_label_image.uvprojx, settings and files
target tensorflow_lite_micro_label_image flexspi_nor_sdram_debug (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: tensorflow_lite_micro_label_image.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, DEBUG, __STDC_CONSTANT_MACROS, __CLK_TCK=1000000, CPU_MIMXRT1052DVL6B, SDK_DEBUGCONSOLE_UART, ARM_MATH_CM7, __FPU_PRESENT=1, SDK_I2C_BASED_COMPONENT_USED=1, SDK_I2C_BASED_COMPONENT_USED=1, FLATBUFFERS_LITTLEENDIAN, GEMMLOWP_MCU, RUY_MCU, TFLITE_MCU, TF_LITE_STATIC_MEMORY
  c misc: -fno-exceptions  -Wno-c++17-extensions  -fno-common  -fdata-sections  -mthumb
  c include: ../../../../../middleware/eiq/tensorflow-lite/examples/micro/label_image;../../../../../middleware/eiq/tensorflow-lite/examples/image/label_image;../../../../../middleware/eiq/common/image;../../../../../middleware/eiq/common/model;..;../../../../../components/video/camera/device;../../../../../components/video/camera/receiver;../../../../../components/video/camera/device/sccb;../../../../../components/video/camera/device/ov7725;../../../../../components/video/camera/device/mt9m114;../../../../../components/video/camera;../../../../../components/video/camera/receiver/csi;../../../../../devices/MIMXRT1052/drivers;../../../../../components/video;../../../../../components/video/i2c;../../../../../components/video/display/dc;../../../../../components/video/display/dc/elcdif;../../../../../devices/MIMXRT1052/utilities/debug_console_lite;../../../../../middleware/eiq/tensorflow-lite;../../../../../middleware/eiq/common/video;../../../../../components/lists;../../../../../components/uart;../../../../../devices/MIMXRT1052;../../../../../devices/MIMXRT1052/xip;../../../xip;../../../../../CMSIS/Include;../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis;../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include;../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp;../../../../../middleware/eiq/tensorflow-lite/third_party;../../../../../middleware/eiq/common
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ../../../../../devices/MIMXRT1052/arm/MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: --remove --predefine="-D__stack_size__=0x10000" --predefine="-D__heap_size__=0x800000" --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group source/image
    ../../../../../middleware/eiq/common/image/: image_conv.c image.h image_capture.c image_decode_raw.c image_resize_nearest.c image_draw.c image_utils.h
    ../../../../../middleware/eiq/tensorflow-lite/examples/micro/label_image/: image_data.h
  group board
    ../../../../../middleware/eiq/common/: board_init.h
    ../: pin_mux.c pin_mux.h board.c board.h board_init.c clock_config.c clock_config.h dcd.c dcd.h
    ./: retarget.c
  group source
    ../../../../../middleware/eiq/common/: demo_info.h timer.h timer.c eiq_common.h eiq_iui.h eiq_iworker.h
    ../../../../../middleware/eiq/tensorflow-lite/examples/micro/label_image/: demo_config.h demo_info.cpp
    ../../../../../middleware/eiq/tensorflow-lite/examples/image/label_image/: labels.h
    ../../../../../middleware/eiq/tensorflow-lite/examples/image/: main.cpp
  group source/model
    ../../../../../middleware/eiq/common/model/: get_top_n.cpp get_top_n.h model.h output_postproc.h
    ../../../../../middleware/eiq/tensorflow-lite/examples/common/model/: output_postproc.cpp
    ../../../../../middleware/eiq/tensorflow-lite/examples/micro/label_image/: model.cpp model_mobilenet_ops_micro.cpp
    ../../../../../middleware/eiq/tensorflow-lite/examples/image/label_image/: model_data.h
  group doc
    ../../../../../middleware/eiq/tensorflow-lite/examples/image/label_image/: labels.txt mobilenet_v1_0.25_128_quant_int8.tflite stopwatch.bmp
    ../: readme.txt
  group video
    ../../../../../components/video/camera/device/: fsl_camera_device.h
    ../../../../../components/video/camera/receiver/: fsl_camera_receiver.h
    ../../../../../components/video/camera/device/sccb/: fsl_sccb.h fsl_sccb.c
    ../../../../../components/video/camera/device/ov7725/: fsl_ov7725.h fsl_ov7725.c
    ../../../../../components/video/camera/device/mt9m114/: fsl_mt9m114.h fsl_mt9m114.c
    ../../../../../components/video/camera/: fsl_camera.h
    ../../../../../components/video/camera/receiver/csi/: fsl_csi_camera_adapter.h fsl_csi_camera_adapter.c
    ../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../components/video/i2c/: fsl_video_i2c.h fsl_video_i2c.c
    ../../../../../components/video/display/dc/: fsl_dc_fb.h
    ../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.h fsl_dc_fb_elcdif.c
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_csi.c fsl_csi.h fsl_elcdif.c fsl_elcdif.h fsl_pxp.c fsl_pxp.h fsl_gpio.h fsl_gpio.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group eiq/tensorflow-lite/tensorflow/core/public
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/core/public/: version.h
  group eiq/tensorflow-lite/tensorflow/lite
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/: type_to_tflitetype.h version.h string_type.h string_util.h string_util.cpp
  group eiq/tensorflow-lite/tensorflow/lite/c
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/c/: common.h common.c builtin_op_data.h
  group eiq/tensorflow-lite/tensorflow/lite/core/api
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/api/: op_resolver.h profiler.h flatbuffer_conversions.h error_reporter.h tensor_utils.h op_resolver.cpp flatbuffer_conversions.cpp tensor_utils_.cpp error_reporter.cpp
  group eiq/tensorflow-lite/tensorflow/lite/kernels
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/: kernel_util.h kernel_util.cpp op_macros.h padding.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/: common.h compatibility.h cppmath.h max.h min.h quantization_util.h quantization_util.cpp strided_slice_logic.h tensor.h tensor_ctypes.h types.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized/: neon_check.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/: add.h arg_min_max.h ceil.h comparisons.h concatenation.h conv.h depthwiseconv_float.h depthwiseconv_uint8.h dequantize.h process_broadcast_shapes.h quantize.h requantize.h floor.h fully_connected.h l2normalization.h binary_function.h logistic.h maximum_minimum.h mul.h neg.h pad.h pooling.h prelu.h reduce.h resize_nearest_neighbor.h round.h softmax.h strided_slice.h sub.h tanh.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops/: add.h conv.h depthwise_conv.h fully_connected.h l2normalization.h logistic.h mul.h pooling.h tanh.h
  group eiq/tensorflow-lite/tensorflow/lite/micro
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/: compatibility.h debug_log.h micro_optional_debug_tools.h micro_utils.h micro_interpreter.h recording_micro_interpreter.h recording_simple_memory_allocator.h simple_memory_allocator.h micro_mutable_op_resolver.h memory_helpers.h all_ops_resolver.h micro_allocator.h micro_profiler.h micro_error_reporter.h recording_micro_allocator.h micro_time.h micro_op_resolver.h micro_string.h recording_micro_allocator.cpp debug_log.cpp memory_helpers.cpp micro_error_reporter.cpp micro_utils.cpp all_ops_resolver.cpp micro_string.cpp micro_profiler.cpp micro_time.cpp micro_allocator.cpp simple_memory_allocator.cpp micro_interpreter.cpp micro_optional_debug_tools.cpp recording_simple_memory_allocator.cpp
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/: micro_utils.h micro_ops.h activation_utils.h activations.cpp arg_min_max.cpp ceil.cpp circular_buffer.cpp comparisons.cpp concatenation.cpp dequantize.cpp elementwise.cpp ethosu.cpp floor.cpp l2norm.cpp logical.cpp logistic.cpp maximum_minimum.cpp neg.cpp pack.cpp pad.cpp prelu.cpp quantize.cpp reduce.cpp reshape.cpp resize_nearest_neighbor.cpp round.cpp split.cpp strided_slice.cpp sub.cpp svdf.cpp tanh.cpp unpack.cpp
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels/cmsis-nn
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/cmsis-nn/: conv.cpp add.cpp softmax.cpp fully_connected.cpp depthwise_conv.cpp mul.cpp pooling.cpp
  group eiq/tensorflow-lite/tensorflow/lite/micro/memory_planner
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/memory_planner/: linear_memory_planner.h memory_planner.h greedy_memory_planner.h linear_memory_planner.cpp greedy_memory_planner.cpp
  group eiq/tensorflow-lite/tensorflow/lite/schema
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/schema/: schema_generated.h
  group source/video
    ../../../../../middleware/eiq/common/video/camera/MT9M114_OV7725/: eiq_camera_conf.c
    ../../../../../middleware/eiq/common/video/display/RK043FN02HC/: eiq_display_conf.c
    ../../../../../middleware/eiq/common/video/: eiq_camera.c eiq_pxp.c eiq_video_worker.c eiq_display.c eiq_camera_conf.h eiq_display.h eiq_video_worker.h eiq_camera.h eiq_display_conf.h eiq_pxp.h
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group device
    ../../../../../devices/MIMXRT1052/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.c system_MIMXRT1052.h
  group startup
    ../../../../../devices/MIMXRT1052/arm/: startup_MIMXRT1052.S
  group xip
    ../../../../../devices/MIMXRT1052/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/Core/Include
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/Core/Include/: core_cm23.h cmsis_armcc.h tz_context.h core_cm3.h mpu_armv8.h core_cm4.h core_cm0.h pmu_armv8.h cmsis_armclang.h core_cm7.h cmsis_iccarm.h core_cm1.h cmsis_compiler.h core_cm55.h core_cm0plus.h core_sc000.h core_armv81mml.h cachel1_armv7.h core_cm35p.h cmsis_armclang_ltm.h cmsis_gcc.h mpu_armv7.h core_armv8mml.h core_cm33.h cmsis_version.h core_armv8mbl.h core_sc300.h
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/DSP/Include
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/DSP/Include/: arm_common_tables_f16.h arm_math_f16.h arm_helium_utils.h arm_math.h arm_mve_tables_f16.h arm_vec_math.h arm_mve_tables.h arm_const_structs_f16.h arm_const_structs.h arm_common_tables.h
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Include
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Include/: arm_nnfunctions.h arm_nnsupportfunctions.h arm_nn_types.h arm_nn_tables.h
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ActivationFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ActivationFunctions/: arm_relu_q7.c arm_nn_activations_q15.c arm_relu6_s8.c arm_relu_q15.c arm_nn_activations_q7.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/BasicMathFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/BasicMathFunctions/: arm_elementwise_mul_s8.c arm_elementwise_add_s8.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ConcatenationFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ConcatenationFunctions/: arm_concatenation_s8_z.c arm_concatenation_s8_w.c arm_concatenation_s8_y.c arm_concatenation_s8_x.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ConvolutionFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ConvolutionFunctions/: arm_depthwise_conv_s8.c arm_convolve_HWC_q7_basic.c arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q15_fast.c arm_nn_mat_mult_kernel_q7_q15.c arm_convolve_HWC_q15_fast_nonsquare.c arm_depthwise_conv_s8_opt.c arm_nn_mat_mult_kernel_s8_s16.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q15_basic.c arm_depthwise_separable_conv_HWC_q7.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_depthwise_conv_3x3_s8.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_depthwise_conv_u8_basic_ver1.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_convolve_1x1_s8_fast.c arm_nn_depthwise_conv_s8_core.c arm_convolve_HWC_q7_RGB.c arm_convolve_1_x_n_s8.c arm_nn_mat_mult_s8.c arm_convolve_s8.c arm_nn_mat_mult_kernel_s8_s16_reordered.c arm_convolve_wrapper_s8.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/FullyConnectedFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q15.c arm_fully_connected_q7_opt.c arm_fully_connected_s8.c arm_fully_connected_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_mat_q7_vec_q15.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/NNSupportFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/NNSupportFunctions/: arm_nn_mult_q7.c arm_q7_to_q15_reordered_no_shift.c arm_nn_accumulate_q7_to_q15.c arm_nn_mat_mul_core_4x_s8.c arm_q7_to_q15_reordered_with_offset.c arm_nn_mat_mult_nt_t_s8.c arm_nn_add_q7.c arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nntables.c arm_q7_to_q15_with_offset.c arm_nn_depthwise_conv_nt_t_s8.c arm_q7_to_q15_no_shift.c arm_nn_mat_mul_core_1x_s8.c arm_nn_vec_mat_mult_t_s8.c arm_nn_mult_q15.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/PoolingFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/PoolingFunctions/: arm_max_pool_s8.c arm_max_pool_s8_opt.c arm_avgpool_s8.c arm_pool_q7_HWC.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ReshapeFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ReshapeFunctions/: arm_reshape_s8.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/SoftmaxFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/SoftmaxFunctions/: arm_softmax_q7.c arm_softmax_q15.c arm_softmax_s8.c arm_softmax_with_batch_q7.c arm_softmax_u8.c
  group eiq/tensorflow-lite/third_party/cmsis
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/: LICENSE.txt
  group eiq/tensorflow-lite/third_party/flatbuffers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/: readme.md LICENSE.txt
  group eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/: idl.h reflection_generated.h hash.h minireflect.h util.h code_generators.h flexbuffers.h registry.h reflection.h base.h flatbuffers.h stl_emulation.h
  group eiq/tensorflow-lite/third_party/gemmlowp
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/: LICENSE AUTHORS CONTRIBUTORS README.md
  group eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint/: fixedpoint_msa.h fixedpoint.h fixedpoint_neon.h fixedpoint_sse.h
  group eiq/tensorflow-lite/third_party/gemmlowp/internal
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/internal/: output_sse.h detect_platform.h kernel.h multi_thread_gemm.h kernel_msa.h compute.h pack.h pack_neon.h kernel_reference.h simd_wrappers_sse.h simd_wrappers_common_neon_sse.h kernel_neon.h simd_wrappers.h output_msa.h output.h kernel_sse.h allocator.h common.h kernel_dsp.h block_params.h dispatch_gemm_shape.h platform.h pack_sse.h kernel_default.h simd_wrappers_neon.h output_neon.h single_thread_gemm.h simd_wrappers_msa.h unpack.h pack_msa.h
  group eiq/tensorflow-lite/third_party/gemmlowp/meta
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/meta/: multi_thread_gemm.h multi_thread_transform.h transform_kernels_arm_32.h streams.h streams_arm_32.h quantized_mul_kernels_arm_32.h legacy_single_thread_gemm.h multi_thread_common.h streams_arm_64.h legacy_multi_thread_common.h legacy_multi_thread_gemm.h transform_kernels.h quantized_mul_kernels.h base.h quantized_mul_kernels_arm_64.h legacy_operations_common.h transform_kernels_arm_64.h single_thread_transform.h legacy_multi_thread_gemv.h single_thread_gemm.h
  group eiq/tensorflow-lite/third_party/gemmlowp/profiling
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/profiling/: profiler.h instrumentation.h pthread_everywhere.h
  group eiq/tensorflow-lite/third_party/gemmlowp/public
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/public/: config.h bit_depth.h gemmlowp.h map.h output_stages.h config.cpp
  group eiq/tensorflow-lite/third_party/ruy
    ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/: LICENSE context.h side_pair.h thread_pool.h ctx_impl.h kernel.h size_util.h system_aligned_alloc.h ruy.h apply_multiplier.h matrix.h pack.h blocking_counter.h pack_x86.h kernel_arm.h trmul_params.h cpu_cache_params.h cpuinfo.h pack_common.h mat.h allocator.h common.h pack_arm.h prepacked_cache.h kernel_x86.h block_map.h opt_set.h ctx.h dispatch.h trmul.h have_built_path_for.h platform.h path.h kernel_common.h tune.h mul_params.h time.h check_macros.h context_get_ctx.h block_map.cpp prepacked_cache.cpp tune.cpp context_get_ctx.cpp have_built_path_for_avx2.cpp kernel_avx512.cpp cpuinfo.cpp have_built_path_for_sse42.cpp ctx.cpp trmul.cpp allocator.cpp thread_pool.cpp pack_avx2.cpp kernel_arm32.cpp context.cpp kernel_avx2.cpp kernel_avxvnni.cpp system_aligned_alloc.cpp pack_avxvnni.cpp pack_arm.cpp kernel_arm64.cpp pack_avx512.cpp apply_multiplier.cpp pack_sse42.cpp blocking_counter.cpp have_built_path_for_avxvnni.cpp kernel_sse42.cpp have_built_path_for_avx512.cpp
  group eiq/tensorflow-lite/third_party/ruy/profiler
    ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/profiler/: treeview.h profiler.h instrumentation.h profiler.cpp treeview.cpp instrumentation.cpp
target tensorflow_lite_micro_label_image flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: tensorflow_lite_micro_label_image.out
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, __STDC_CONSTANT_MACROS, __CLK_TCK=1000000, CPU_MIMXRT1052DVL6B, SDK_DEBUGCONSOLE_UART, ARM_MATH_CM7, __FPU_PRESENT=1, SDK_I2C_BASED_COMPONENT_USED=1, SDK_I2C_BASED_COMPONENT_USED=1, FLATBUFFERS_LITTLEENDIAN, GEMMLOWP_MCU, RUY_MCU, TFLITE_MCU, TF_LITE_STATIC_MEMORY
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: as above
  link misc: as above
