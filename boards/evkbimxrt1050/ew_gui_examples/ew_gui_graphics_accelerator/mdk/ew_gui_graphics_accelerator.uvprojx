# Keil uVision project ew_gui_graphics_accelerator.uvprojx, settings and files
target ew_gui_graphics_accelerator flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ew_gui_graphics_accelerator.out
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1052DVL6B, SKIP_SYSCLK_INIT, XIP_BOOT_HEADER_DCD_ENABLE=1, EW_USE_DOUBLE_BUFFER=1, EW_CPU_LOAD_MEASURING=1, EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565, EW_SURFACE_ROTATION=0, EW_USE_FREE_RTOS=0, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../..;../../../../../CMSIS/Include;../../../../../devices;../GeneratedCode;../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RTE;../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RGB565;../../../../../middleware/EmbeddedWizard/TargetSpecific/RT;../../../../../devices/MIMXRT1052/drivers;../../../../../components/ft5406_rt;../../../../../devices/MIMXRT1052;../../../../../devices/MIMXRT1052/utilities/str;../../../../../devices/MIMXRT1052/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../devices/MIMXRT1052/xip;../../../xip;../../../../../devices/MIMXRT1052/utilities
  asm define: DEBUG, __STARTUP_CLEAR_BSS, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RGB565/libewgfx-m7-keil.lib ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RTE/libewrte-m7-keil.lib --remove --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group board
    ../: board.c board.h clock_config.c clock_config.h dcd.c dcd.h ewconfig.h ewdef.h pin_mux.c pin_mux.h
  group source
    ../: main.c ewmain.c ewmain.h DeviceDriver.c DeviceDriver.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_cache.c fsl_cache.h fsl_elcdif.c fsl_elcdif.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_pxp.c fsl_pxp.h fsl_lpi2c.c fsl_lpi2c.h fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h fsl_gpio.c fsl_gpio.h
  group touchpanel
    ../../../../../components/ft5406_rt/: fsl_ft5406_rt.c fsl_ft5406_rt.h
  group EmbeddedWizard-GeneratedCode
    ../GeneratedCode/: Accelerator.c Accelerator.h Application.c Application.h Core.c Core.h Effects.c Effects.h Graphics.c Graphics.h GraphicsSystem.c GraphicsSystem.h Resources.c Resources.h Templates.c Templates.h Views.c Views.h WidgetSet.c WidgetSet.h _AcceleratorAccelerator.h _AcceleratorFontLarge.h _AcceleratorFontMedium.h _AcceleratorFontSmall.h _AcceleratorGraphicsFactory.h _AcceleratorImgBlend1.h _AcceleratorImgBlend2.h _AcceleratorImgBlend3.h _AcceleratorImgBlend4.h _AcceleratorImgBlend5.h _AcceleratorImgBlend6.h _AcceleratorImgBlend7.h _AcceleratorImgCopy1.h _AcceleratorImgCopy2.h _AcceleratorImgCopy3.h _AcceleratorImgCopy4.h _AcceleratorImgCopy5.h _AcceleratorLogo.h _ApplicationApplication.h _CoreCursorEvent.h _CoreCursorGrabEvent.h _CoreCursorHit.h _CoreDialogContext.h _CoreDragEvent.h _CoreEvent.h _CoreGroup.h _CoreKeyEvent.h _CoreKeyPressHandler.h _CoreLayoutContext.h _CoreLayoutQuadContext.h _CoreModalContext.h _CoreOutline.h _CoreQuadView.h _CoreRectView.h _CoreResource.h _CoreRoot.h _CoreSimpleTouchHandler.h _CoreTask.h _CoreTaskQueue.h _CoreTimer.h _CoreView.h _EffectsEffectTimerClass.h _GraphicsCanvas.h _GraphicsSystemDeviceClass.h _ResourcesBitmap.h _ResourcesFont.h _ResourcesFontMedium.h _TemplatesDeviceClass.h _ViewsFrame.h _ViewsImage.h _ViewsRectangle.h _ViewsText.h _WidgetSetPushButton.h _WidgetSetPushButtonConfig.h _WidgetSetPushButtonMedium.h _WidgetSetSwitchMedium.h _WidgetSetToggleButton.h _WidgetSetToggleButtonConfig.h _WidgetSetWidgetConfig.h ewlocale.h
  group EmbeddedWizard-PlatformPackage-RT-RGB565
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RGB565/: ewextbmp.h ewextfnt.h ewextgfx.c ewextgfx.h ewextpxl_RGB565.h ewgfx.h ewgfxcore.h ewgfxdefs.h ewgfxdriver.h ewgfxlinks.h ewgfxres.h ewgfxtasks.h
  group EmbeddedWizard-PlatformPackage-RT-RTE
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RTE/: ewextrte.c ewextrte.h ewrte.h
  group EmbeddedWizard-TargetSpecific-RT
    ../../../../../middleware/EmbeddedWizard/TargetSpecific/RT/: ew_bsp_clock.c ew_bsp_clock.h ew_bsp_console.c ew_bsp_console.h ew_bsp_display.c ew_bsp_display.h ew_bsp_event.c ew_bsp_event.h ew_bsp_graphics.c ew_bsp_graphics.h ew_bsp_inout.c ew_bsp_inout.h ew_bsp_system.c ew_bsp_system.h ew_bsp_touch.c ew_bsp_touch.h
  group device
    ../../../../../devices/MIMXRT1052/: MIMXRT1052.h MIMXRT1052_features.h fsl_device_registers.h system_MIMXRT1052.c system_MIMXRT1052.h
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c
  group component-uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MIMXRT1052/arm/: startup_MIMXRT1052.S
  group xip
    ../../../../../devices/MIMXRT1052/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
target ew_gui_graphics_accelerator flexspi_nor_release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ew_gui_graphics_accelerator.out
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1052DVL6B, SKIP_SYSCLK_INIT, XIP_BOOT_HEADER_DCD_ENABLE=1, EW_USE_DOUBLE_BUFFER=1, EW_CPU_LOAD_MEASURING=1, EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565, EW_SURFACE_ROTATION=0, EW_USE_FREE_RTOS=0, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_CLEAR_BSS, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: as above
