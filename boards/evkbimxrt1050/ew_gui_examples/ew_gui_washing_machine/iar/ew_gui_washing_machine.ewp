# IAR project ew_gui_washing_machine.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1052DVL6B; SKIP_SYSCLK_INIT; XIP_BOOT_HEADER_DCD_ENABLE=1; EW_USE_DOUBLE_BUFFER=1; EW_CPU_LOAD_MEASURING=1; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565; EW_SURFACE_ROTATION=0; EW_USE_FREE_RTOS=0
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../devices/MIMXRT1052/drivers; ../../../../../components/ft5406_rt; ../../../../../devices/MIMXRT1052/utilities/debug_console_lite; ../GeneratedCode; ../../../../../middleware/EmbeddedWizard/TargetSpecific/RT; ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RGB565; ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RTE; ../../../../../devices/MIMXRT1052; ../../../../../components/uart; ../../../../../components/lists; ../../../../../devices/MIMXRT1052/xip; ../../../xip; ../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_CLEAR_BSS; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: ew_gui_washing_machine.out
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RTE/libewrte-m7-iar.a; ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RGB565/libewgfx-m7-iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1052DVL6B; SKIP_SYSCLK_INIT; XIP_BOOT_HEADER_DCD_ENABLE=1; EW_USE_DOUBLE_BUFFER=1; EW_CPU_LOAD_MEASURING=1; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565; EW_SURFACE_ROTATION=0; EW_USE_FREE_RTOS=0
  AARM.ADefines: NDEBUG; __STARTUP_CLEAR_BSS; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../: board.c board.h clock_config.c clock_config.h dcd.c dcd.h ewconfig.h ewdef.h pin_mux.c pin_mux.h
  group source
    ../: main.c ewmain.c ewmain.h DeviceDriver.c DeviceDriver.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_cache.c fsl_cache.h fsl_elcdif.c fsl_elcdif.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_pxp.c fsl_pxp.h fsl_lpi2c.c fsl_lpi2c.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group touchpanel
    ../../../../../components/ft5406_rt/: fsl_ft5406_rt.h fsl_ft5406_rt.c
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group EmbeddedWizard/GeneratedCode
    ../GeneratedCode/: Application.c Effects.c Resources.c Core.c Washer.c Views.c Graphics.c _ViewsRectangle.h _WasherBgHot.h _CoreKeyPressHandler.h _WasherTimeList.h _WasherTempItemL.h _WasherProgList.h _CoreSimpleTouchHandler.h Resources.h _WasherSpinItemS.h _WasherStartButton.h _ViewsImage.h _CoreLayoutContext.h _WasherOptList.h ewlocale.h _WasherListFontS.h _WasherBgSpin.h _CoreLayoutQuadContext.h _CoreEvent.h Views.h _WasherBgDelicates.h _WasherBgEco.h Core.h _WasherListFontL.h _EffectsEffectTimerClass.h _CoreView.h _CoreTaskQueue.h _CoreVerticalList.h _WasherMinItemS.h _WasherMinItemL.h _EffectsTimingList.h _WasherOptItemL.h _WasherTempItemS.h _WasherBgDrain.h _WasherBgSportswear.h _WasherProgItemL.h _EffectsRectEffect.h _EffectsInt32Effect.h _WasherListFontXL.h _WasherShadow.h _EffectsEffect.h _CoreCursorEvent.h _ViewsText.h _CoreRoot.h _ViewsBorder.h _CoreOutline.h _CoreModalContext.h _WasherTempList.h Application.h _ApplicationApplication.h _CorePropertyObserver.h _CoreQuadView.h _WasherProgItemS.h _CoreDragEvent.h _CoreCursorGrabEvent.h _GraphicsCanvas.h Effects.h Graphics.h _WasherBgWool.h _WasherWasher.h _WasherDescrFont.h _CoreKeyEvent.h _CoreCursorHit.h _CoreSlideTouchHandler.h _WasherBgEasyCare.h _WasherSpinItemL.h _WasherOptItemS.h _ResourcesFont.h _WasherSpinList.h _CoreTask.h _WasherDeviceClass.h _CoreDialogContext.h _CoreTimer.h _ResourcesBitmap.h _WasherHourItemS.h _CoreGroup.h _WasherListFontM.h Washer.h _WasherHourItemL.h _ViewsFrame.h _CoreResource.h _CoreRectView.h
  group EmbeddedWizard/TargetSpecific/RT
    ../../../../../middleware/EmbeddedWizard/TargetSpecific/RT/: ew_bsp_console.c ew_bsp_system.c ew_bsp_clock.c ew_bsp_event.c ew_bsp_graphics.c ew_bsp_display.c ew_bsp_inout.c ew_bsp_touch.c ew_bsp_console.h ew_bsp_display.h ew_bsp_touch.h ew_bsp_clock.h ew_bsp_inout.h ew_bsp_system.h ew_bsp_event.h ew_bsp_graphics.h
  group EmbeddedWizard/PlatformPackage/RT/RGB565
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RGB565/: ewextgfx.c ewgfxdefs.h ewgfxres.h ewextgfx.h ewgfxdriver.h ewextfnt.h ewgfxcore.h ewextbmp.h ewgfxlinks.h ewgfxtasks.h ewextpxl_RGB565.h ewgfx.h
  group EmbeddedWizard/PlatformPackage/RT/RTE
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RTE/: ewextrte.c ewextrte.h ewrte.h
  group device
    ../../../../../devices/MIMXRT1052/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.c system_MIMXRT1052.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1052/iar/: startup_MIMXRT1052.s
  group xip
    ../../../../../devices/MIMXRT1052/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
