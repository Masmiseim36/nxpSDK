# IAR project littlefs_shell.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; LFS_NO_INTRINSICS=1; SDK_DEBUGCONSOLE_UART; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1052DVL6B; MIMXRT1052_SERIES; SERIAL_PORT_TYPE_UART=1; MFLASH_FILE_BASEADDR=64487424
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../xip; ../../../../../devices/MIMXRT1052/drivers; ../../../../../CMSIS/Core/Include; ../../../../../CMSIS/Core/Include/m-profile; ../../../../../devices/MIMXRT1052; ../../../../../devices/MIMXRT1052/periph; ../../../../../devices/MIMXRT1052/xip; ../../../../../devices/MIMXRT1052/utilities/debug_console; ../../../../../components/lists; ../../../../../devices/MIMXRT1052/utilities/str; ../../../../../devices/MIMXRT1052/utilities/shell; ../../../../../components/serial_manager; ../../../../../components/uart; ../../../../../components/flash/mflash; ../../../../../components/flash/mflash/mimxrt1052; ../../../../../components/flash/nor; ../../../../../components/flash/nor/flexspi; ../../../../../middleware/littlefs; ../../../../../middleware/littlefs/mflash
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT1052DVL6B; MIMXRT1052_SERIES
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: littlefs_shell.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x1000
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; USE_SDRAM=1; SKIP_SYSCLK_INIT=1; DATA_SECTION_IS_CACHEABLE=1; LFS_NO_INTRINSICS=1; SDK_DEBUGCONSOLE_UART; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1052DVL6B; MIMXRT1052_SERIES; SERIAL_PORT_TYPE_UART=1; MFLASH_FILE_BASEADDR=64487424
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: LFS_NO_ASSERT; NDEBUG; LFS_NO_INTRINSICS=1; SDK_DEBUGCONSOLE_UART; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1052DVL6B; MIMXRT1052_SERIES; SERIAL_PORT_TYPE_UART=1; MFLASH_FILE_BASEADDR=64487424
  ICCARM.CCOptLevel: 3
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: LFS_NO_ASSERT; NDEBUG; USE_SDRAM=1; SKIP_SYSCLK_INIT=1; DATA_SECTION_IS_CACHEABLE=1; LFS_NO_INTRINSICS=1; SDK_DEBUGCONSOLE_UART; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1052DVL6B; MIMXRT1052_SERIES; SERIAL_PORT_TYPE_UART=1; MFLASH_FILE_BASEADDR=64487424
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram.icf
  group source
    ../: littlefs_shell.c peripherals.c peripherals.h fsl_debug_console_conf.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group xip
    ../../../xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h
    ../../../: dcd.c dcd.h
    ../../../../../devices/MIMXRT1052/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_flexspi.c fsl_flexspi.h fsl_gpc.c fsl_gpc.h fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_pmu.h fsl_pmu.c fsl_src.c fsl_src.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv7m_cachel1.h armv7m_mpu.h
  group device
    ../../../../../devices/MIMXRT1052/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h MIMXRT1052_COMMON.h system_MIMXRT1052.c system_MIMXRT1052.h
  group device/periph
    ../../../../../devices/MIMXRT1052/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_AIPSTZ.h PERI_AOI.h PERI_BEE.h PERI_CAN.h PERI_CCM.h PERI_CCM_ANALOG.h PERI_CM7_MCM.h PERI_CMP.h PERI_CSI.h PERI_CSU.h PERI_DCDC.h PERI_DCP.h PERI_DMA.h PERI_DMAMUX.h PERI_ENC.h PERI_ENET.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_KPP.h PERI_LCDIF.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_OCOTP.h PERI_PGC.h PERI_PIT.h PERI_PMU.h PERI_PWM.h PERI_PXP.h PERI_ROMC.h PERI_RTWDOG.h PERI_SEMC.h PERI_SNVS.h PERI_SPDIF.h PERI_SRC.h PERI_TEMPMON.h PERI_TMR.h PERI_TRNG.h PERI_TSC.h PERI_USB.h PERI_USBNC.h PERI_USBPHY.h PERI_USB_ANALOG.h PERI_USDHC.h PERI_WDOG.h PERI_XBARA.h PERI_XBARB.h PERI_XTALOSC24M.h
  group startup/iar
    ../../../../../devices/MIMXRT1052/iar/: startup_MIMXRT1052.s
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/debug_console/: fsl_assert.h fsl_assert.c
    ../../../../../devices/MIMXRT1052/utilities/shell/: fsl_shell.h fsl_shell.c
  group utilities/str
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console
    ../../../../../devices/MIMXRT1052/utilities/debug_console/: fsl_debug_console.h fsl_debug_console.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group flash/mflash
    ../../../../../components/flash/mflash/: mflash_common.h mflash_file.c mflash_file.h
  group flash/mflash/mimxrt1052
    ../../../../../components/flash/mflash/mimxrt1052/: mflash_drv.c mflash_drv.h
  group nor_flash/nor
    ../../../../../components/flash/nor/: fsl_nor_flash.h
  group nor_flash/nor/flexspi
    ../../../../../components/flash/nor/flexspi/: fsl_flexspi_nor_flash.c fsl_flexspi_nor_flash.h
  group littlefs
    ../../../../../middleware/littlefs/: lfs.c lfs.h lfs_util.c lfs_util.h
  group littlefs/mflash
    ../../../../../middleware/littlefs/mflash/: lfs_mflash.c lfs_mflash.h
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
