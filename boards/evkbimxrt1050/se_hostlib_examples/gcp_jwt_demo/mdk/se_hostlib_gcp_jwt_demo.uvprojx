# Keil uVision project se_hostlib_gcp_jwt_demo.uvprojx, settings and files
target se_hostlib_gcp_jwt_demo flexspi_nor_debug (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: se_hostlib_gcp_jwt_demo.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1052DVL6B, IMX_RT, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, MBEDTLS_CONFIG_FILE='\"a71ch_mbedtls_evkbimxrt1050_config.h\"', mqttconfigENABLE_METRICS=0, USE_RTOS=1, LPC_ENET, GCP_IOT, PRINTF_ADVANCED_ENABLE=1, _POSIX_SOURCE, TGT_A71CH, I2C, FSL_RTOS_FREE_RTOS, MBEDTLS, SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC
  c misc: --library_interface=armcc 
--diag_suppress=66,1296,186 
--diag_suppress=1296,186 
--diag_suppress=177
  c include: ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F;..;../../../../../middleware/se_hostlib/demo/gcp_jwt_demo;../../../../src/se_hostlib_examples/aws_jitr_demo;../../../../../middleware/se_hostlib/demo/aws_ca_upload;../../../../../middleware/se_hostlib/demo/common;../../../../../middleware/se_hostlib/demo/common/config;../../../../../middleware/se_hostlib/ext/evkbimxrt1050/board;../../../../../rtos/amazon-freertos/lib/include/private;../../../../../rtos/amazon-freertos/lib/pkcs11/portable/nxp/se_hostlib;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../middleware/se_hostlib;../../../../../middleware/se_hostlib/hostLib/tstUtil;../../../../../rtos/amazon-freertos/lib/include;../../../../../rtos/amazon-freertos/lib/include/private;../../../../../middleware/mbedtls/include;../../../../../middleware/mbedtls/port/ksdk;../../../../../middleware/se_hostlib/hostLib/libCommon/hostCrypto;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../rtos/amazon-freertos/lib/third_party/mcu_vendor/nxp/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../rtos/amazon-freertos/lib/include;../../../../../rtos/amazon-freertos/lib/include/private;../../../../../rtos/amazon-freertos/lib/third_party/pkcs11;../../../../../rtos/amazon-freertos/lib/third_party;../../../../../rtos/amazon-freertos/lib/third_party/jsmn;../../../../../middleware/se_hostlib/hostLib/a71ch/inc;../../../../../middleware/se_hostlib/hostLib/api/inc;../../../../../middleware/se_hostlib/hostLib/mbedtls/inc;../../../../../middleware/se_hostlib/hostLib/libCommon/infra;../../../../../middleware/se_hostlib/hostLib/libCommon/scp;../../../../../middleware/se_hostlib/hostLib/libCommon/smCom;../../../../../middleware/se_hostlib/hostLib/platform/inc;../../../../../middleware/se_hostlib/platform;../../../../../rtos/amazon-freertos/demos/common/include;../../../../../middleware/se_hostlib/hostLib/tstUtil;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052;../../../../../devices/MIMXRT1052/utilities/str;../../../../../devices/MIMXRT1052/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/serial_manager;../../../../../devices/MIMXRT1052/drivers;../../../../../components/lists;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/xip;../../../xip;../../../../../middleware/lwip/port;../../../../../middleware/lwip/src;../../../../../middleware/lwip/src/include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../../..;../../../../../middleware/se_hostlib/demo/gcp_jwt_demo;../../../../src/se_hostlib_examples/aws_jitr_demo;..
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: --remove 
--keep=*(.boot_hdr.ivt) 
--keep=*(.boot_hdr.boot_data) 
--keep=*(.boot_hdr.conf) 
--predefine="-DXIP_BOOT_HEADER_ENABLE=1" 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x8000" 
--predefine="-D__stack_size__=0x1000" 
--predefine="-D__heap_size__=0x1000" 
--predefine="-D__ram_vector_table__=1"
  group source
    ../: gcpJWTDemo_Main.c gcpJWTDemo.c gcpJWTDemo.h gcp_iot_config.h gcp_default_root_certificates.h gcp_cert.c gcpNTPGetEpoch.c gcpPubSub.c FreeRTOSConfig.h FreeRTOSConfig.c FreeRTOSIPConfig.h aws_secure_sockets_config.h aws_mqtt_config.h aws_bufferpool_config.h aws_mqtt_agent_config.h aws_pkcs11_config.h wifi_config.h aws_clientcredential.h
  group amazon-freertos-pkcs11
    ../: pkcs11_se.c pkcs11_se.h mflash_drv.h mflash_file.h
    ../../../../../rtos/amazon-freertos/lib/pkcs11/mbedtls/: aws_pkcs11_mbedtls.c
    ../../../../../rtos/amazon-freertos/lib/pkcs11/portable/nxp/evkbimxrt1050/: aws_pkcs11_pal.c
  group board
    ../: pin_mux.c pin_mux.h fsl_phy.c fsl_phy.h lwipopts.h httpsclient.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_trng.c fsl_trng.h fsl_lpi2c.c fsl_lpi2c.h fsl_dcp.c fsl_dcp.h fsl_pit.c fsl_pit.h fsl_cache.c fsl_cache.h fsl_flexspi.c fsl_flexspi.h fsl_enet.h fsl_enet.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group amazon-freertos-drivers
    ../../../../../rtos/amazon-freertos/lib/third_party/mcu_vendor/nxp/MIMXRT1052/drivers/: mflash_drv.h mflash_drv.c mflash_file.h mflash_file.c
  group amazon-freertos-include
    ../../../../../rtos/amazon-freertos/lib/include/: FreeRTOS.h aws_crypto.h aws_greengrass_discovery.h aws_mqtt_agent.h aws_mqtt_lib.h aws_pkcs11.h aws_secure_sockets.h aws_shadow.h aws_system_init.h aws_tls.h aws_wifi.h event_groups.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h event_groups.h FreeRTOS.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
    ../../../../../rtos/amazon-freertos/lib/include/private/: aws_bufferpool.h aws_default_root_certificates.h aws_doubly_linked_list.h aws_ggd_config_defaults.h aws_helper_secure_connect.h aws_lib_init.h aws_mqtt_agent_config_defaults.h aws_mqtt_buffer.h aws_mqtt_config_defaults.h aws_secure_sockets_config_defaults.h aws_shadow_config_defaults.h aws_shadow_json.h deprecated_definitions.h list.h mpu_wrappers.h portable.h projdefs.h stack_macros.h deprecated_definitions.h list.h mpu_wrappers.h portable.h projdefs.h stack_macros.h
    ../../../../../rtos/amazon-freertos/demos/common/include/: aws_clientcredential.h aws_clientcredential_keys.h aws_demo.h aws_dev_mode_key_provisioning.h aws_logging_task.h aws_shadow_lightbulb_on_off.h aws_greengrass_discovery_demo.h
  group amazon-freertos-mqtt
    ../../../../../rtos/amazon-freertos/lib/mqtt/: aws_mqtt_agent.c aws_mqtt_lib.c
  group amazon-freertos-tls
    ../../../../../rtos/amazon-freertos/lib/tls/: aws_tls.c
  group amazon-freertos-bufferpool
    ../../../../../rtos/amazon-freertos/lib/bufferpool/: aws_bufferpool_static_thread_safe.c
  group amazon-freertos-crypto
    ../../../../../rtos/amazon-freertos/lib/crypto/: aws_crypto.c
  group amazon-freertos-third_party-pkcs11
    ../../../../../rtos/amazon-freertos/lib/third_party/pkcs11/: pkcs11.h pkcs11f.h pkcs11t.h
  group amazon-freertos-utils
    ../../../../../rtos/amazon-freertos/lib/utils/: aws_system_init.c
  group amazon-freertos-third_party-jsmn
    ../../../../../rtos/amazon-freertos/lib/third_party/jsmn/: jsmn.c jsmn.h
  group amazon-freertos-secure_sockets
    ../../../../../rtos/amazon-freertos/lib/secure_sockets/portable/nxp/lwip/: aws_secure_sockets.c
  group lwip-port
    ../../../../../middleware/lwip/port/: ethernetif.c ethernetif.h sys_arch.c
  group se_hostlib-ax
    ../../../../../middleware/se_hostlib/hostLib/api/src/: ax_scp.c ax_switch.c A71HLSEWrapper.c ax_crypto_ecc.c ax_crypto_rng.c ax_util.c ax_sst.c ax_crypto_aes_key.c
    ../../../../../middleware/se_hostlib/hostLib/api/inc/: ax_scp_private.h HLSEObjects.h HLSECrypto.h HLSEMisc.h ax_api.h ax_util.h ax_common.h ax_common_private.h HLSEComm.h ax_scp.h HLSETypes.h HLSEAPI.h
    ../../../../../middleware/se_hostlib/hostLib/a71ch/src/: a71ch_crypto_derive.c a71ch_com.c a71ch_sst.c a71ch_crypto_ecc.c a71ch_module.c
    ../../../../../middleware/se_hostlib/hostLib/a71ch/inc/: a71ch_const.h a71ch_util.h a71ch_api.h
  group se_hostlib-common
    ../../../../../middleware/se_hostlib/hostLib/libCommon/infra/: a71_debug.c a71_debug.h global_platf.c global_platf.h sm_apdu.c sm_apdu.h sm_errors.c sm_errors.h sm_types.h nxLog.c nxLog.h nxLog_App.h nxLog_DefaultConfig.h
    ../../../../../middleware/se_hostlib/hostLib/libCommon/scp/: scp.c scp.h
    ../../../../../middleware/se_hostlib/hostLib/libCommon/smCom/: apduComm.h sci2c.c sci2c.h smCom.c smComSCI2C.c
    ../../../../../middleware/se_hostlib/hostLib/libCommon/hostCrypto/: axHostCrypto.h axHostCryptombedtls.c hcAsn.c hcAsn.h HostCryptoAPI.h
  group se_hostlib-platform
    ../../../../../middleware/se_hostlib/hostLib/platform/generic/: sm_printf.c
    ../../../../../middleware/se_hostlib/hostLib/platform/inc/: i2c_a7.h sm_printf.h sm_timer.h
    ../../../../../middleware/se_hostlib/hostLib/platform/kinetis/: i2c_frdm.c i2c_imxrt10xx.c i2c_lpc54xxx.c timer_kinetis.c timer_kinetis_bm.c timer_kinetis_freertos.c
    ../../../../../middleware/se_hostlib/hostLib/tstUtil/: app_boot.c
  group se_hostlib-inc
    ../../../../../middleware/se_hostlib/hostLib/libCommon/smCom/: smCom.h smComSCI2C.h sci2c_cfg.h
  group amazon-freertos-logging
    ../../../../../rtos/amazon-freertos/demos/common/logging/: aws_logging_task_dynamic_buffers.c
  group amazon-freertos-devmode_key_provisioning
    ../../../../../rtos/amazon-freertos/demos/common/devmode_key_provisioning/: aws_dev_mode_key_provisioning.c
  group se_hostlib-tst
    ../../../../../middleware/se_hostlib/hostLib/tstUtil/: axWebUtil.h hkdf_mbedtls.c hkdf_mbedtls.h tst_a71ch_util.c tst_a71ch_util.h tst_sm_time.h tst_sm_time_kinetis.c tst_sm_util.c tst_sm_util.h tstHostCrypto.h tstHostCrypto_mbedtls.c app_boot.h tst_utils_kinetis.c tst_utils_rtos.c tst_utils_kinetis.h
  group amazon-freertos-FreeRTOS-portable
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F/: fsl_tickless_systick.c fsl_tickless_generic.h port.c portmacro.h
  group amazon-freertos-license
    ../../../../../rtos/amazon-freertos/: LICENSE
  group amazon-freertos-FreeRTOS
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group se_hostlib-src
    ../../../../../middleware/se_hostlib/hostLib/libCommon/hostCrypto/: HostCryptoAPImbedtls.c
  group se_hostlib-mbedtls
    ../../../../../middleware/se_hostlib/hostLib/mbedtls/inc/: a71ch_mbedtls_frdm_config.h a71ch_mbedtls_frdmkw41z_config.h a71ch_mbedtls_evkbimxrt1050_config.h ax_mbedtls.h ecp_alt.h
    ../../../../../middleware/se_hostlib/hostLib/mbedtls/src/: ax_mbedtls.c ecdh_alt.c ecdh_alt_ax.c ecp_alt.c ecp_alt_ax.c ecp_curves_alt.c
  group mbedtls-mbedtls_include
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls-mbedtls_source
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c chacha20.c chachapoly.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls-mbedtls_port
    ../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c
  group device
    ../../../../../devices/MIMXRT1052/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.c system_MIMXRT1052.h
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1052/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: uart.h lpuart_adapter.c
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: generic_list.h generic_list.c
  group startup
    ../../../../../devices/MIMXRT1052/arm/: startup_MIMXRT1052.s
  group xip
    ../../../../../devices/MIMXRT1052/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
  group lwip-port-arch
    ../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip-src-api
    ../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-src-core
    ../../../../../middleware/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip-src-core-ipv4
    ../../../../../middleware/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip-src-core-ipv6
    ../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip-src-include-lwip
    ../../../../../middleware/lwip/src/include/lwip/: api.h arch.h debug.h dhcp.h dns.h errno.h ethip6.h icmp6.h inet.h init.h ip_addr.h ip4_addr.h ip6.h ip6_frag.h memp.h nd6.h netdb.h netifapi.h pbuf.h sio.h sockets.h sys.h tcpip.h udp.h autoip.h def.h dhcp6.h err.h etharp.h icmp.h igmp.h inet_chksum.h ip.h ip4.h ip4_frag.h ip6_addr.h mem.h mld6.h netbuf.h netif.h opt.h raw.h snmp.h stats.h tcp.h timeouts.h
  group lwip-src-include-lwip-priv
    ../../../../../middleware/lwip/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h nd6_priv.h tcp_priv.h tcpip_priv.h
  group lwip-src-include-lwip-prot
    ../../../../../middleware/lwip/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h ethernet.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip-src-include-netif
    ../../../../../middleware/lwip/src/include/netif/: etharp.h ethernet.h lowpan6.h lowpan6_opts.h slipif.h
  group lwip-src-include-netif-ppp
    ../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap_ms.h chap-md5.h chap-new.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip-src-include-netif-ppp-polarssl
    ../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip-src-include-posix
    ../../../../../middleware/lwip/src/include/posix/: errno.h netdb.h
  group lwip-src-include-posix-sys
    ../../../../../middleware/lwip/src/include/posix/sys/: socket.h
  group lwip-src-netif
    ../../../../../middleware/lwip/src/netif/: ethernet.c lowpan6.c slipif.c
  group lwip-src-netif-ppp
    ../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
target se_hostlib_gcp_jwt_demo flexspi_nor_release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: se_hostlib_gcp_jwt_demo.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1052DVL6B, IMX_RT, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, MBEDTLS_CONFIG_FILE='\"a71ch_mbedtls_evkbimxrt1050_config.h\"', mqttconfigENABLE_METRICS=0, USE_RTOS=1, LPC_ENET, GCP_IOT, PRINTF_ADVANCED_ENABLE=1, _POSIX_SOURCE, TGT_A71CH, I2C, FSL_RTOS_FREE_RTOS, MBEDTLS, SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: as above
