<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>se_hostlib_ibm_watson_demo</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
      <member>
        <project>se_hostlib_ibm_watson_demo</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_debug</name>
      <member>
        <project>se_hostlib_ibm_watson_demo</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_release</name>
      <member>
        <project>se_hostlib_ibm_watson_demo</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/se_hostlib_ibm_watson_demo.ewp</path>
  </project>
</workspace>
