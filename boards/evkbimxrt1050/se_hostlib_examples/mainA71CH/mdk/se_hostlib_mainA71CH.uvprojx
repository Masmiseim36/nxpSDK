# Keil uVision project se_hostlib_mainA71CH.uvprojx, settings and files
target se_hostlib_mainA71CH flexspi_nor_debug (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: se_hostlib_mainA71CH.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1052DVL6B, IMX_RT, MBEDTLS_CONFIG_FILE='\"a71ch_mbedtls_evkbimxrt1050_config.h\"', PRINTF_ADVANCED_ENABLE=1, TGT_A71CH, I2C, MBEDTLS, SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC
  c misc: --library_interface=armcc --diag_suppress=66,1296,186 --diag_suppress=177 --diag_suppress=1296,186
  c include: ..;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../middleware/se_hostlib;../../../../../middleware/mbedtls/include;../../../../../middleware/mbedtls/port/ksdk;../../../../../middleware/se_hostlib/hostLib/libCommon/hostCrypto;../../../../../middleware/se_hostlib/hostLib/tstUtil;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../middleware/se_hostlib/hostLib/libCommon/infra;../../../../../middleware/se_hostlib/hostLib/libCommon/scp;../../../../../middleware/se_hostlib/hostLib/inc;../../../../../middleware/se_hostlib/hostLib/libCommon/smCom;../../../../../middleware/se_hostlib/hostLib/platform/inc;../../../../../middleware/se_hostlib/platform;../../../../../middleware/se_hostlib/hostLib/tstUtil;../../../../../middleware/se_hostlib/hostLib/a71ch/inc;../../../../../middleware/se_hostlib/hostLib/api/inc;../../../../../middleware/se_hostlib/hostLib/inc;../../../../../middleware/se_hostlib/hostLib/mbedtls/inc;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052;../../../../../devices/MIMXRT1052/utilities/str;../../../../../devices/MIMXRT1052/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/serial_manager;../../../../../devices/MIMXRT1052/drivers;../../../../../components/lists;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/xip;../../../xip
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: --remove --keep=*(.boot_hdr.ivt) --keep=*(.boot_hdr.boot_data) --keep=*(.boot_hdr.conf) --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x8000"
  group source
    ../: mainA71CH.c a71ch_ex.h ex_aes.c ex_boot.c ex_config.c ex_debug.c ex_ecc_nohc.c ex_gpstorage.c ex_misc.c ex_psk.c ex_scp.c ex_sst.c ex_sst_kp.c ex_walkthrough.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_trng.c fsl_trng.h fsl_lpi2c.c fsl_lpi2c.h fsl_dcp.c fsl_dcp.h fsl_pit.c fsl_pit.h fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h fsl_gpio.c fsl_gpio.h
  group se_hostlib-inc
    ../../../../../middleware/se_hostlib/hostLib/inc/: HLSEAPI.h HLSEComm.h HLSECrypto.h HLSEMisc.h HLSEObjects.h HLSETypes.h PlugAndTrust_HostLib_Ver.h PlugAndTrust_Pkg_Ver.h a71ch_api.h a71ch_const.h a71ch_util.h ax_api.h ax_common.h ax_common_a71ch.h ax_common_a71cl.h ax_common_private.h ax_scp.h ax_scp_private.h ax_sss_scp.h ax_util.h fsl_sss_ftr_default.h nxEnsure.h scp.h
    ../../../../../middleware/se_hostlib/hostLib/libCommon/smCom/: sci2c_cfg.h smCom.h smComSCI2C.h
  group se_hostlib-common
    ../../../../../middleware/se_hostlib/hostLib/libCommon/infra/: global_platf.c global_platf.h nxLog.c nxLog.h nxLog_App.h nxLog_DefaultConfig.h nxLog_UseCases.h nxLog_VCOM.h nxLog_hostLib.h nxLog_mbedtls.h nxLog_scp.h nxLog_smCom.h nxLog_sscp.h nxLog_sss.h sm_apdu.c sm_apdu.h sm_api.h sm_errors.c sm_errors.h sm_printf.c sm_types.h a71_debug.c a71_debug.h
    ../../../../../middleware/se_hostlib/hostLib/libCommon/scp/: scp.c scp.h
    ../../../../../middleware/se_hostlib/hostLib/libCommon/smCom/: apduComm.h sci2c.c sci2c.h smCom.c smComSCI2C.c
    ../../../../../middleware/se_hostlib/hostLib/libCommon/hostCrypto/: HostCryptoAPI.h axHostCrypto.h axHostCryptombedtls.c hcAsn.c hcAsn.h
  group se_hostlib-platform
    ../../../../../middleware/se_hostlib/hostLib/platform/inc/: i2c_a7.h sm_printf.h sm_timer.h
    ../../../../../middleware/se_hostlib/hostLib/platform/kinetis/: i2c_frdm.c i2c_imxrt10xx.c i2c_lpc54xxx.c timer_kinetis.c timer_kinetis_bm.c timer_kinetis_freertos.c
    ../../../../../middleware/se_hostlib/hostLib/tstUtil/: app_boot.c
  group se_hostlib-src
    ../../../../../middleware/se_hostlib/hostLib/libCommon/hostCrypto/: HostCryptoAPImbedtls.c
  group se_hostlib-mbedtls
    ../../../../../middleware/se_hostlib/hostLib/mbedtls/inc/: a71ch_mbedtls_evkbimxrt1050_config.h a71ch_mbedtls_frdm_config.h a71ch_mbedtls_frdmkw41z_config.h ax_mbedtls.h
    ../../../../../middleware/se_hostlib/hostLib/mbedtls/src/: ax_mbedtls.c ecdh_alt.c ecdh_alt_ax.c
  group se_hostlib-tst
    ../../../../../middleware/se_hostlib/hostLib/tstUtil/: app_boot.h axWebUtil.h hkdf_mbedtls.c hkdf_mbedtls.h tstHostCrypto.h tstHostCrypto_mbedtls.c tst_a71ch_util.c tst_a71ch_util.h tst_sm_time.h tst_sm_time_kinetis.c tst_sm_util.c tst_sm_util.h tst_utils_kinetis.c tst_utils_kinetis.h tst_utils_rtos.c
  group se_hostlib-ax
    ../../../../../middleware/se_hostlib/hostLib/a71ch/src/: a71ch_com.c a71ch_com_scp.c a71ch_crypto_derive.c a71ch_crypto_ecc.c a71ch_module.c a71ch_sst.c
    ../../../../../middleware/se_hostlib/hostLib/api/src/: A71HLSEWrapper.c ax_crypto_aes_key.c ax_crypto_ecc.c ax_crypto_rng.c ax_scp.c ax_sss_scp.c ax_sst.c ax_switch.c ax_util.c
  group mbedtls-mbedtls_include
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls-mbedtls_source
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls-mbedtls_port
    ../../../../../middleware/mbedtls/port/ksdk/: aes_alt.c aes_alt.h des_alt.c des_alt.h ecp_alt.c ecp_alt.h ecp_alt_ksdk.c ecp_curves_alt.c ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h
  group device
    ../../../../../devices/MIMXRT1052/: MIMXRT1052.h MIMXRT1052_features.h fsl_device_registers.h system_MIMXRT1052.c system_MIMXRT1052.h
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c
  group component-uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MIMXRT1052/arm/: startup_MIMXRT1052.s
  group xip
    ../../../../../devices/MIMXRT1052/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h
target se_hostlib_mainA71CH flexspi_nor_release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: se_hostlib_mainA71CH.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1052DVL6B, IMX_RT, MBEDTLS_CONFIG_FILE='\"a71ch_mbedtls_evkbimxrt1050_config.h\"', PRINTF_ADVANCED_ENABLE=1, TGT_A71CH, I2C, MBEDTLS, SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: as above
