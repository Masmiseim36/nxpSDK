# Keil uVision project se_SE05x_cloud_aws.uvprojx, settings and files
target se_SE05x_cloud_aws flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: se_SE05x_cloud_aws.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SKIP_SYSCLK_INIT, XIP_BOOT_HEADER_DCD_ENABLE=1, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1052DVL6B, IMX_RT, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, MBEDTLS_CONFIG_FILE='\"sss_mbedtls_evkbimxrt1050_config.h\"', mqttconfigENABLE_METRICS=0, SDK_DEBUGCONSOLE_UART, FREEDOM, LPC_ENET, AWS_IOT, PRINTF_ADVANCED_ENABLE=1, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS, T1oI2C, T1oI2C_UM1225_SE050, SSS_USE_FTR_FILE, NO_SECURE_CHANNEL_SUPPORT, MBEDTLS, SDK_OS_FREE_RTOS, USE_RTOS, SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../rtos/amazon-freertos/freertos_kernel/portable/GCC/ARM_CM4F;..;../../../../../middleware/se_hostlib/demos/ksdk/se050/aws;../../../../../middleware/se_hostlib/demos/ksdk/aws;../../../../../middleware/se_hostlib/hostlib/demo/aws_jwt_demo;../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/common/include/private;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../rtos/amazon-freertos/freertos_kernel/include;../../../../../rtos/amazon-freertos/libraries/abstractions/secure_sockets/include;../../../../../middleware/mbedtls/include;../../../../../middleware/mbedtls/port/ksdk;../../../../../rtos/amazon-freertos/libraries/abstractions/platform/freertos/include;../../../../../rtos/amazon-freertos/libraries/abstractions/platform/include;../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/tls/include;../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/pkcs11/include;../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/crypto/include;../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/utils/include;../../../../../rtos/amazon-freertos/demos/network_manager;../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/mqtt/include;../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/mqtt/src;../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/common/include;../../../../../rtos/amazon-freertos/libraries/3rdparty/pkcs11;../../../../../rtos/amazon-freertos/libraries/3rdparty/jsmn;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../middleware/lwip/src/include;../../../../../middleware/lwip/port;../../../../../middleware/lwip/src;../../../../../middleware/lwip/src/include;../../../../../middleware/se_hostlib/sss/inc;../../../../../middleware/se_hostlib/sss/ex/inc;../../../../../middleware/se_hostlib/sss/port/ksdk;../../../../../middleware/se_hostlib/hostlib/hostLib/se05x_03_xx_xx;../../mainA71CH;../../../../../middleware/se_hostlib/sss/plugin/mbedtls;../../../../../middleware/se_hostlib/hostlib/hostLib/tstUtil;../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/infra;../../../../../middleware/se_hostlib/hostlib/hostLib/mbedtls/inc;../../../../../rtos/amazon-freertos/lib/include/private;../../../../../rtos/amazon-freertos/lib/pkcs11/portable/nxp/se_hostlib;../../../../../middleware/se_hostlib/demos/ksdk/common/https_client;../../../../../rtos/amazon-freertos/libraries/3rdparty/pkcs11;../../../../../rtos/amazon-freertos/libraries/3rdparty/jsmn;../../../../../rtos/amazon-freertos/vendors/nxp/mflash/se_hostlib;../../../../../rtos/amazon-freertos/libraries/abstractions/secure_sockets/include;../../../../../rtos/amazon-freertos/libraries/abstractions/pkcs11/mbedtls;../../../../../middleware/se_hostlib/demos/ksdk/common/freertos/boards/evkbimxrt1050;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052;../../../../../devices/MIMXRT1052/utilities/str;../../../../../devices/MIMXRT1052/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../components/serial_manager;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/xip;../../../xip;../../../xip;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../middleware/se_hostlib;../../../../../middleware/se_hostlib/hostlib/hostLib/inc;../../../../../middleware/se_hostlib/platform;../../../../../middleware/se_hostlib/hostlib/hostLib/platform/inc;../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom;../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/T1oI2C;../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/infra;../../../../../middleware/se_hostlib/demos/ksdk/common/boards/evkbimxrt1050/se_hostlib_examples/cloud_demo;../../../../../middleware/se_hostlib/demos/ksdk/common;../../../../../middleware/mbedtls/include;../../../../../middleware/mbedtls/port/ksdk;../../../../../middleware/se_hostlib/sss/plugin/mbedtls;../../../../../devices/MIMXRT1052/utilities
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../../../../../middleware/se_hostlib/demo/se_SE05x_cloud_aws;..;../../..;../../../../../middleware/se_hostlib/demos/ksdk/common/freertos/boards/evkbimxrt1050
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: --keep=*(.boot_hdr.dcd_data) --predefine="-D__stack_size__=0x2048" --predefine="-D__heap_size__=0x20000" --predefine="-D__ram_vector_table__=1" --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group se_hostlib-demos-ksdk-common-boards-evkbimxrt1050-se_hostlib_examples-cloud_demo
    ../../../../../middleware/se_hostlib/demos/ksdk/common/boards/evkbimxrt1050/se_hostlib_examples/cloud_demo/: fsl_phy.c fsl_phy.h pin_mux.c pin_mux.h
  group source
    ../: fsl_sss_ftr.h aws_demo.h aws_iot_config.h aws_client_credential_keys.h aws_jitr_demo_Main_lwip.c aws_jitr_task_lwip.c FreeRTOSConfig.h iot_config_common.h
  group board
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_trng.c fsl_trng.h fsl_dcp.c fsl_dcp.h fsl_pit.c fsl_pit.h fsl_cache.c fsl_cache.h fsl_flexspi.c fsl_flexspi.h fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h fsl_gpio.c fsl_gpio.h fsl_lpi2c.c fsl_lpi2c.h fsl_enet.c fsl_enet.h
  group drivers-freertos
    ../../../../../devices/MIMXRT1052/drivers/: fsl_lpi2c_freertos.c fsl_lpi2c_freertos.h
  group se_hostlib-demos-ksdk-common-freertos-boards-evkbimxrt1050
    ../../../../../middleware/se_hostlib/demos/ksdk/common/freertos/boards/evkbimxrt1050/: lwipopts.h FreeRTOSIPConfig.h app.h aws_bufferpool_config.h aws_mqtt_config.h aws_secure_sockets_config.h iot_mqtt_agent_config.h
  group lwip-port-arch
    ../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip-port
    ../../../../../middleware/lwip/port/: sys_arch.c enet_ethernetif_kinetis.c enet_ethernetif.c enet_ethernetif.h enet_ethernetif_priv.h
  group lwip-src-api
    ../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-src-core
    ../../../../../middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip-src-core-ipv4
    ../../../../../middleware/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip-src-core-ipv6
    ../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip-src-include-compat-posix-arpa
    ../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip-src-include-compat-posix-net
    ../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip-src-include-compat-posix
    ../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip-src-include-compat-posix-sys
    ../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip-src-include-compat-stdc
    ../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip-src-include-lwip
    ../../../../../middleware/lwip/src/include/lwip/: altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip-src-include-lwip-priv
    ../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group lwip-src-include-lwip-prot
    ../../../../../middleware/lwip/src/include/lwip/prot/: autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip-src-include-netif
    ../../../../../middleware/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lwip-src-include-netif-ppp
    ../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip-src-include-netif-ppp-polarssl
    ../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip-src-netif
    ../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip-src-netif-ppp
    ../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group device
    ../../../../../devices/MIMXRT1052/: MIMXRT1052.h MIMXRT1052_features.h fsl_device_registers.h system_MIMXRT1052.c system_MIMXRT1052.h
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c
  group component-uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MIMXRT1052/arm/: startup_MIMXRT1052.s
  group xip
    ../../../../../devices/MIMXRT1052/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
  group amazon-freertos-freertos_kernel
    ../../../../../rtos/amazon-freertos/freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos-freertos_kernel-include
    ../../../../../rtos/amazon-freertos/freertos_kernel/include/: FreeRTOS.h atomic.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group amazon-freertos-freertos_kernel-portable-GCC-ARM_CM4F
    ../../../../../rtos/amazon-freertos/freertos_kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group amazon-freertos-freertos_kernel-portable-MemMang
    ../../../../../rtos/amazon-freertos/freertos_kernel/portable/MemMang/: ReadMe.url heap_4.c
  group amazon-freertos-freertos_kernel-portable
    ../../../../../rtos/amazon-freertos/freertos_kernel/portable/: readme.txt
  group amazon-freertos-vendors-nxp-secure_sockets-lwip
    ../../../../../rtos/amazon-freertos/vendors/nxp/secure_sockets/lwip/: iot_secure_sockets.c
  group amazon-freertos-libraries-abstractions-secure_sockets-include
    ../../../../../rtos/amazon-freertos/libraries/abstractions/secure_sockets/include/: iot_secure_sockets.h iot_secure_sockets_config_defaults.h iot_secure_sockets_wrapper_metrics.h
  group se_hostlib-hostlib-hostLib-inc
    ../../../../../middleware/se_hostlib/hostlib/hostLib/inc/: HLSEAPI.h HLSEComm.h HLSECrypto.h HLSEMisc.h HLSEObjects.h HLSETypes.h PlugAndTrust_HostLib_Ver.h PlugAndTrust_Pkg_Ver.h SE_HAL_Lib.h a71ch_api.h a71ch_util.h a71cl_api.h a71cl_util.h ax_api.h ax_common.h ax_common_a71ch.h ax_common_a71cl.h ax_common_private.h ax_scp.h ax_scp_private.h ax_sss_scp.h ax_util.h ledHandler.h nxEnsure.h nxScp03_Apis.h nxScp03_Const.h nxScp03_Types.h scp.h se05x_const.h se05x_ecc_curves.h se05x_ecc_curves_inc.h se05x_ecc_curves_values.h se05x_enums.h se05x_ftr.h se05x_tlv.h sm_const.h ledHandler.h
  group se_hostlib-hostlib-hostLib-se05x-src
    ../../../../../middleware/se_hostlib/hostlib/hostLib/se05x/src/: se05x_ECC_curves.c se05x_mw.c se05x_tlv.c
  group se_hostlib-sss-inc
    ../../../../../middleware/se_hostlib/sss/inc/: fsl_sscp.h fsl_sscp_a71ch.h fsl_sscp_a71cl.h fsl_sscp_commands.h fsl_sscp_mu.h fsl_sss_api.h fsl_sss_api_ver.h fsl_sss_config.h fsl_sss_ftr_default.h fsl_sss_keyid_map.h fsl_sss_mbedtls_apis.h fsl_sss_mbedtls_types.h fsl_sss_openssl_apis.h fsl_sss_openssl_types.h fsl_sss_policy.h fsl_sss_se05x_apis.h fsl_sss_se05x_policy.h fsl_sss_se05x_scp03.h fsl_sss_se05x_types.h fsl_sss_sscp.h fsl_sss_sscp_config.h fsl_sss_util_asn1_der.h fsl_sss_util_rsa_sign_utils.h
  group se_hostlib-sss-port-ksdk
    ../../../../../middleware/se_hostlib/sss/port/ksdk/: fsl_sss_types.h
  group se_hostlib-sss-src
    ../../../../../middleware/se_hostlib/sss/src/: fsl_sss_apis.c fsl_sss_util_asn1_der.c fsl_sss_util_rsa_sign_utils.c
  group se_hostlib-sss-src-se05x
    ../../../../../middleware/se_hostlib/sss/src/se05x/: fsl_sss_se05x_apis.c fsl_sss_se05x_fastscp.c fsl_sss_se05x_mw.c fsl_sss_se05x_policy.c fsl_sss_se05x_scp03.c
  group se_hostlib-hostlib-hostLib-platform-inc
    ../../../../../middleware/se_hostlib/hostlib/hostLib/platform/inc/: ax_reset.h i2c_a7.h se05x_apis.h se_pit_config.h se_reset_config.h sm_printf.h sm_timer.h
  group se_hostlib-hostlib-hostLib-platform-ksdk
    ../../../../../middleware/se_hostlib/hostlib/hostLib/platform/ksdk/: ax_reset.c i2c_frdm.c i2c_imxrt10xx.c i2c_lpc54xxx.c i2c_lpc55sxx.c se05x_reset.c timer_kinetis.c timer_kinetis_bm.c timer_kinetis_freertos.c
  group se_hostlib-hostlib-hostLib-libCommon-smCom-T1oI2C
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/T1oI2C/: phEseStatus.h phEseTypes.h phNxpEsePal_i2c.c phNxpEsePal_i2c.h phNxpEseProto7816_3.c phNxpEseProto7816_3.h phNxpEse_Api.c phNxpEse_Api.h phNxpEse_Internal.h
  group se_hostlib-hostlib-hostLib-libCommon-smCom
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/: apduComm.h sci2c_cfg.h smCom.c smCom.h smComT1oI2C.c smComT1oI2C.h
  group se_hostlib-hostlib-hostLib-libCommon-infra
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/infra/: a71_debug.h app_boot.h app_boot_nfc.h global_platf.c global_platf.h nxLog.c nxLog.h nxLog_App.h nxLog_DefaultConfig.h nxLog_UseCases.h nxLog_VCOM.h nxLog_hostLib.h nxLog_mbedtls.h nxLog_scp.h nxLog_smCom.h nxLog_sscp.h nxLog_sss.h sm_apdu.c sm_apdu.h sm_api.h sm_connect.c sm_demo_utils.h sm_errors.c sm_errors.h sm_printf.c sm_types.h sm_demo_utils.c sm_demo_utils_rtos.c
  group se_hostlib-sss-ex-inc
    ../../../../../middleware/se_hostlib/sss/ex/inc/: ex_sss.h ex_sss_auth.h ex_sss_boot.h ex_sss_main_freeRTOS_inc.h ex_sss_main_inc.h ex_sss_main_inc_frdmk64f.h ex_sss_main_inc_imx_rt.h ex_sss_main_inc_ksdk.h ex_sss_main_inc_lpcxpresso55s.h ex_sss_objid.h ex_sss_ports.h ex_sss_scp03_keys.h ex_sss_tp_scp03_keys.h
  group se_hostlib-sss-ex-src
    ../../../../../middleware/se_hostlib/sss/ex/src/: ex_sss_boot.c ex_sss_boot_connectstring.c ex_sss_boot_int.h ex_sss_se05x.c ex_sss_se05x_auth.c
  group se_hostlib-hostlib-hostLib-se05x_03_xx_xx
    ../../../../../middleware/se_hostlib/hostlib/hostLib/se05x_03_xx_xx/: Applet_SE050_Ver.h se05x_APDU.c se05x_APDU.h se05x_APDU_apis.h se05x_APDU_impl.h
  group se_hostlib-hostlib-hostLib-libCommon-nxScp
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/nxScp/: nxScp03_Com.c
  group se_hostlib-hostlib-hostLib-libCommon-scp
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/scp/: scp.c
  group se_hostlib-demos-ksdk-common
    ../../../../../middleware/se_hostlib/demos/ksdk/common/: aws_clientcredential.h aws_clientcredential_keys.h aws_demo_config.h aws_pkcs11_config.h iot_config.h iot_config_common.h iot_logging_task.h iot_pkcs11_config.h ledHandler.c
  group se_hostlib-demos-ksdk-common-freertos
    ../../../../../middleware/se_hostlib/demos/ksdk/common/freertos/: FreeRTOSConfig.c
  group se_hostlib-demos-ksdk-common-https_client
    ../../../../../middleware/se_hostlib/demos/ksdk/common/https_client/: httpsclient.h
  group se_hostlib-hostlib-hostLib-tstUtil
    ../../../../../middleware/se_hostlib/hostlib/hostLib/tstUtil/: tstHostCrypto.h
  group amazon-freertos-libraries-abstractions-pkcs11-mbedtls
    ../../../../../rtos/amazon-freertos/libraries/abstractions/pkcs11/mbedtls/: threading_alt.h
  group amazon-freertos-vendors-nxp-pkcs11-se_hostlib
    ../../../../../rtos/amazon-freertos/vendors/nxp/pkcs11/se_hostlib/: aws_pkcs11_pal.c
  group mbedtls-include-mbedtls
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls-library
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls-port-ksdk
    ../../../../../middleware/mbedtls/port/ksdk/: aes_alt.c aes_alt.h des_alt.c des_alt.h ecp_alt.c ecp_alt.h ecp_alt_ksdk.c ecp_curves_alt.c ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h
  group amazon-freertos-libraries-abstractions-platform-freertos-include-platform
    ../../../../../rtos/amazon-freertos/libraries/abstractions/platform/freertos/include/platform/: iot_network_ble.h iot_network_freertos.h iot_platform_types_freertos.h
  group amazon-freertos-libraries-abstractions-platform-freertos
    ../../../../../rtos/amazon-freertos/libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_metrics.c iot_network_freertos.c iot_threads_freertos.c
  group amazon-freertos-libraries-abstractions-platform-include-platform
    ../../../../../rtos/amazon-freertos/libraries/abstractions/platform/include/platform/: iot_clock.h iot_metrics.h iot_network.h iot_threads.h
  group amazon-freertos-libraries-abstractions-platform-include-types
    ../../../../../rtos/amazon-freertos/libraries/abstractions/platform/include/types/: iot_platform_types.h
  group amazon-freertos-libraries-freertos_plus-standard-tls-include
    ../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/tls/include/: iot_tls.h
  group amazon-freertos-libraries-freertos_plus-standard-tls-src
    ../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group amazon-freertos-libraries-freertos_plus-standard-pkcs11-include
    ../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/pkcs11/include/: iot_pkcs11.h
  group amazon-freertos-libraries-freertos_plus-standard-pkcs11-src
    ../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/pkcs11/src/: iot_pkcs11.c
  group amazon-freertos-libraries-freertos_plus-standard-crypto-include
    ../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/crypto/include/: iot_crypto.h
  group amazon-freertos-libraries-freertos_plus-standard-crypto-src
    ../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group amazon-freertos-libraries-freertos_plus-standard-utils-include
    ../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/utils/include/: iot_pki_utils.h iot_system_init.h
  group amazon-freertos-libraries-freertos_plus-standard-utils-src
    ../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/utils/src/: iot_pki_utils.c iot_system_init.c
  group amazon-freertos-libraries-c_sdk-standard-common-include
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/common/include/: iot_appversion32.h iot_atomic.h iot_init.h iot_linear_containers.h iot_logging_setup.h iot_logging_task.h iot_taskpool.h
  group amazon-freertos-libraries-c_sdk-standard-common-include-private
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/common/include/private/: iot_default_root_certificates.h iot_doubly_linked_list.h iot_error.h iot_lib_init.h iot_logging.h iot_static_memory.h iot_taskpool_internal.h
  group amazon-freertos-libraries-c_sdk-standard-common-include-types
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/common/include/types/: iot_network_types.h iot_taskpool_types.h
  group amazon-freertos-libraries-c_sdk-standard-common
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/common/: iot_device_metrics.c iot_init.c iot_static_memory_common.c
  group amazon-freertos-libraries-c_sdk-standard-common-logging
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/common/logging/: iot_logging.c iot_logging_task_dynamic_buffers.c
  group amazon-freertos-libraries-c_sdk-standard-common-taskpool
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group amazon-freertos-libraries-c_sdk-standard-mqtt-include
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/mqtt/include/: iot_mqtt.h iot_mqtt_agent.h iot_mqtt_agent_config_defaults.h iot_mqtt_config_defaults.h iot_mqtt_lib.h
  group amazon-freertos-libraries-c_sdk-standard-mqtt-include-types
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/mqtt/include/types/: iot_mqtt_types.h
  group amazon-freertos-libraries-c_sdk-standard-mqtt-src
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/mqtt/src/: iot_mqtt_agent.c iot_mqtt_api.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_serialize.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_validate.c
  group amazon-freertos-libraries-c_sdk-standard-mqtt-src-private
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/mqtt/src/private/: iot_mqtt_internal.h
  group amazon-freertos-libraries-3rdparty-pkcs11
    ../../../../../rtos/amazon-freertos/libraries/3rdparty/pkcs11/: pkcs11.h pkcs11f.h pkcs11t.h
  group amazon-freertos-libraries-3rdparty-jsmn
    ../../../../../rtos/amazon-freertos/libraries/3rdparty/jsmn/: jsmn.c jsmn.h
  group se_hostlib-sss-plugin-mbedtls
    ../../../../../middleware/se_hostlib/sss/plugin/mbedtls/: ecdh_alt_ax.c ecp_alt_sss.c sss_mbedtls.c sss_mbedtls_rsa.c ecp_alt.h rsa_alt.h sss_mbedtls.h sss_mbedtls_evkbimxrt1050_config.h sss_mbedtls_frdmk64f_config.h sss_mbedtls_frdmkw41z_config.h sss_mbedtls_lpcxpresso55s69_config.h sss_mbedtls_x86_config.h
  group se_hostlib-hostlib-hostLib-mbedtls-inc
    ../../../../../middleware/se_hostlib/hostlib/hostLib/mbedtls/inc/: a71ch_mbedtls_evkbimxrt1050_config.h a71ch_mbedtls_evkmimxrt1050_config.h a71ch_mbedtls_frdm_config.h a71ch_mbedtls_frdmk64f_config.h a71ch_mbedtls_frdmk82f_config.h a71ch_mbedtls_frdmkw41z_config.h a71ch_mbedtls_lpc54018iotmodule_config.h a71ch_mbedtls_lpcxpresso54018_config.h a71ch_mbedtls_lpcxpresso55s69_config.h a71ch_mbedtls_pi_config.h a71ch_mbedtls_x86_config.h ax_mbedtls.h ecp_alt.h
  group se_hostlib-hostlib-hostLib-mbedtls-src
    ../../../../../middleware/se_hostlib/hostlib/hostLib/mbedtls/src/: ecdh_alt.c rsa_alt.c
  group se_hostlib-sss-src-mbedtls
    ../../../../../middleware/se_hostlib/sss/src/mbedtls/: fsl_sss_mbedtls_apis.c
target se_SE05x_cloud_aws flexspi_nor_release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: se_SE05x_cloud_aws.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SKIP_SYSCLK_INIT, XIP_BOOT_HEADER_DCD_ENABLE=1, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1052DVL6B, IMX_RT, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, MBEDTLS_CONFIG_FILE='\"sss_mbedtls_evkbimxrt1050_config.h\"', mqttconfigENABLE_METRICS=0, SDK_DEBUGCONSOLE_UART, FREEDOM, LPC_ENET, AWS_IOT, PRINTF_ADVANCED_ENABLE=1, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS, T1oI2C, T1oI2C_UM1225_SE050, SSS_USE_FTR_FILE, NO_SECURE_CHANNEL_SUPPORT, MBEDTLS, SDK_OS_FREE_RTOS, USE_RTOS, SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: as above
