# IAR project wolfssl_benchmark.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1052DVL6B; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; FREESCALE_KSDK_BM; WOLFSSL_USER_SETTINGS
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ..; ../../..; ../../../../../middleware/wolfssl; ../../../../../middleware/wolfssl/wolfssl/wolfcrypt/port; ../../../../../devices/MIMXRT1052/drivers; ../../../../../devices/MIMXRT1052; ../../../../../devices/MIMXRT1052/utilities/io; ../../../../../devices/MIMXRT1052/utilities/str; ../../../../../devices/MIMXRT1052/utilities/log; ../../../../../devices/MIMXRT1052/utilities; ../../../../../devices/MIMXRT1052/xip
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: wolfssl_benchmark.out
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; CPU_MIMXRT1052DVL6B; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; FREESCALE_KSDK_BM; WOLFSSL_USER_SETTINGS
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; DEBUG; CPU_MIMXRT1052DVL6B; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; FREESCALE_KSDK_BM; WOLFSSL_USER_SETTINGS
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1052DVL6B; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; FREESCALE_KSDK_BM; WOLFSSL_USER_SETTINGS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; CPU_MIMXRT1052DVL6B; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; FREESCALE_KSDK_BM; WOLFSSL_USER_SETTINGS
  ICCARM.CCOptLevel: 2
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SKIP_SYSCLK_INIT; CPU_MIMXRT1052DVL6B; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; FREESCALE_KSDK_BM; WOLFSSL_USER_SETTINGS
  ICCARM.CCOptLevel: 2
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram.icf
  group source
    ../: wolfssl_benchmark.c user_settings.h
  group board
    ../: pin_mux.c pin_mux.h
  group board/src
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_dcp.c fsl_dcp.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_trng.c fsl_trng.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group startup
    ../../../../../devices/MIMXRT1052/: system_MIMXRT1052.c system_MIMXRT1052.h
    ../../../../../devices/MIMXRT1052/iar/: startup_MIMXRT1052.s
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MIMXRT1052/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1052/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group xip
    ../../../../../devices/MIMXRT1052/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h
  group wolfssl/wolfssl_include
    ../../../../../middleware/wolfssl/wolfssl/: callbacks.h certs_test.h crl.h error-ssl.h internal.h ocsp.h options.h sniffer.h sniffer_error.h ssl.h test.h version.h
    ../../../../../middleware/wolfssl/wolfssl/openssl/: ec.h ssl.h bn.h
    ../../../../../middleware/wolfssl/wolfssl/wolfcrypt/: aes.h arc4.h asn.h asn_public.h blake2.h blake2-impl.h blake2-int.h camellia.h cmac.h chacha.h chacha20_poly1305.h coding.h compress.h curve25519.h des3.h dh.h dsa.h ecc.h ed25519.h error-crypt.h fe_operations.h fips_test.h ge_operations.h hash.h hc128.h hmac.h integer.h idea.h logging.h md2.h md4.h md5.h mem_track.h memory.h misc.h mpi_class.h mpi_superclass.h pkcs7.h poly1305.h pwdbased.h rabbit.h random.h ripemd.h rsa.h settings.h sha.h sha256.h sha512.h signature.h srp.h tfm.h types.h visibility.h wc_encrypt.h wc_port.h
  group wolfssl/wolfssl_source
    ../../../../../middleware/wolfssl/wolfcrypt/src/: aes.c arc4.c asm.c asn.c blake2b.c camellia.c cmac.c chacha.c chacha20_poly1305.c coding.c compress.c curve25519.c des3.c dh.c dsa.c ecc.c ecc_fp.c ed25519.c error.c fe_low_mem.c fe_operations.c ge_low_mem.c ge_operations.c hash.c hc128.c hmac.c integer.c idea.c logging.c md2.c md4.c md5.c memory.c misc.c pkcs7.c poly1305.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha512.c signature.c srp.c tfm.c wc_encrypt.c wc_port.c
    ../../../../../middleware/wolfssl/src/: async.c crl.c internal.c io.c keys.c ocsp.c sniffer.c ssl.c tls.c
  group wolfssl/wolfssl_port
    ../../../../../middleware/wolfssl/wolfcrypt/src/port/nxp/: ksdk_port.c
    ../../../../../middleware/wolfssl/wolfssl/wolfcrypt/port/nxp/: ksdk_port.h
