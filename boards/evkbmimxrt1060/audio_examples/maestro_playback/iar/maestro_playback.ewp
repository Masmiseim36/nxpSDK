# IAR project maestro_playback.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6B NXP MIMXRT1062xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; FLAC_DEC=1; CPU_MIMXRT1062DVL6B; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; PRINTF_ADVANCED_ENABLE=1; PRINTF_FLOAT_ENABLE=1; OGG_OPUS_DEC=1; WAV_DEC=1; SSRC_PROC=1; MP3_DEC=1; STREAMER_ENABLE_FILESRC; STREAMER_ENABLE_MEM_SRC; STREAMER_ENABLE_MEM_SINK; STREAMER_ENABLE_DECODER; STREAMER_ENABLE_AUDIO_PROC; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; OSA_USED; SHELL_TASK_STACK_SIZE=4000; SAI_XFER_QUEUE_SIZE=2; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; CODEC_MULTI_ADAPTERS=1; SD_ENABLED; CASCFG_PLATFORM_FREERTOS; FSL_OS_SELECTED=SDK_OS_FREERTOS; FSL_OSA_TASK_ENABLE=1; DEBUG_CONSOLE_RX_ENABLE=0; HAVE_CONFIG_H; SERIAL_PORT_TYPE_UART=1; CODEC_CS42448_ENABLE; SDK_OS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.IExtraOptions: --align_sp_on_irq  --macro_positions_in_diagnostics  --header_context  --no_unaligned_access
  ICCARM.CCIncludePath2: ..; ../../common/att; ../../..; ../../../../../devices/MIMXRT1062/drivers; ../../../../../components/codec/wm8960; ../../../../../components/codec/port; ../../../../../components/codec; ../../../../../components/codec/port/wm8960; ../../../../../components/codec/port/cs42448; ../../../../../components/i2c; ../../../../../components/codec/i2c; ../../../../../middleware/sdmmc/host/usdhc; ../../../../../middleware/sdmmc/sd; ../../../../../components/gpio; ../../../../../middleware/maestro/config; ../../../../../middleware/maestro/inc; ../../../../../middleware/maestro/streamer/cci/include; ../../../../../middleware/maestro/streamer/core; ../../../../../middleware/maestro/streamer/decoders/cci_dec; ../../../../../middleware/maestro/streamer/devices; ../../../../../middleware/maestro/streamer/elements; ../../../../../middleware/maestro/streamer/encoders/opus; ../../../../../middleware/maestro/streamer/encoders/cei; ../../../../../middleware/maestro/streamer/pipelines; ../../../../../devices/MIMXRT1062/utilities; ../../../../../middleware/fatfs/source/fsl_sd_disk; ../../../../../middleware/fatfs/source; ../../../../../middleware/maestro/mcu-audio/opus/celt; ../../../../../middleware/maestro/mcu-audio/opus/include; ../../../../../middleware/maestro/mcu-audio/opus/silk; ../../../../../middleware/maestro/mcu-audio/opus/silk/fixed; ../../../../../middleware/maestro/mcu-audio/opus/src; ../../../../../middleware/maestro/mcu-audio/opusfile/include; ../../../../../middleware/maestro/mcu-audio/opusfile/src; ../../../../../middleware/maestro/mcu-audio/ogg/include; ../../../../../middleware/maestro/mcu-audio/ogg/src; ../../../../../devices/MIMXRT1062; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../devices/MIMXRT1062/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../devices/MIMXRT1062/xip; ../../../xip; ../../../../../components/codec/cs42448; ../../../../../middleware/sdmmc/common; ../../../../../middleware/sdmmc/osa; ../../../../../components/osa; ../../../../../rtos/freertos/freertos-kernel/include; ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F; ../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: maestro_playback.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x3000
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/maestro/libs/cm7f/iar/release/libmp3.a; ../../../../../middleware/maestro/libs/cm7f/iar/release/libwav.a; ../../../../../middleware/maestro/libs/cm7f/iar/release/libflac.a; ../../../../../middleware/maestro/libs/cm7f/iar/release/libssrc.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; FLAC_DEC=1; CPU_MIMXRT1062DVL6B; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; PRINTF_ADVANCED_ENABLE=1; PRINTF_FLOAT_ENABLE=1; OGG_OPUS_DEC=1; WAV_DEC=1; SSRC_PROC=1; MP3_DEC=1; STREAMER_ENABLE_FILESRC; STREAMER_ENABLE_MEM_SRC; STREAMER_ENABLE_MEM_SINK; STREAMER_ENABLE_DECODER; STREAMER_ENABLE_AUDIO_PROC; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; OSA_USED; SHELL_TASK_STACK_SIZE=4000; SAI_XFER_QUEUE_SIZE=2; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; CODEC_MULTI_ADAPTERS=1; SD_ENABLED; CASCFG_PLATFORM_FREERTOS; FSL_OS_SELECTED=SDK_OS_FREERTOS; FSL_OSA_TASK_ENABLE=1; DEBUG_CONSOLE_RX_ENABLE=0; HAVE_CONFIG_H; SERIAL_PORT_TYPE_UART=1; CODEC_CS42448_ENABLE; SDK_OS_FREE_RTOS
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: streamer_pcm.c streamer_pcm_app.h app_data.h app_streamer.c app_streamer.h cmd.c cmd.h ssrc_proc.c ssrc_proc.h main.c main.h FreeRTOSConfig.h ffconf.h app_definitions.h
  group board
    ../: pin_mux.c pin_mux.h sdmmc_config.c sdmmc_config.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group att
    ../../common/att/: eap_att.c eap_att.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_lpi2c.c fsl_lpi2c.h fsl_sai.h fsl_sai.c fsl_sai_edma.h fsl_sai_edma.c fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_cache.c fsl_cache.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_usdhc.c fsl_usdhc.h
  group codec
    ../../../../../components/codec/wm8960/: fsl_wm8960.h fsl_wm8960.c
    ../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
    ../../../../../components/codec/cs42448/: fsl_cs42448.h fsl_cs42448.c
  group codec/port
    ../../../../../components/codec/port/: fsl_codec_adapter.c fsl_codec_adapter.h fsl_codec_adapter.h
  group codec/port/wm8960
    ../../../../../components/codec/port/wm8960/: fsl_codec_wm8960_adapter.c fsl_codec_wm8960_adapter.h
  group codec/port/cs42448
    ../../../../../components/codec/port/cs42448/: fsl_codec_cs42448_adapter.c fsl_codec_cs42448_adapter.h
  group component/i2c
    ../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group component/gpio
    ../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h fsl_os_abstraction_config.h
  group sdmmc/host
    ../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt ChangeLogKSDK.txt
    ../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group sdmmc/src
    ../../../../../middleware/sdmmc/sd/: fsl_sd.c
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc/sd/: fsl_sd.h
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sd
    ../../../../../middleware/sdmmc/sd/: ChangeLogKSDK.txt
  group sdmmc/osa
    ../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group freertos/freertos-kernel
    ../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/portable
    ../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos-kernel/portable/IAR/ARM_CM4F
    ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos-kernel/include
    ../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group maestro/inc
    ../../../../../middleware/maestro/inc/: error.h file_utils.h general_utils.h maestro_logging.h ringbuffer.h streamer_api.h streamer_element_properties.h streamer_message.h streamer_pcm.h
  group maestro/config
    ../../../../../middleware/maestro/config/: audio_cfg.h
  group maestro/streamer/cci/include
    ../../../../../middleware/maestro/streamer/cci/include/: LVC_Types.h cci_metadata.h codec_interface.h codec_interface_public_api.h errordefs.h ssrc_head.h
  group maestro/streamer/cci/metadata/src/mp3
    ../../../../../middleware/maestro/streamer/cci/metadata/src/mp3/: mp3_extractmetadata.c mp3_id3v2.c mp3_vbr.c mp3_id3v2.h mp3_id3v2_internal.h mp3_metadata.h
  group maestro/streamer/cci/metadata/src/adpcm
    ../../../../../middleware/maestro/streamer/cci/metadata/src/adpcm/: adpcm_extractmetadata.c wav_common.c wav_metadata.h wavedata.h wavedefs.h
  group maestro/streamer/cci/metadata/src/opus
    ../../../../../middleware/maestro/streamer/cci/metadata/src/opus/: opus_extractmetadata.c
  group maestro/streamer/cci/metadata/src/aac
    ../../../../../middleware/maestro/streamer/cci/metadata/src/aac/: aac_extractmetadata.c
  group maestro/streamer/cci/metadata/src/flac
    ../../../../../middleware/maestro/streamer/cci/metadata/src/flac/: flac_extractmetadata.c
  group maestro/streamer/core
    ../../../../../middleware/maestro/streamer/core/: pad.h pipeline.h streamer.h streamer_element.h pad.c pipeline.c streamer.c streamer_element.c streamer_msg.c
  group maestro/streamer/decoders/cci_dec
    ../../../../../middleware/maestro/streamer/decoders/cci_dec/: ccidec.h ccidec.c codec_interface.c codecextractmetadata.c
  group maestro/streamer/devices
    ../../../../../middleware/maestro/streamer/devices/: audio_sink_pcmrtos.h audio_src_pcmrtos.h audio_sink_pcmrtos.c audio_src_pcmrtos.c
  group maestro/streamer/elements
    ../../../../../middleware/maestro/streamer/elements/: audio_proc.h audio_sink.h audio_src.h decoder.h decoder_pads.h encoder.h file_sink.h file_src_freertos.h mem_sink.h mem_src.h netbuf_src.h vit_sink.h audio_proc.c audio_sink.c audio_src.c decoder.c decoder_pads.c file_sink.c file_src_freertos.c mem_sink.c vit_sink.c mem_src.c netbuf_src.c encoder.c
  group maestro/streamer/pipelines
    ../../../../../middleware/maestro/streamer/pipelines/: streamer_audiosrc.h streamer_fs.h streamer_mic2file.h streamer_opusmem2mem.h streamer_pcm_speaker.h streamer_pcm_speaker_mem.h streamer_testeapfile2file.h streamer_vit.h streamer_vit_filesink.h streamer_audiosrc.c streamer_fs.c streamer_mic2file.c streamer_opusmem2mem.c streamer_pcm_speaker.c streamer_pcm_speaker_mem.c streamer_testeapfile2file.c streamer_vit.c streamer_vit_filesink.c
  group maestro/streamer/encoders/cei
    ../../../../../middleware/maestro/streamer/encoders/cei/: cei.h cei_enctypes.h cei_table.h
  group maestro/streamer/encoders/opus
    ../../../../../middleware/maestro/streamer/encoders/opus/: opusenc_cei.h opusenc_cei.c
  group maestro/streamer/parsers/cci
    ../../../../../middleware/maestro/streamer/parsers/cci/: cci_codec_type_conversion.c
  group maestro/streamer/utils
    ../../../../../middleware/maestro/streamer/utils/: file_utils.c general_utils.c maestro_logging.c ringbuffer.c
  group maestro/opus/celt
    ../../../../../middleware/maestro/mcu-audio/opus/celt/: bands.c celt.c celt_decoder.c celt_encoder.c celt_lpc.c cwrs.c entcode.c entdec.c entenc.c kiss_fft.c laplace.c mathops.c mdct.c modes.c pitch.c quant_bands.c rate.c vq.c _kiss_fft_guts.h arch.h bands.h celt.h celt_lpc.h cpu_support.h cwrs.h ecintrin.h entcode.h entdec.h entenc.h fixed_c5x.h fixed_c6x.h fixed_debug.h fixed_generic.h float_cast.h kiss_fft.h laplace.h mathops.h mdct.h mfrngcod.h modes.h os_support.h pitch.h quant_bands.h rate.h stack_alloc.h static_modes_fixed.h static_modes_float.h vq.h
  group maestro/opus/include
    ../../../../../middleware/maestro/mcu-audio/opus/include/: config.h opus.h opus_cci.h opus_cci_raw.h opus_custom.h opus_defines.h opus_multistream.h opus_projection.h opus_types.h test_opus_common.h
  group maestro/opus/silk
    ../../../../../middleware/maestro/mcu-audio/opus/silk/: A2NLSF.c CNG.c HP_variable_cutoff.c LPC_analysis_filter.c LPC_fit.c LPC_inv_pred_gain.c LP_variable_cutoff.c NLSF2A.c NLSF_VQ.c NLSF_VQ_weights_laroia.c NLSF_decode.c NLSF_del_dec_quant.c NLSF_encode.c NLSF_stabilize.c NLSF_unpack.c NSQ.c NSQ_del_dec.c PLC.c VAD.c VQ_WMat_EC.c ana_filt_bank_1.c biquad_alt.c bwexpander.c bwexpander_32.c check_control_input.c code_signs.c control_SNR.c control_audio_bandwidth.c control_codec.c debug.c dec_API.c decode_core.c decode_frame.c decode_indices.c decode_parameters.c decode_pitch.c decode_pulses.c decoder_set_fs.c enc_API.c encode_indices.c encode_pulses.c gain_quant.c init_decoder.c init_encoder.c inner_prod_aligned.c interpolate.c lin2log.c log2lin.c pitch_est_tables.c process_NLSFs.c quant_LTP_gains.c resampler.c resampler_down2.c resampler_down2_3.c resampler_private_AR2.c resampler_private_IIR_FIR.c resampler_private_down_FIR.c resampler_private_up2_HQ.c resampler_rom.c shell_coder.c sigm_Q15.c sort.c stereo_LR_to_MS.c stereo_MS_to_LR.c stereo_decode_pred.c stereo_encode_pred.c stereo_find_predictor.c stereo_quant_pred.c sum_sqr_shift.c table_LSF_cos.c tables_LTP.c tables_NLSF_CB_NB_MB.c tables_NLSF_CB_WB.c tables_gain.c tables_other.c tables_pitch_lag.c tables_pulses_per_block.c API.h Inlines.h MacroCount.h MacroDebug.h NSQ.h PLC.h SigProc_FIX.h control.h debug.h define.h errors.h macros.h main.h pitch_est_defines.h resampler_private.h resampler_rom.h resampler_structs.h structs.h tables.h tuning_parameters.h typedef.h
  group maestro/opus/silk/fixed
    ../../../../../middleware/maestro/mcu-audio/opus/silk/fixed/: LTP_analysis_filter_FIX.c LTP_scale_ctrl_FIX.c apply_sine_window_FIX.c autocorr_FIX.c burg_modified_FIX.c corrMatrix_FIX.c encode_frame_FIX.c find_LPC_FIX.c find_LTP_FIX.c find_pitch_lags_FIX.c find_pred_coefs_FIX.c k2a_FIX.c k2a_Q16_FIX.c noise_shape_analysis_FIX.c pitch_analysis_core_FIX.c process_gains_FIX.c regularize_correlations_FIX.c residual_energy16_FIX.c residual_energy_FIX.c schur64_FIX.c schur_FIX.c vector_ops_FIX.c warped_autocorrelation_FIX.c main_FIX.h structs_FIX.h
  group maestro/opus/src
    ../../../../../middleware/maestro/mcu-audio/opus/src/: opus.c opus_cci.c opus_cci_raw.c opus_decoder.c opus_encoder.c opus_multistream.c opus_multistream_decoder.c opus_multistream_encoder.c repacketizer.c analysis.h mlp.h opus_private.h
  group maestro/opusfile/src
    ../../../../../middleware/maestro/mcu-audio/opusfile/src/: info.c internal.c opusfile.c stream.c internal.h
  group maestro/opusfile/include
    ../../../../../middleware/maestro/mcu-audio/opusfile/include/: opusfile.h
  group maestro/ogg/include/ogg
    ../../../../../middleware/maestro/mcu-audio/ogg/include/ogg/: memory.h ogg.h os_types.h
  group maestro/ogg/src
    ../../../../../middleware/maestro/mcu-audio/ogg/src/: framing.c memory.c crctable.h
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/: fsl_shell.c fsl_shell.h fsl_assert.c
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group fatfs/source
    ../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_sd_disk
    ../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group startup
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkbmimxrt1060_flexspi_nor_config.c evkbmimxrt1060_flexspi_nor_config.h
  group EAP/Doc
    ../../../../../middleware/EAP/Doc/: EAP_SDK_ApplicationNote.pdf EAP_UserGuide.pdf
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
