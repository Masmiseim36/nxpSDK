# IAR project maestro_playback_8ch_96kHz.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1062DVL6A; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; OSA_USED; SHELL_TASK_STACK_SIZE=4000; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; CODEC_MULTI_ADAPTERS=1; SD_ENABLED; SAI_XFER_QUEUE_SIZE=2; DEBUG_CONSOLE_RX_ENABLE=0; SERIAL_PORT_TYPE_UART=1; CODEC_CS42448_ENABLE; SDK_OS_FREE_RTOS; CASCFG_PLATFORM_FREERTOS; FSL_OS_SELECTED=SDK_OS_FREERTOS; FSL_OSA_TASK_ENABLE=1; STREAMER_ENABLE_FILESRC; STREAMER_ENABLE_FILE_SINK; STREAMER_ENABLE_MEM_SRC; STREAMER_ENABLE_MEM_SINK; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa050,Pa082,Pe186,Pe815
  ICCARM.IExtraOptions: --align_sp_on_irq  --macro_positions_in_diagnostics  --header_context  --no_unaligned_access
  ICCARM.CCIncludePath2: ..; ../../common/att; ../../..; ../../../../../devices/MIMXRT1062/drivers; ../../../../../components/codec/wm8960; ../../../../../components/codec; ../../../../../components/codec/port; ../../../../../components/codec/port/wm8960; ../../../../../components/codec/port/cs42448; ../../../../../components/codec/i2c; ../../../../../components/i2c; ../../../../../middleware/sdmmc/sd; ../../../../../middleware/sdmmc/common; ../../../../../middleware/sdmmc/host/usdhc; ../../../../../components/gpio; ../../../../../middleware/maestro/config; ../../../../../middleware/maestro/inc; ../../../../../devices/MIMXRT1062/utilities; ../../../../../middleware/fatfs/source; ../../../../../middleware/fatfs/source/fsl_sd_disk; ../../../../../devices/MIMXRT1062; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../devices/MIMXRT1062/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../devices/MIMXRT1062/xip; ../../../xip; ../../../../../components/silicon_id; ../../../../../CMSIS/Core/Include; ../../../../../components/codec/cs42448; ../../../../../middleware/sdmmc/osa; ../../../../../components/osa; ../../../../../rtos/freertos/freertos_kernel/include; ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F; ../../../../../middleware/maestro/streamer/cci/include; ../../../../../middleware/maestro/streamer/core; ../../../../../middleware/maestro/streamer/decoders/cci_dec; ../../../../../middleware/maestro/streamer/devices; ../../../../../middleware/maestro/streamer/elements; ../../../../../middleware/maestro/streamer/encoders/opus; ../../../../../middleware/maestro/streamer/encoders/cei; ../../../../../middleware/maestro/streamer/pipelines
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: maestro_playback_8ch_96kHz.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x3000
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/maestro/libs/cm7f/iar/release/libmp3.a; ../../../../../middleware/maestro/libs/cm7f/iar/release/libwav.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1062DVL6A; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; OSA_USED; SHELL_TASK_STACK_SIZE=4000; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; CODEC_MULTI_ADAPTERS=1; SD_ENABLED; SAI_XFER_QUEUE_SIZE=2; DEBUG_CONSOLE_RX_ENABLE=0; SERIAL_PORT_TYPE_UART=1; CODEC_CS42448_ENABLE; SDK_OS_FREE_RTOS; CASCFG_PLATFORM_FREERTOS; FSL_OS_SELECTED=SDK_OS_FREERTOS; FSL_OSA_TASK_ENABLE=1; STREAMER_ENABLE_FILESRC; STREAMER_ENABLE_FILE_SINK; STREAMER_ENABLE_MEM_SRC; STREAMER_ENABLE_MEM_SINK; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: streamer_pcm.c streamer_pcm_app.h app_data.h app_streamer.c app_streamer.h cmd.c cmd.h main.c main.h FreeRTOSConfig.h ffconf.h app_definitions.h
  group board
    ../: pin_mux.c pin_mux.h sdmmc_config.c sdmmc_config.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group att
    ../../common/att/: eap_att.c eap_att.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_lpi2c.c fsl_lpi2c.h fsl_sai.h fsl_sai.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_sai_edma.h fsl_sai_edma.c fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_cache.c fsl_cache.h fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_usdhc.c fsl_usdhc.h
  group codec
    ../../../../../components/codec/wm8960/: fsl_wm8960.h fsl_wm8960.c
    ../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
    ../../../../../components/codec/cs42448/: fsl_cs42448.h fsl_cs42448.c
  group codec/port
    ../../../../../components/codec/port/: fsl_codec_adapter.c fsl_codec_adapter.h fsl_codec_adapter.h
  group codec/port/wm8960
    ../../../../../components/codec/port/wm8960/: fsl_codec_wm8960_adapter.c fsl_codec_wm8960_adapter.h
  group codec/port/cs42448
    ../../../../../components/codec/port/cs42448/: fsl_codec_cs42448_adapter.c fsl_codec_cs42448_adapter.h
  group component/i2c
    ../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group component/gpio
    ../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/silicon_id
    ../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c
  group sdmmc/src
    ../../../../../middleware/sdmmc/sd/: fsl_sd.c
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc/sd/: fsl_sd.h
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sd
    ../../../../../middleware/sdmmc/sd/: ChangeLogKSDK.txt
  group sdmmc/host
    ../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt
    ../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group sdmmc/osa
    ../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group freertos/freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/include
    ../../../../../rtos/freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group maestro/inc
    ../../../../../middleware/maestro/inc/: error.h file_utils.h general_utils.h logging.h ringbuffer.h streamer_api.h streamer_element_properties.h streamer_message.h streamer_pcm.h
  group maestro/config
    ../../../../../middleware/maestro/config/: audio_cfg.h
  group maestro/streamer/cci/include
    ../../../../../middleware/maestro/streamer/cci/include/: cci_metadata.h codec_interface.h codec_interface_public_api.h errordefs.h
  group maestro/streamer/cci/metadata/src/mp3
    ../../../../../middleware/maestro/streamer/cci/metadata/src/mp3/: mp3_extractmetadata.c mp3_id3v2.c mp3_vbr.c mp3_id3v2.h mp3_id3v2_internal.h mp3_metadata.h
  group maestro/streamer/cci/metadata/src/adpcm
    ../../../../../middleware/maestro/streamer/cci/metadata/src/adpcm/: adpcm_extractmetadata.c
  group maestro/streamer/cci/metadata/src/opus
    ../../../../../middleware/maestro/streamer/cci/metadata/src/opus/: opus_extractmetadata.c
  group maestro/streamer/core
    ../../../../../middleware/maestro/streamer/core/: pad.h pipeline.h streamer.h streamer_element.h pad.c pipeline.c streamer.c streamer_element.c streamer_msg.c
  group maestro/streamer/decoders/cci_dec
    ../../../../../middleware/maestro/streamer/decoders/cci_dec/: ccidec.h ccidec.c codec_interface.c codecextractmetadata.c
  group maestro/streamer/devices
    ../../../../../middleware/maestro/streamer/devices/: audio_sink_pcmrtos.h audio_src_pcmrtos.h freertos_pcm.h audio_sink_pcmrtos.c audio_src_pcmrtos.c
  group maestro/streamer/elements
    ../../../../../middleware/maestro/streamer/elements/: audio_sink.h audio_src.h decoder.h decoder_pads.h eap.h encoder.h file_sink.h file_src_freertos.h mem_sink.h mem_src.h netbuf_src.h vit_sink.h audio_sink.c audio_src.c decoder.c decoder_pads.c eap.c file_sink.c file_src_freertos.c mem_sink.c vit_sink.c mem_src.c netbuf_src.c encoder.c
  group maestro/streamer/pipelines
    ../../../../../middleware/maestro/streamer/pipelines/: streamer_audiosrc.h streamer_fs.h streamer_mic2file.h streamer_opusmem2mem.h streamer_pcm_eap_speaker.h streamer_testeapfile2file.h streamer_vit.h streamer_audiosrc.c streamer_fs.c streamer_mic2file.c streamer_opusmem2mem.c streamer_pcm_eap_speaker.c streamer_testeapfile2file.c streamer_vit.c
  group maestro/streamer/encoders/cei
    ../../../../../middleware/maestro/streamer/encoders/cei/: cei.h cei_enctypes.h cei_table.h
  group maestro/streamer/encoders/opus
    ../../../../../middleware/maestro/streamer/encoders/opus/: opusenc_cei.h opusenc_cei.c
  group maestro/streamer/parsers/cci
    ../../../../../middleware/maestro/streamer/parsers/cci/: cci_codec_type_conversion.c
  group maestro/streamer/utils
    ../../../../../middleware/maestro/streamer/utils/: file_utils.c general_utils.c logging.c ringbuffer.c
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/: fsl_shell.c fsl_shell.h fsl_assert.c
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group fatfs/source
    ../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_sd_disk
    ../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group startup
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkbmimxrt1060_flexspi_nor_config.c evkbmimxrt1060_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
