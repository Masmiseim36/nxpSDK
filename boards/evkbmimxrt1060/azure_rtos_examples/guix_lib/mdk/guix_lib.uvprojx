# Keil uVision project guix_lib.uvprojx, settings and files
target guix_lib Debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: guix_lib.out (library)
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: DEBUG, CPU_MIMXRT1062DVL6A, MCUXPRESSO_SDK, TX_INCLUDE_USER_DEFINE_FILE, GX_INCLUDE_USER_DEFINE_FILE
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../../rtos/azure-rtos/threadx/common/inc;../../../../../rtos/azure-rtos/guix/common/inc;../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc;../../../../../rtos/azure-rtos/guix/ports/cortex_m7/ac6/inc
  asm define: DEBUG, DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group doc
    ../: readme.txt
  group azure-rtos/config
    ../: tx_user.h gx_user.h
  group azure-rtos/guix/common/inc
    ../../../../../rtos/azure-rtos/guix/common/inc/: gx_animation.h gx_api.h gx_binres_loader.h gx_button.h gx_canvas.h gx_circular_gauge.h gx_context.h gx_display.h gx_drop_list.h gx_icon.h gx_image_reader.h gx_line_chart.h gx_menu.h gx_multi_line_text_input.h gx_multi_line_text_view.h gx_numeric_pixelmap_prompt.h gx_numeric_prompt.h gx_pixelmap_prompt.h gx_progress_bar.h gx_prompt.h gx_radial_progress_bar.h gx_radial_slider.h gx_rich_text_view.h gx_screen_stack.h gx_scroll_wheel.h gx_scrollbar.h gx_single_line_text_input.h gx_slider.h gx_sprite.h gx_system.h gx_system_rtos_bind.h gx_text_input_cursor.h gx_tree_view.h gx_user_sample.h gx_utility.h gx_widget.h gx_window.h
  group azure-rtos/guix/common
    ../../../../../rtos/azure-rtos/guix/common/: gx_source.c
  group azure-rtos/guix/common/src
    ../../../../../rtos/azure-rtos/guix/common/src/: gx_display_driver_1555xrgb_canvas_blend.c gx_display_driver_1555xrgb_jpeg_draw.c gx_display_driver_1555xrgb_native_color_get.c gx_display_driver_1555xrgb_pixel_blend.c gx_display_driver_1555xrgb_pixelmap_rotate.c gx_display_driver_1555xrgb_png_draw.c gx_display_driver_1555xrgb_setup.c gx_display_driver_16bpp_block_move.c gx_display_driver_16bpp_canvas_copy.c gx_display_driver_16bpp_horizontal_line_draw.c gx_display_driver_16bpp_horizontal_pattern_line_draw.c gx_display_driver_16bpp_mouse_capture.c gx_display_driver_16bpp_mouse_restore.c gx_display_driver_16bpp_pixel_write.c gx_display_driver_16bpp_pixelmap_blend.c gx_display_driver_16bpp_pixelmap_draw.c gx_display_driver_16bpp_pixelmap_rotate.c gx_display_driver_16bpp_rotated_block_move.c gx_display_driver_16bpp_rotated_canvas_copy.c gx_display_driver_16bpp_rotated_horizontal_line_draw.c gx_display_driver_16bpp_rotated_horizontal_pattern_line_draw.c gx_display_driver_16bpp_rotated_pixel_write.c gx_display_driver_16bpp_rotated_pixelmap_blend.c gx_display_driver_16bpp_rotated_pixelmap_draw.c gx_display_driver_16bpp_rotated_pixelmap_rotate.c gx_display_driver_16bpp_rotated_simple_line_draw.c gx_display_driver_16bpp_rotated_vertical_line_draw.c gx_display_driver_16bpp_rotated_vertical_pattern_line_draw.c gx_display_driver_16bpp_row_pitch_get.c gx_display_driver_16bpp_simple_line_draw.c gx_display_driver_16bpp_vertical_line_draw.c gx_display_driver_16bpp_vertical_pattern_line_draw.c gx_display_driver_1bpp_block_move.c gx_display_driver_1bpp_canvas_copy.c gx_display_driver_1bpp_glyph_1bpp_draw.c gx_display_driver_1bpp_horizontal_line_draw.c gx_display_driver_1bpp_horizontal_pattern_line_draw.c gx_display_driver_1bpp_horizontal_pixelmap_line_draw.c gx_display_driver_1bpp_mouse_capture.c gx_display_driver_1bpp_mouse_restore.c gx_display_driver_1bpp_native_color_get.c gx_display_driver_1bpp_pixel_write.c gx_display_driver_1bpp_pixelmap_draw.c gx_display_driver_1bpp_pixelmap_rotate.c gx_display_driver_1bpp_row_pitch_get.c gx_display_driver_1bpp_simple_line_draw.c gx_display_driver_1bpp_vertical_line_draw.c gx_display_driver_1bpp_vertical_pattern_line_draw.c gx_display_driver_24xrgb_canvas_blend.c gx_display_driver_24xrgb_jpeg_draw.c gx_display_driver_24xrgb_mouse_capture.c gx_display_driver_24xrgb_mouse_restore.c gx_display_driver_24xrgb_native_color_get.c gx_display_driver_24xrgb_pixel_blend.c gx_display_driver_24xrgb_pixelmap_blend.c gx_display_driver_24xrgb_png_draw.c gx_display_driver_24xrgb_rotated_canvas_blend.c gx_display_driver_24xrgb_rotated_jpeg_draw.c gx_display_driver_24xrgb_rotated_pixel_blend.c gx_display_driver_24xrgb_rotated_png_draw.c gx_display_driver_24xrgb_rotated_setup.c gx_display_driver_24xrgb_setup.c gx_display_driver_32argb_native_color_get.c gx_display_driver_32argb_pixel_blend.c gx_display_driver_32argb_pixelmap_blend.c gx_display_driver_32argb_pixelmap_draw.c gx_display_driver_32argb_rotated_pixel_blend.c gx_display_driver_32argb_rotated_setup.c gx_display_driver_32argb_setup.c gx_display_driver_32bpp_block_move.c gx_display_driver_32bpp_canvas_copy.c gx_display_driver_32bpp_glyph_1bit_draw.c gx_display_driver_32bpp_horizontal_line_draw.c gx_display_driver_32bpp_horizontal_pattern_line_draw.c gx_display_driver_32bpp_horizontal_pixelmap_line_draw.c gx_display_driver_32bpp_pixel_write.c gx_display_driver_32bpp_pixelmap_draw.c gx_display_driver_32bpp_pixelmap_rotate.c gx_display_driver_32bpp_rotated_block_move.c gx_display_driver_32bpp_rotated_canvas_copy.c gx_display_driver_32bpp_rotated_glyph_1bit_draw.c gx_display_driver_32bpp_rotated_horizontal_line_draw.c gx_display_driver_32bpp_rotated_horizontal_pattern_line_draw.c gx_display_driver_32bpp_rotated_horizontal_pixelmap_line_draw.c gx_display_driver_32bpp_rotated_pixel_write.c gx_display_driver_32bpp_rotated_pixelmap_blend.c gx_display_driver_32bpp_rotated_pixelmap_draw.c gx_display_driver_32bpp_rotated_pixelmap_rotate.c gx_display_driver_32bpp_rotated_simple_line_draw.c gx_display_driver_32bpp_rotated_vertical_line_draw.c gx_display_driver_32bpp_rotated_vertical_pattern_line_draw.c gx_display_driver_32bpp_row_pitch_get.c gx_display_driver_32bpp_simple_line_draw.c gx_display_driver_32bpp_vertical_line_draw.c gx_display_driver_32bpp_vertical_pattern_line_draw.c gx_display_driver_332rgb_native_color_get.c gx_display_driver_332rgb_pixel_blend.c gx_display_driver_332rgb_pixelmap_draw.c gx_display_driver_332rgb_pixelmap_rotate.c gx_display_driver_332rgb_setup.c gx_display_driver_4444argb_canvas_blend.c gx_display_driver_4444argb_horizontal_pixelmap_line_draw.c gx_display_driver_4444argb_native_color_get.c gx_display_driver_4444argb_pixel_blend.c gx_display_driver_4444argb_pixelmap_draw.c gx_display_driver_4444argb_pixelmap_rotate.c gx_display_driver_4444argb_setup.c gx_display_driver_4bpp_block_move.c gx_display_driver_4bpp_canvas_copy.c gx_display_driver_4bpp_glyph_1bit_draw.c gx_display_driver_4bpp_glyph_4bit_draw.c gx_display_driver_4bpp_grayscale_setup.c gx_display_driver_4bpp_horizontal_line_draw.c gx_display_driver_4bpp_horizontal_pattern_line_draw.c gx_display_driver_4bpp_horizontal_pixelmap_line_draw.c gx_display_driver_4bpp_mouse_capture.c gx_display_driver_4bpp_mouse_restore.c gx_display_driver_4bpp_native_color_get.c gx_display_driver_4bpp_pixel_write.c gx_display_driver_4bpp_pixelmap_draw.c gx_display_driver_4bpp_pixelmap_rotate.c gx_display_driver_4bpp_row_pitch_get.c gx_display_driver_4bpp_simple_line_draw.c gx_display_driver_4bpp_vertical_line_draw.c gx_display_driver_4bpp_vertical_pattern_line_draw.c gx_display_driver_565rgb_canvas_blend.c gx_display_driver_565rgb_glyph_1bit_draw.c gx_display_driver_565rgb_horizontal_pixelmap_line_draw.c gx_display_driver_565rgb_jpeg_draw.c gx_display_driver_565rgb_native_color_get.c gx_display_driver_565rgb_pixel_blend.c gx_display_driver_565rgb_png_draw.c gx_display_driver_565rgb_rotated_canvas_blend.c gx_display_driver_565rgb_rotated_glyph_1bit_draw.c gx_display_driver_565rgb_rotated_horizontal_pixelmap_line_draw.c gx_display_driver_565rgb_rotated_jpeg_draw.c gx_display_driver_565rgb_rotated_pixel_blend.c gx_display_driver_565rgb_rotated_png_draw.c gx_display_driver_565rgb_rotated_setup.c gx_display_driver_565rgb_setup.c gx_display_driver_8bit_palette_native_color_get.c gx_display_driver_8bit_palette_rotated_setup.c gx_display_driver_8bit_palette_setup.c gx_display_driver_8bpp_block_move.c gx_display_driver_8bpp_canvas_copy.c gx_display_driver_8bpp_glyph_1bit_draw.c gx_display_driver_8bpp_glyph_3bit_draw.c gx_display_driver_8bpp_glyph_4bit_draw.c gx_display_driver_8bpp_horizontal_line_draw.c gx_display_driver_8bpp_horizontal_pattern_line_draw.c gx_display_driver_8bpp_horizontal_pixelmap_line_draw.c gx_display_driver_8bpp_mouse_capture.c gx_display_driver_8bpp_mouse_restore.c gx_display_driver_8bpp_pixel_write.c gx_display_driver_8bpp_pixelmap_blend.c gx_display_driver_8bpp_pixelmap_draw.c gx_display_driver_8bpp_pixelmap_rotate.c gx_display_driver_8bpp_rotated_block_move.c gx_display_driver_8bpp_rotated_canvas_copy.c gx_display_driver_8bpp_rotated_glyph_1bit_draw.c gx_display_driver_8bpp_rotated_glyph_3bit_draw.c gx_display_driver_8bpp_rotated_glyph_4bit_draw.c gx_display_driver_8bpp_rotated_horizontal_line_draw.c gx_display_driver_8bpp_rotated_horizontal_pattern_line_draw.c gx_display_driver_8bpp_rotated_horizontal_pixelmap_line_draw.c gx_display_driver_8bpp_rotated_pixel_write.c gx_display_driver_8bpp_rotated_pixelmap_draw.c gx_display_driver_8bpp_rotated_pixelmap_rotate.c gx_display_driver_8bpp_rotated_simple_line_draw.c gx_display_driver_8bpp_rotated_vertical_line_draw.c gx_display_driver_8bpp_rotated_vertical_pattern_line_draw.c gx_display_driver_8bpp_row_pitch_get.c gx_display_driver_8bpp_simple_line_draw.c gx_display_driver_8bpp_vertical_line_draw.c gx_display_driver_8bpp_vertical_pattern_line_draw.c gx_display_driver_arc_clipping_get.c gx_display_driver_generic_aliased_arc_draw.c gx_display_driver_generic_aliased_circle_draw.c gx_display_driver_generic_aliased_ellipse_draw.c gx_display_driver_generic_aliased_filled_circle_draw.c gx_display_driver_generic_aliased_fixed_point_line_draw.c gx_display_driver_generic_aliased_line_draw.c gx_display_driver_generic_aliased_wide_arc_draw.c gx_display_driver_generic_aliased_wide_circle_draw.c gx_display_driver_generic_aliased_wide_ellipse_draw.c gx_display_driver_generic_aliased_wide_line_draw.c gx_display_driver_generic_alphamap_draw.c gx_display_driver_generic_arc_draw.c gx_display_driver_generic_arc_fill.c gx_display_driver_generic_circle_draw.c gx_display_driver_generic_circle_fill.c gx_display_driver_generic_drawing_complete.c gx_display_driver_generic_drawing_initiate.c gx_display_driver_generic_ellipse_draw.c gx_display_driver_generic_ellipse_fill.c gx_display_driver_generic_filled_circle_draw.c gx_display_driver_generic_glyph_4bpp_draw.c gx_display_driver_generic_glyph_8bpp_draw.c gx_display_driver_generic_mouse_cursor_define.c gx_display_driver_generic_mouse_draw.c gx_display_driver_generic_mouse_enable.c gx_display_driver_generic_mouse_position_set.c gx_display_driver_generic_pie_fill.c gx_display_driver_generic_polygon_draw.c gx_display_driver_generic_polygon_fill.c gx_display_driver_generic_rotated_alphamap_draw.c gx_display_driver_generic_rotated_arc_fill.c gx_display_driver_generic_rotated_circle_fill.c gx_display_driver_generic_rotated_ellipse_fill.c gx_display_driver_generic_rotated_glyph_4bit_draw.c gx_display_driver_generic_rotated_glyph_8bit_draw.c gx_display_driver_generic_rotated_pie_fill.c gx_display_driver_generic_rotated_polygon_fill.c gx_display_driver_generic_rotated_wide_line_fill.c gx_display_driver_generic_simple_pie_fill.c gx_display_driver_generic_simple_wide_line_draw.c gx_display_driver_generic_wide_arc_draw.c gx_display_driver_generic_wide_circle_draw.c gx_display_driver_generic_wide_ellipse_draw.c gx_display_driver_generic_wide_line_fill.c gx_display_driver_generic_wide_line_points_calculate.c gx_display_driver_horizontal_line_alpha_draw.c gx_display_driver_monochrome_setup.c gx_display_driver_simple_line_alpha_draw.c gx_display_driver_vertical_line_alpha_draw.c gx_system_font_4bpp.c gx_system_font_8bpp.c gx_system_font_mono.c gx_system_initialize.c gx_utility_1555xrgb_pixelmap_resize.c gx_utility_1555xrgb_pixelmap_rotate.c gx_utility_16bpp_pixelmap_resize.c gx_utility_1bpp_pixelmap_resize.c gx_utility_1bpp_pixelmap_rotate.c gx_utility_32argb_pixelmap_resize.c gx_utility_32argb_pixelmap_rotate.c gx_utility_332rgb_pixelmap_rotate.c gx_utility_4444argb_pixelmap_resize.c gx_utility_4444argb_pixelmap_rotate.c gx_utility_4bpp_pixelmap_resize.c gx_utility_4bpp_pixelmap_rotate.c gx_utility_565rgb_pixelmap_rotate.c gx_utility_8bpp_pixelmap_resize.c gx_utility_8bpp_pixelmap_rotate.c gx_utility_alphamap_create.c gx_utility_bidi_arabic_shaping.c gx_utility_bidi_bracket_pair_get.c gx_utility_bidi_character_type_get.c gx_utility_bidi_mirroring_get.c gx_utility_bidi_paragraph_reorder.c gx_utility_bidi_resolved_text_info_delete.c gx_utility_canvas_to_bmp.c gx_utility_circle_point_get.c gx_utility_easing_function_calculate.c gx_utility_gradient_create.c gx_utility_gradient_delete.c gx_utility_ltoa.c gx_utility_math_acos.c gx_utility_math_asin.c gx_utility_math_cos.c gx_utility_math_sin.c gx_utility_math_sqrt.c gx_utility_pixelmap_resize.c gx_utility_pixelmap_rotate.c gx_utility_pixelmap_simple_rotate.c gx_utility_rectangle_center.c gx_utility_rectangle_center_find.c gx_utility_rectangle_combine.c gx_utility_rectangle_compare.c gx_utility_rectangle_define.c gx_utility_rectangle_inside_detect.c gx_utility_rectangle_overlap_detect.c gx_utility_rectangle_point_detect.c gx_utility_rectangle_resize.c gx_utility_rectangle_shift.c gx_utility_string_compare.c gx_utility_string_length_check.c gx_utility_string_to_alphamap.c gx_utility_thai_glyph_shaping.c gx_utility_unicode_to_utf8.c gx_utility_utf8_string_backward_character_length_get.c gx_utility_utf8_string_character_get.c
  group azure-rtos/threadx/common/inc
    ../../../../../rtos/azure-rtos/threadx/common/inc/: tx_api.h tx_block_pool.h tx_byte_pool.h tx_event_flags.h tx_initialize.h tx_mutex.h tx_queue.h tx_semaphore.h tx_thread.h tx_timer.h tx_trace.h tx_user_sample.h
  group azure-rtos/threadx/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc/: tx_port.h
  group azure-rtos/guix/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/guix/ports/cortex_m7/ac6/inc/: gx_port.h
target guix_lib Release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: guix_lib.out (library)
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1062DVL6A, MCUXPRESSO_SDK, TX_INCLUDE_USER_DEFINE_FILE, GX_INCLUDE_USER_DEFINE_FILE
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: NDEBUG, NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
