<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>netx_duo_ping</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
      <member>
        <project>netx_duo_ping</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
      <member>
        <project>netx_duo_ping</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>netx_duo_ping</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_debug</name>
      <member>
        <project>netx_duo_ping</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_release</name>
      <member>
        <project>netx_duo_ping</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>netx_duo_ping</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>netx_duo_ping</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/netx_duo_ping.ewp</path>
  </project>
</workspace>
