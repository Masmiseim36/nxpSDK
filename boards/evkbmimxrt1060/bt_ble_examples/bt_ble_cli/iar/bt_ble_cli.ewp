# IAR project bt_ble_cli.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6B NXP MIMXRT1062xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; FILE=FIL; CPU_MIMXRT1062DVL6B; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; APPL_CONFIG_DISABLE; PXM; HTS; APPL_MENU_OPS; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; SAI_XFER_QUEUE_SIZE=6; SDK_COMPONENT_INTEGRATION=1; gNvStorageIncluded_d=1; gNvTableKeptInRam_d=1; gAppUseNvm_d=1; IPSP_HAVE_6LO_NIFACE; LWIP_IPV6; SUPPORT_HTTP_CLIENT; FSL_OSA_MAIN_FUNC_ENABLE=0; APPL_GAP_CENTRAL; APPL_GAP_PERIPHERAL; HAL_UART_ADAPTER_FIFO=1; HAL_UART_ISR_PRIORITY=configLIBRARY_LOWEST_INTERRUPT_PRIORITY; STORAGE_IDLE_TASK_SYNC_ENABLE=1; NVRAM_WORKAROUND; BT_SNOOP_WRITE_TRUNCATE; OOB_WAKEUP; HAL_AUDIO_DMA_INIT_ENABLE=0; HAL_UART_DMA_ENABLE=1; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; SDK_OS_FREE_RTOS; FSL_OSA_TASK_ENABLE=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; GATT_DB; GATT_CLIENT; CONFIG_BT_SNOOP=1; DEBUG_CONSOLE_SCANF_MAX_LOG_LEN=64; CONFIG_BT_SETTINGS; APPL_LIMIT_LOGS; NXP_CODE; NVM_NO_COMPONNET=1; SDIO_ENABLED=1; CPU_MIMXRT1062DVL6A; CPU_MIMXRT1062DVL6A_cm7; MCUXPRESSO_SDK; MBEDTLS_CONFIG_FILE="mbedtls_config_client.h"; SDK_I2C_BASED_COMPONENT_USED=1; SERIAL_PORT_TYPE_UART=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; LWIP_DISABLE_PBUF_POOL_SIZE_SANITY_CHECKS=1; LWIP_DNS=1; LWIP_NETIF_HOSTNAME=1; LWIP_NETIF_STATUS_CALLBACK=1; LWIP_IGMP=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.IExtraOptions: --diag_suppress Pa167,Pe177,Pe191,Pe546
  ICCARM.PreInclude: ../wifi_config.h
  ICCARM.CCIncludePath2: ..; ../../..; ../appl/reference; ../appl/lc3; ../appl/lc3/sim; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/br/profile_appl; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/client; ../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth/controller; ../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/hps; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/hts; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/ipspn; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/pxr; ../../../../../middleware/wireless/ethermind/bluetooth/export/eOSAL; ../../../../../middleware/wireless/ethermind/bluetooth/export/include; ../../../../../middleware/wireless/ethermind/bluetooth/export/vendor; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/att; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avctp; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avdtp; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/bnep; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/common; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/dbase; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/hci_1.2; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/mcap; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/obex; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/rfcomm; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sdp; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sm; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/smp; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/write_task; ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/aes_cmac; ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/at_parser; ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/btsnoop; ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/object_parser; ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/racp; ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/security; ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/status; ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/storage; ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/xml_parser; ../../../../../middleware/wireless/ethermind/port/pal/mcux/ethal; ../../../../../middleware/wireless/ethermind/port/pal/mcux/sbc; ../../../../../middleware/wireless/ethermind/port/pal/mcux/lc3; ../../../../../middleware/wireless/ethermind/port/osal/src/freertos; ../../../../../middleware/wireless/ethermind/port/pal/mcux; ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/sbc; ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/lc3/export/include; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/br/protocol_appl; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/br/al; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/ga/appl; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/ga/bearer; ../../../../../middleware/wireless/ethermind/bluetooth/private/profiles/ga/eOSAL; ../../../../../middleware/wireless/ethermind/bluetooth/private/profiles/ga/include; ../../../../../middleware/wireless/ethermind/bluetooth/private/profiles/ga/source/profiles/ccp; ../../../../../middleware/wireless/ethermind/bluetooth/private/profiles/ga/source/profiles/mcp; ../../../../../middleware/wireless/ethermind/bluetooth/private/profiles/ga/source/core; ../../../../../middleware/wireless/ethermind/bluetooth/private/profiles/ga/source/core/bap; ../../../../../middleware/wireless/ethermind/bluetooth/private/profiles/ga/source/core/bap/bass; ../../../../../middleware/wireless/ethermind/bluetooth/private/profiles/ga/source/core/csip; ../../../../../middleware/wireless/ethermind/bluetooth/private/profiles/ga/source/core/micp; ../../../../../middleware/wireless/ethermind/bluetooth/private/profiles/ga/source/core/vcp; ../../../../../middleware/wireless/ethermind/examples/ethermind; ../../../../../middleware/wireless/ethermind/port/pal/mcux/toolspec/iar; ../../../../../middleware/wireless/ethermind/port/pal/mcux/lc3/iar; ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/lc3/private/fixed/common; ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/lc3/private/fixed/config; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/protocol_appl; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/config; ../../../../../middleware/wireless/ethermind/bluetooth/export/extension; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/bps; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/cpms; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/cscs; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/gls; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/basic; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/hid; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/hrs; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/tis; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/pts; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/pass; ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/rscs; ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/a2dp; ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/avrcp; ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/bip; ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/bpp; ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/ctn; ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/ftp; ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/map; ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/opp; ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/pan; ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/pbap; ../../../../../components/i2c; ../../../../../components/codec/i2c; ../../../../../components/lists; ../../../../../components/log; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/audio; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062; ../../../../../components/codec/port/wm8960; ../../../../../components/codec/port; ../../../../../components/codec; ../../../../../components/phy/device/phyksz8081; ../../../../../components/codec/wm8960; ../../../xip; ../../../../../devices/MIMXRT1062/xip; ../../../../../middleware/fatfs/source/fsl_usb_disk; ../../../../../middleware/fatfs/source; ../../../../../middleware/lwip/port; ../../../../../middleware/lwip/src; ../../../../../middleware/lwip/src/include; ../../../../../middleware/lwip/contrib/apps/ping; ../../../../../middleware/mbedtls/include; ../../../../../middleware/mbedtls/library; ../../../../../middleware/mbedtls/port/ksdk; ../../../../../middleware/sdmmc/host/usdhc; ../../../../../middleware/sdmmc/sdio; ../../../../../middleware/usb/host; ../../../../../middleware/usb/include; ../../../../../middleware/usb/host/class; ../../../../../middleware/usb/phy; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../devices/MIMXRT1062/utilities/debug_console; ../../../../../components/osa; ../../../../../middleware/wifi_nxp/incl; ../../../../../middleware/wifi_nxp/wifi_bt_firmware; ../../../../../middleware/wifi_nxp/wifidriver; ../../../../../middleware/wifi_nxp/wifidriver/incl; ../../../../../rtos/freertos/freertos-kernel/include; ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F; ../../../../../components/internal_flash; ../../../../../components/gpio; ../../../../../components/nvm; ../../../../../middleware/littlefs; ../../../../../middleware/wireless/framework/Common; ../../../../../middleware/wireless/framework/NVM/Interface; ../../../../../middleware/wireless/framework/NVM/Source; ../../../../../middleware/wireless/framework/FunctionLib; ../../../../../CMSIS/Core/Include; ../../../../../components/phy; ../../../../../middleware/sdmmc/common; ../../../../../middleware/sdmmc/osa; ../../../../../middleware/wifi_nxp/incl/wifidriver; ../../../../../middleware/wifi_nxp/incl/port/os; ../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits; ../../../../../components/wifi_bt_module/Murata/tx_pwr_limits
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../appl/reference
  ILINK.IlinkOutputFile: bt_ble_cli.out
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_a2dp.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_avrcp.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_bip.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_bpp.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_core.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_ctn.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_ftp.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_gatt.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_ga.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_hfp.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_hid.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_map.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_opp.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_pan.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_pbap.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_protocol.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_sap.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_spp.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_util.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_sbc_common.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_sbc_decoder.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_sbc_encoder.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_lc3_common.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_lc3_decoder.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_lc3_encoder.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; FILE=FIL; CPU_MIMXRT1062DVL6B; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; APPL_CONFIG_DISABLE; PXM; HTS; APPL_MENU_OPS; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; SAI_XFER_QUEUE_SIZE=6; SDK_COMPONENT_INTEGRATION=1; gNvStorageIncluded_d=1; gNvTableKeptInRam_d=1; gAppUseNvm_d=1; IPSP_HAVE_6LO_NIFACE; LWIP_IPV6; SUPPORT_HTTP_CLIENT; FSL_OSA_MAIN_FUNC_ENABLE=0; APPL_GAP_CENTRAL; APPL_GAP_PERIPHERAL; HAL_UART_ADAPTER_FIFO=1; HAL_UART_ISR_PRIORITY=configLIBRARY_LOWEST_INTERRUPT_PRIORITY; STORAGE_IDLE_TASK_SYNC_ENABLE=1; NVRAM_WORKAROUND; BT_SNOOP_WRITE_TRUNCATE; OOB_WAKEUP; HAL_AUDIO_DMA_INIT_ENABLE=0; HAL_UART_DMA_ENABLE=1; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; SDK_OS_FREE_RTOS; FSL_OSA_TASK_ENABLE=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; GATT_DB; GATT_CLIENT; CONFIG_BT_SNOOP=1; DEBUG_CONSOLE_SCANF_MAX_LOG_LEN=64; CONFIG_BT_SETTINGS; APPL_LIMIT_LOGS; NXP_CODE; NVM_NO_COMPONNET=1; SDIO_ENABLED=1; CPU_MIMXRT1062DVL6A; CPU_MIMXRT1062DVL6A_cm7; MCUXPRESSO_SDK; MBEDTLS_CONFIG_FILE="mbedtls_config_client.h"; SDK_I2C_BASED_COMPONENT_USED=1; SERIAL_PORT_TYPE_UART=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; LWIP_DISABLE_PBUF_POOL_SIZE_SANITY_CHECKS=1; LWIP_DNS=1; LWIP_NETIF_HOSTNAME=1; LWIP_NETIF_STATUS_CALLBACK=1; LWIP_IGMP=1
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: app_config.h lwipopts.h lwippools.h mbedtls_config_client.h main.c wifi_config.h app.h ffconf.h host_msd_fatfs.c host_msd_fatfs.h usb_host_config.h
    ../appl/reference/: FreeRTOSConfig.h
  group source/appl
    ../: a2dp_pl_ext.c leaudio_pl_ext.c sco_audio_pl_ext.c ringtone.h db_gen.c
  group source/appl/reference
    ../appl/reference/: appl_main.c appl_main.h appl_profile.h appl_protocol.h appl_utils.c appl_utils.h
  group source/appl/reference/br/profile_appl
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/br/profile_appl/: appl_a2dp.c appl_a2dp.h appl_bip.h appl_bip_initiator.c appl_bip_responder.c appl_bpp.h appl_bpp_printer.c appl_bpp_sender.c appl_ctn.h appl_ctn_cce.c appl_ctn_cse.c appl_did.h appl_did_client.c appl_did_server.c appl_ftp.h appl_ftp_client.c appl_ftp_server.c appl_hdp.c appl_hdp.h appl_hfp_ag.c appl_hfp_ag.h appl_hfp_ag_atrsp.h appl_hfp_unit.c appl_hfp_unit.h appl_hid_device.c appl_hid_device.h appl_hid_host.c appl_hid_host.h appl_map.h appl_map_mce.c appl_map_mse.c appl_opp.h appl_opp_client.c appl_opp_server.c appl_pbap_pce.c appl_pbap_pce.h appl_pbap_pse.c appl_pbap_pse.h appl_sap_client.c appl_sap_client.h appl_sap_server.c appl_sap_server.h appl_spp.c appl_spp.h appl_pan.c appl_pan.h
  group source/appl/reference/br/protocol_appl
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/br/protocol_appl/: appl_avctp.c appl_avctp.h appl_avdtp.c appl_avdtp.h appl_bnep.c appl_bnep.h appl_dbase.c appl_dbase_dyn.c appl_hci.c appl_hci.h appl_hci_api.c appl_l2cap.c appl_l2cap.h appl_mcap.c appl_mcap.h appl_obex_client.c appl_obex_client.h appl_obex_common.h appl_obex_server.c appl_obex_server.h appl_rfcomm.c appl_rfcomm.h appl_sdp.c appl_sdp.h appl_sm.c appl_sm.h
  group source/appl/reference/br/al
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/br/al/: appl_avrcp.c appl_avrcp.h appl_avrcp_ct.c appl_avrcp_ct.h appl_avrcp_tg.c appl_avrcp_tg.h appl_avrcp_tg_virtual_media_player.c appl_avrcp_tg_virtual_media_player.h avrcp_al_api.c avrcp_al_internal.c avrcp_al_internal.h BT_avrcp_al_api.h avrcp_al_extern.h
  group source/appl/reference/le
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/: appl_le.c appl_le.h
  group source/appl/reference/le/profile_appl
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/: appl_gatt_client.c appl_gatt_client.h appl_gatt_server.c appl_gatt_server.h gatt.c gatt.h appl_beacon.c appl_beacon.h
  group source/appl/reference/le/profile_appl/client
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/client/: appl_bac.c appl_bpc.c appl_cpmc.c appl_cscc.c appl_dic.c appl_fml.c appl_glc.c appl_hidh.c appl_hrc.c appl_htc.c appl_pasp.c appl_pxm.c appl_rscc.c appl_hpc.c appl_tic.c appl_ipspr.c
  group source/appl/reference/le/profile_appl/server
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/: appl_service.c appl_service.h appl_service_mops.c appl_service_mops.h gatt_db.h
  group source/appl/reference/le/profile_appl/server/hps
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/hps/: appl_hps.c appl_hps.h appl_hps_gap_config_params.c appl_hps_mops.c appl_hps_mops.h gatt_db_dyn_hps.c gatt_db_hps.h gatt_db_hps_handler.c gatt_db_stat_hps.c
  group source/appl/reference/le/profile_appl/server/hts
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/hts/: appl_hts.c appl_hts.h appl_hts_gap_config_params.c appl_hts_mops.c appl_hts_mops.h gatt_db_dyn_hts.c gatt_db_hts.h gatt_db_hts_handler.c gatt_db_stat_hts.c
  group source/appl/reference/le/profile_appl/server/ipspn
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/ipspn/: appl_ipspn.c appl_ipspn.h appl_ipspn_gap_config_params.c appl_ipspn_mops.c appl_ipspn_mops.h gatt_db_dyn_ipspn.c gatt_db_ipspn.h gatt_db_ipspn_handler.c gatt_db_stat_ipspn.c
  group source/appl/reference/le/profile_appl/server/pxr
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/pxr/: appl_pxr.c appl_pxr.h appl_pxr_gap_config_params.c appl_pxr_mops.c appl_pxr_mops.h gatt_db_dyn_pxr.c gatt_db_pxr.h gatt_db_pxr_handler.c gatt_db_stat_pxr.c
  group source/appl/reference/le/profile_appl/server/bps
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/bps/: appl_bps.c appl_bps.h appl_bps_gap_config_params.c appl_bps_mops.c appl_bps_mops.h gatt_db_bps.h gatt_db_bps_handler.c gatt_db_dyn_bps.c gatt_db_stat_bps.c
  group source/appl/reference/le/profile_appl/server/cpms
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/cpms/: appl_cpms.c appl_cpms.h appl_cpms_gap_config_params.c appl_cpms_mops.c appl_cpms_mops.h gatt_db_cpms.h gatt_db_cpms_handler.c gatt_db_dyn_cpms.c gatt_db_stat_cpms.c
  group source/appl/reference/le/profile_appl/server/cscs
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/cscs/: appl_cscs.c appl_cscs.h appl_cscs_gap_config_params.c appl_cscs_mops.c appl_cscs_mops.h gatt_db_cscs.h gatt_db_cscs_handler.c gatt_db_dyn_cscs.c gatt_db_stat_cscs.c
  group source/appl/reference/le/profile_appl/server/gls
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/gls/: appl_gls.c appl_gls.h appl_gls_gap_config_params.c appl_gls_mops.c appl_gls_mops.h gatt_db_dyn_gls.c gatt_db_gls.h gatt_db_gls_handler.c gatt_db_stat_gls.c
  group source/appl/reference/le/profile_appl/server/basic
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/basic/: appl_basic.c appl_basic.h appl_basic_gap_config_params.c appl_basic_mops.c appl_basic_mops.h gatt_db_basic.h gatt_db_basic_handler.c gatt_db_dyn_basic.c gatt_db_stat_basic.c
  group source/appl/reference/le/profile_appl/server/hid
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/hid/: appl_hid.c appl_hid.h appl_hid_gap_config_params.c appl_hid_mops.c appl_hid_mops.h gatt_db_dyn_hid.c gatt_db_hid.h gatt_db_hid_handler.c gatt_db_stat_hid.c
  group source/appl/reference/le/profile_appl/server/hrs
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/hrs/: appl_hrs.c appl_hrs.h appl_hrs_gap_config_params.c appl_hrs_mops.c appl_hrs_mops.h gatt_db_dyn_hrs.c gatt_db_hrs.h gatt_db_hrs_handler.c gatt_db_stat_hrs.c
  group source/appl/reference/le/profile_appl/server/tis
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/tis/: appl_tis.c appl_tis.h appl_tis_gap_config_params.c appl_tis_mops.c appl_tis_mops.h gatt_db_dyn_tis.c gatt_db_stat_tis.c gatt_db_tis.h gatt_db_tis_handler.c
  group source/appl/reference/le/profile_appl/server/pts
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/pts/: appl_pts.c appl_pts.h appl_pts_gap_config_params.c appl_pts_mops.c appl_pts_mops.h gatt_db_dyn_pts.c gatt_db_pts.h gatt_db_pts_handler.c gatt_db_stat_pts.c
  group source/appl/reference/le/profile_appl/server/pass
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/pass/: appl_pass.c appl_pass.h appl_pass_gap_config_params.c appl_pass_mops.c appl_pass_mops.h gatt_db_dyn_pass.c gatt_db_pass.h gatt_db_pass_handler.c gatt_db_stat_pass.c
  group source/appl/reference/le/profile_appl/server/rscs
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/profile_appl/server/rscs/: appl_rscs.c appl_rscs.h appl_rscs_gap_config_params.c appl_rscs_mops.c appl_rscs_mops.h gatt_db_dyn_rscs.c gatt_db_rscs.h gatt_db_rscs_handler.c gatt_db_stat_rscs.c
  group source/appl/reference/le/protocol_appl
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/le/protocol_appl/: appl_att_client.c appl_att_client.h appl_gap_le.c appl_gap_le.h appl_hci_le.c appl_hci_le.h appl_hci_le_api.c appl_l2cap_le.c appl_l2cap_le.h appl_l2cap_ecbfc.c appl_l2cap_ecbfc.h appl_smp.c appl_smp.h
  group source/appl/reference/ga/appl
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/ga/appl/: appl_aics.c appl_aics.h appl_csip.c appl_csip.h appl_ccp_ce.c appl_ccp_ce.h appl_ccp_se.c appl_ccp_se.h appl_ga.c appl_ga.h appl_ga_utils.c appl_ga_utils.h appl_ccp.h appl_micp.c appl_micp.h appl_vcp.c appl_vcp.h appl_mcp_ce.c appl_mcp_ce.h appl_mcp_se.c appl_mcp_se.h otp_se_utils.h appl_hap.c appl_hap.h appl_tmap.c appl_tmap.h appl_ga_bc.c appl_ga_bc.h appl_ga_bc_ba.c appl_ga_bc_ba.h appl_ga_bc_sd.c appl_ga_bc_sd.h appl_ga_common.h appl_ga_features.h appl_ga_legacy.c appl_ga_legacy.h appl_ga_uc.c appl_ga_uc.h appl_ga_ucc.c appl_ga_ucc.h appl_ga_ucs.c appl_ga_ucs.h appl_ga_utils_audio_snk.c appl_ga_utils_audio_snk.h appl_ga_utils_audio_src.c appl_ga_utils_audio_src.h appl_ga_utils_hci.c appl_ga_utils_hci.h appl_ccp_utils.c appl_ccp_utils.h appl_mcp_utils.c appl_mcp_utils.h
    ../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth/: audio_pl.c audio_pl.h
  group source/appl/reference/ga/bearer
    ../../../../../middleware/wireless/ethermind/bluetooth/export/appl/reference/ga/bearer/: ga_brr_api.c ga_brr_appl.h ga_brr_extern.h ga_brr_init.c ga_brr_internal.c ga_brr_internal.h ga_brr_pl.c ga_brr_pl.h ga_brr_utils.c ga_brr_utils.h ga_gatt_db.c ga_gatt_db.h ga_gatt_db_dyn.c
  group source/appl/lc3
    ../appl/lc3/: lc3_decoder_input_data.h lc3_encoder_input_44100.h lc3_encoder_input_48000.h lc3_encoder_input_data.h lc3_fops.h lc3_fops.c lc3_test.c
  group source/appl/lc3/sim
    ../appl/lc3/sim/: lc3_EM_debug.h lc3_EM_fops.h lc3_EM_os.h lc3_EM_platform.h
  group board
    ../: sdmmc_config.c sdmmc_config.h wifi_bt_config.c wifi_bt_config.h pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.txt
  group ethermind/port/pal/mcux
    ../../../../../middleware/wireless/ethermind/port/pal/mcux/: EM_platform.c EM_platform.h EM_platform.h
  group ethermind/port/pal/mcux/bluetooth
    ../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth/: hci_uart.c hci_uart.h hci_uart_internal.h hps_pl.c hps_pl.h https_pl.c https_pl.h ipsp_pl.c ipsp_pl.h ipspr_ping.c niface.c niface.h pan_pl.c pan_pl.h BT_assert.h BT_config.h BT_debug.h BT_debug_api.h BT_fops.h BT_os.h BT_status_pl.c BT_storage_pl.c BT_storage_pl.h BT_timer.h btsnoop_pl.c btsnoop_pl.h ctn_pl.c ctn_pl.h ftp_pl.c ftp_pl.h ht_read_task_pl.c map_pl.c map_pl.h obex_pl.c obex_pl.h pbap_pl.c pbap_pl.h write_task_extern_pl.h write_task_pl.c write_task_pl.h littlefs_pl.c littlefs_pl.h fw_loader_uart.c fw_loader_types.h hfp_ag_pl.c hfp_ag_pl.h nwsim.c nwsim.h sco_audio_pl.c sco_audio_pl.h a2dp_pl.c a2dp_pl.h a2dp_pl_media_16KHz.h a2dp_pl_media_48KHz.h vcom_pl.c vcom_pl.h
  group ethermind/port/pal/mcux/bluetooth/controller
    ../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth/controller/: controller.h controller_wifi_nxp.c controller_hci_uart.h controller_features.h controller_features.c
  group ethermind/port/pal/mcux/sbc
    ../../../../../middleware/wireless/ethermind/port/pal/mcux/sbc/: sbc_os.h
  group ethermind/port/pal/mcux/lc3
    ../../../../../middleware/wireless/ethermind/port/pal/mcux/lc3/: LC3_os.h LC3_os.h
  group ethermind/port/pal/mcux/lc3/iar
    ../../../../../middleware/wireless/ethermind/port/pal/mcux/lc3/iar/: lc3_common_internal.h
  group ethermind/port/pal/mcux/ethal
    ../../../../../middleware/wireless/ethermind/port/pal/mcux/ethal/: ethal_assert.h ethal_config.c ethal_config.h ethal_debug.c ethal_debug.h ethal_debug_api.h ethal_debug_internal.h ethal_fops.c ethal_fops.h ethal_os.c ethal_os.h ethal_serial.c ethal_serial.h ethal_timer.c ethal_timer.h ethal_timer_internal.h ethal_assert.h ethal_config.h ethal_debug.h ethal_debug_api.h ethal_debug_internal.h ethal_fops.h ethal_os.h ethal_serial.h ethal_timer.h ethal_timer_internal.h
  group ethermind/port/osal/src/freertos
    ../../../../../middleware/wireless/ethermind/port/osal/src/freertos/: EM_assert.h EM_config.c EM_config.h EM_debug.c EM_debug.h EM_debug_api.h EM_debug_internal.h EM_fops.c EM_fops.h EM_os.c EM_os.h EM_serial.c EM_serial.h EM_timer.c EM_timer.h EM_timer_internal.h
  group ethermind/bluetooth/export/eOSAL
    ../../../../../middleware/wireless/ethermind/bluetooth/export/eOSAL/: eBT_assert.h eBT_config.h eBT_debug_api.h eBT_fops.h eBT_os.h eBT_serial.h eBT_timer.h
  group ethermind/bluetooth/export/vendor
    ../../../../../middleware/wireless/ethermind/bluetooth/export/vendor/: vendor_specific_commands.h vendor_specific_init.c vendor_specific_init.h
  group ethermind/bluetooth/export/include
    ../../../../../middleware/wireless/ethermind/bluetooth/export/include/: BT_a2dp_api.h BT_api.h BT_assigned_numbers.h BT_at_parser_api.h BT_att_api.h BT_avctp_api.h BT_avdtp_api.h BT_avrcp_api.h BT_avrcp_ca_api.h BT_bip_api.h BT_bnep_api.h BT_bottom_half.h BT_bpp_api.h BT_common.h BT_ctn_api.h BT_dbase_api.h BT_device_queue.h BT_error.h BT_ftp_api.h BT_gap_api.h BT_gatt_db_api.h BT_hci_api.h BT_hdp_api.h BT_hfp_ag_api.h BT_hfp_unit_api.h BT_hid_device_api.h BT_hid_host_api.h BT_irobex_api.h BT_jpl_api.h BT_map_api.h BT_mcap_api.h BT_obex_api.h BT_opp_api.h BT_pan_api.h BT_pbap_api.h BT_racp.h BT_rfcomm_api.h BT_sap_api.h BT_sdp_api.h BT_security.h BT_sm_api.h BT_smp_api.h BT_snoop.h BT_spp_api.h BT_status.h BT_storage.h BT_version.h fsm_defines.h fsm_engine.h gatt_defines.h hci_transport.h l2cap.h write_task.h
  group ethermind/bluetooth/export/extension
    ../../../../../middleware/wireless/ethermind/bluetooth/export/extension/: aes_cmac_pl.c aes_cmac_pl.h BT_common_pl.c BT_common_pl.h device_queue_pl.c device_queue_pl.h sm_pl.c sm_pl.h sm_ssp_pl.c sm_ssp_pl.h smp_pl.c smp_pl.h gatt_db_pl.c gatt_db_pl.h
  group ethermind/bluetooth/private/protocols/att
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/att/: att.h
  group ethermind/bluetooth/private/protocols/avctp
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avctp/: avctp.h
  group ethermind/bluetooth/private/protocols/avdtp
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avdtp/: avdtp.h
  group ethermind/bluetooth/private/protocols/bnep
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/bnep/: bnep.h
  group ethermind/bluetooth/private/protocols/dbase
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/dbase/: database.h
  group ethermind/bluetooth/private/protocols/hci_1.2
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/hci_1.2/: hci_h.h
  group ethermind/bluetooth/private/protocols/mcap
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/mcap/: mcap.h
  group ethermind/bluetooth/private/protocols/obex
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/obex/: obex.h
  group ethermind/bluetooth/private/protocols/rfcomm
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/rfcomm/: rfcomm.h
  group ethermind/bluetooth/private/protocols/sdp
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sdp/: sdp.h
  group ethermind/bluetooth/private/protocols/sm
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sm/: sm.h sm_extern.h sm_internal.h
  group ethermind/bluetooth/private/protocols/smp
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/smp/: smp.h smp_extern.h smp_fsm.h smp_fsm_engine.h smp_internal.h
  group ethermind/bluetooth/private/utils/at_parser
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/at_parser/: at_parser_hsp_hfp.h
  group ethermind/bluetooth/private/utils/storage
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/storage/: storage.h
  group ethermind/bluetooth/private/utils/xml_parser
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/xml_parser/: xml_common_defines.h xml_encoder.h xml_parser.h
  group ethermind/bluetooth/private/utils/aes_cmac
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/aes_cmac/: aes_cmac.h
  group ethermind/bluetooth/private/utils/object_parser
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/object_parser/: object_parser_api.h tokenizer.h
  group ethermind/bluetooth/private/utils/racp
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/racp/: racp.h
  group ethermind/bluetooth/private/utils/sbc
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/sbc/: sbc_api.h
  group ethermind/bluetooth/private/utils/lc3
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/lc3/export/include/: LC3_api.h
  group ethermind/bluetooth/private/utils/lc3/export/include
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/lc3/export/include/: LC3_api.h
  group ethermind/bluetooth/private/utils/lc3/private/fixed/common
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/lc3/private/fixed/common/: lc3_defines.h lc3_extern.h lc3_internal.h
  group ethermind/bluetooth/private/utils/lc3/private/fixed/config
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/lc3/private/fixed/config/: LC3_features.h LC3_limits.h
  group ethermind/bluetooth/private/profiles/ga/eOSAL
    ../../../../../middleware/wireless/ethermind/bluetooth/private/profiles/ga/eOSAL/: GA_os.h GA_timer.h GA_debug.h
  group ethermind/bluetooth/private/profiles/ga/include
    ../../../../../middleware/wireless/ethermind/bluetooth/private/profiles/ga/include/: GA_hap_api.h GA_tmap_api.h GA_api.h GA_assigned_numbers.h GA_audio_config.h GA_bearer_api.h GA_ccp_ce_api.h GA_ccp_se_api.h GA_common.h GA_error.h GA_features.h GA_limits.h GA_mcp_ce_api.h GA_mcp_se_api.h GA_property_config.h GA_bass_api.h GA_bass_db.h GA_pbp_api.h
    ../../../../../middleware/wireless/ethermind/bluetooth/private/profiles/ga/source/core/bap/: bap.h
    ../../../../../middleware/wireless/ethermind/bluetooth/private/profiles/ga/source/core/bap/bass/: bass_extern.h bass_internal.h
    ../../../../../middleware/wireless/ethermind/bluetooth/private/profiles/ga/source/core/csip/: csip.h csip_extern.h csip_internal.h
    ../../../../../middleware/wireless/ethermind/bluetooth/private/profiles/ga/source/core/micp/: micp.h micp_extern.h micp_internal.h
    ../../../../../middleware/wireless/ethermind/bluetooth/private/profiles/ga/source/core/vcp/: vcp.h vcp_extern.h vcp_internal.h
    ../../../../../middleware/wireless/ethermind/bluetooth/private/profiles/ga/source/core/: cap.h cap_extern.h cap_internal.h
    ../../../../../middleware/wireless/ethermind/bluetooth/private/profiles/ga/source/profiles/ccp/: ccp_extern.h ccp_internal.h
    ../../../../../middleware/wireless/ethermind/bluetooth/private/profiles/ga/source/profiles/mcp/: mcp_extern.h mcp_internal.h
    ../../../../../middleware/wireless/ethermind/bluetooth/private/profiles/ga/source/core/brr/: brr_internal.h
    ../../../../../middleware/wireless/ethermind/bluetooth/private/profiles/ga/source/profiles/hap/: hap_extern.h hap_internal.h
    ../../../../../middleware/wireless/ethermind/bluetooth/private/profiles/ga/source/profiles/tmap/: tmap_extern.h tmap_internal.h
  group ethermind/bluetooth/private/lib/config
    ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/config/: BT_features.h BT_limits.h db_gen.h
  group ethermind/bluetooth/tools/resources/a2dp
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/a2dp/: SineWaveMinus48.wav a2dp_source.conf sample.wav
  group ethermind/bluetooth/tools/resources/avrcp
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/avrcp/: Image_200_200.jpg Image_640_480.gif Image_640_480.jpg Image_75_75.jpg avrcp_cap_company_id_list.dat avrcp_cap_event_id_list.dat avrcp_folder_depth_1_items_list.dat avrcp_media_element_attr_info.dat avrcp_media_element_attr_info_large.dat avrcp_media_element_attr_info_new_track.dat avrcp_media_element_list_file.dat avrcp_media_player_list_info.dat avrcp_new_media_element_file.dat avrcp_player_appl_attr_info.dat avrcp_player_cur_media_play_status.dat avrcp_root_folder_items_list.dat company_id_list_1.dat event_id_list_1.dat folder_items_list.dat media_element_list_file.dat media_player_list_file.dat new_folder_item.dat new_song_info.dat player_attr_file_1.dat player_status_file.dat player_vfs.dat song_info_1.dat song_info_1_for_fragmentation_handling.dat
  group ethermind/bluetooth/tools/resources/bip
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/bip/: BIP_1_160_120.jpg BIP_1_160_120_jpg_desc.xml BIP_1_160_120_thumbnail.jpg BIP_1_640_480.jpg BIP_1_640_480_jpg_desc.xml BIP_1_640_480_thumbnail.jpg bip_attachment.txt image_list.xml image_properties.xml images_capabilities.xml monitoring_image.jpg print_job.txt sample.jpg sample1.png sample2.jpg sample3.jpg sample_thumbnail.jpg
  group ethermind/bluetooth/tools/resources/bpp
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/bpp/: ImageByReference.html OF-BV-01-I-A.html OF-BV-01-I-B.html OF-BV-01-I-C.html OF-BV-02-I-A.html OF-BV-02-I-B.html OF-BV-02-I-C.html OF-BV-02-I-D.html OF-BV-02-I-E.html OF-BV-02-I-F.html OF-BV-02-I-G.html OF-BV-05-I-A.html OF-BV-05-I-B.html OF-BV-05-I-C.html OF-BV-05-I-D.html OF-BV-05-I-E.html OF-BV-05-I-F.html OF-BV-05-I-G.html OF-BV-05-I-H.html Simple_text.txt bigpic.jpg bpp_cancel_job_response.txt bpp_create_job_response.txt bpp_create_precise_job_response.txt bpp_get_event_response.txt bpp_get_job_attrs_response.txt bpp_get_margins_response.txt bpp_get_printer_attrs_response.txt bpp_get_rui_response.txt bpp_send_ref_list.txt bpp_send_ref_request.txt bpp_send_ref_simple_req.txt bpp_simple_ref_push_soap_msg.txt cancel_job_request.txt cancel_job_response.txt create_job_request.txt create_job_response.txt create_precise_job_request.txt create_precise_job_response.txt feynman.jpg get_event_request.txt get_event_response.txt get_event_rsp_job_completed.txt get_event_rsp_job_stopped.txt get_job_attribs_request.txt get_job_attribs_response.txt get_margins_request.txt get_margins_response.txt get_prt_attribs_request.txt get_prt_attribs_response.txt kshrc.txt precise_job_request.txt sample_ref_push_file.xml send_doc_request.txt single_page_xhtml.html vCal_multiple_object.vcs vCal_single_object.vcs vCard_multiple.vcf vCard_single.vcf vmsg.vmg
  group ethermind/bluetooth/tools/resources/bpp/RUN_OF-BV-01-I-C_FROM_HERE
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/bpp/RUN_OF-BV-01-I-C_FROM_HERE/: OF-BV-01-I-C.html
  group ethermind/bluetooth/tools/resources/ctn
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/ctn/: CTN-account-info.ics CTN-event.ics CTN-listing_large.xml new_calendar.ics push_calendar.ics push_notes.ics push_task.ics
  group ethermind/bluetooth/tools/resources/ctn/root/telecom/CTN/calendar
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/ctn/root/telecom/CTN/calendar/: 10000000000000000000000000000001.ics 10000000000000000000000000000002.ics 10000000000000000000000000000003.ics 10000000000000000000000000000004.ics 10000000000000000000000000000005.ics 10000000000000000000000000000006.ics CTN-listing.xml
  group ethermind/bluetooth/tools/resources/ctn/root/telecom/CTN/notes
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/ctn/root/telecom/CTN/notes/: 20000000000000000000000000000001.ics 20000000000000000000000000000002.ics CTN-listing.xml
  group ethermind/bluetooth/tools/resources/ctn/root/telecom/CTN/tasks
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/ctn/root/telecom/CTN/tasks/: 30000000000000000000000000000001.ics 30000000000000000000000000000002.ics 30000000000000000000000000000003.ics CTN-listing.xml
  group ethermind/bluetooth/tools/resources/ftp
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/ftp/: food.jpeg sachin.jpeg sample.bmp
  group ethermind/bluetooth/tools/resources/map
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/map/: event_email.xml event_im.xml event_mms.xml event_sms_cdma.xml event_sms_gsm.xml map_event_report_v11.xml map_event_report_v12.xml map_mse_conversation_list.txt map_mse_message_listing_v11.txt map_mse_participant_data.xml message_email.msg message_email.vmg message_im.vmg message_mms.msg message_mms.vmg message_sms_cdma.msg message_sms_cdma.vmg message_sms_gsm.msg message_sms_gsm.vmg
  group ethermind/bluetooth/tools/resources/opp
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/opp/: bmp2MB.bmp mybmp.bmp mycal.vcs mycard.vcf mymsg.vmg mynote.vnt vCal-1.vcs vCal-2.vcs vCal-multiple.vcs vCard-1.vcf vCard-2.vcf vCard-multiple.vcf vMsg-1.vmg vMsg-2.vmg vMsg-multiple.vmg vNote-1.vnt vNote-2.vnt vNote-multiple.vnt
  group ethermind/bluetooth/tools/resources/pan
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/pan/: arp_gratuitous_reply.dat arp_request.dat arp_response.dat dhcp_ack.dat dhcp_discover.dat dhcp_offer.dat dhcp_request.dat dns_query.dat dns_response.dat eth_payload_60_0x34d.dat eth_payload_60_0x44a.dat eth_payload_60_0x5a0.dat eth_payload_ipv4ping.dat http_request.dat http_request_ipv6.dat http_response.dat http_response_ipv6.dat llmnr_query.dat llmnr_query_ipv6.dat llmnr_response.dat ndns_request.dat ping_reply.dat ping_reply_ipv6.dat ping_request.dat ping_request_ipv6.dat wap_request.dat wap_response.dat
  group ethermind/bluetooth/tools/resources/pbap/phonebook
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/pbap/phonebook/: pb_0.vcf pb_1.vcf
  group ethermind/bluetooth/tools/resources/pbap/phonebook/root/SIM1/telecom/cch
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/pbap/phonebook/root/SIM1/telecom/cch/: 1.vcf 2.vcf 3.vcf 4.vcf 5.vcf 6.vcf 7.vcf
  group ethermind/bluetooth/tools/resources/pbap/phonebook/root/SIM1/telecom/fav
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/pbap/phonebook/root/SIM1/telecom/fav/: 1.vcf 2.vcf 3.vcf
  group ethermind/bluetooth/tools/resources/pbap/phonebook/root/SIM1/telecom/mch
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/pbap/phonebook/root/SIM1/telecom/mch/: 1.vcf 2.vcf 3.vcf 4.vcf
  group ethermind/bluetooth/tools/resources/pbap/phonebook/root/SIM1/telecom/och
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/pbap/phonebook/root/SIM1/telecom/och/: 1.vcf 2.vcf 3.vcf 4.vcf 5.vcf
  group ethermind/bluetooth/tools/resources/pbap/phonebook/root/SIM1/telecom/pb
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/pbap/phonebook/root/SIM1/telecom/pb/: 0.vcf 1.vcf 10.vcf 11.vcf 12.vcf 13.vcf 14.vcf 15.vcf 16.vcf 17.vcf 2.vcf 3.vcf 4.vcf 5.vcf 6.vcf 7.vcf 8.vcf 9.vcf
  group ethermind/bluetooth/tools/resources/pbap/phonebook/root/SIM1/telecom/spd
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/pbap/phonebook/root/SIM1/telecom/spd/: 1.vcf 2.vcf 3.vcf
  group ethermind/bluetooth/tools/resources/pbap/phonebook/root/telecom/cch
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/pbap/phonebook/root/telecom/cch/: 1.vcf 16.vcf 17.vcf 2.vcf 3.vcf 4.vcf 5.vcf 6.vcf 7.vcf
  group ethermind/bluetooth/tools/resources/pbap/phonebook/root/telecom/fav
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/pbap/phonebook/root/telecom/fav/: 1.vcf 2.vcf 3.vcf
  group ethermind/bluetooth/tools/resources/pbap/phonebook/root/telecom/ich
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/pbap/phonebook/root/telecom/ich/: 1.vcf 2.vcf 3.vcf 4.vcf 5.vcf 6.vcf
  group ethermind/bluetooth/tools/resources/pbap/phonebook/root/telecom/mch
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/pbap/phonebook/root/telecom/mch/: 1.vcf 2.vcf 3.vcf 4.vcf
  group ethermind/bluetooth/tools/resources/pbap/phonebook/root/telecom/och
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/pbap/phonebook/root/telecom/och/: 1.vcf 2.vcf 3.vcf 4.vcf 5.vcf
  group ethermind/bluetooth/tools/resources/pbap/phonebook/root/telecom/pb
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/pbap/phonebook/root/telecom/pb/: 0.vcf 1.vcf 10.vcf 11.vcf 12.vcf 13.vcf 14.vcf 15.vcf 16.vcf 17.vcf 2.vcf 3.vcf 4.vcf 5.vcf 6.vcf 7.vcf 8.vcf 9.vcf
  group ethermind/bluetooth/tools/resources/pbap/phonebook/root/telecom/spd
    ../../../../../middleware/wireless/ethermind/bluetooth/tools/resources/pbap/phonebook/root/telecom/spd/: 1.vcf 2.vcf 3.vcf
  group component/i2c
    ../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/log
    ../../../../../components/log/: fsl_component_log.h fsl_component_log_config.h fsl_component_log.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/audio
    ../../../../../components/audio/: fsl_adapter_audio.h fsl_adapter_sai.c
  group component/phy
    ../../../../../components/phy/device/phyksz8081/: fsl_phyksz8081.h fsl_phyksz8081.c
    ../../../../../components/phy/: fsl_phy.h
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h fsl_os_abstraction_config.h
  group component/internal_flash
    ../../../../../components/internal_flash/: fsl_adapter_flash.h
  group component/internal_flash/evkbmimxrt1060
    ../../../../../components/internal_flash/evkbmimxrt1060/: fsl_adapter_flexspi_nor_flash.c
  group component/gpio
    ../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group component/nvm
    ../../../../../components/nvm/: nvm_adapter.h nvm_adapter.c
  group component/wifi_bt_module/AzureWave/tx_pwr_limits
    ../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits/: wlan_txpwrlimit_cfg_WW.h wlan_txpwrlimit_cfg_WW_rw610.h
  group component/wifi_bt_module/Murata/tx_pwr_limits
    ../../../../../components/wifi_bt_module/Murata/tx_pwr_limits/: wlan_txpwrlimit_cfg_murata_1XK_CA.h wlan_txpwrlimit_cfg_murata_1XK_EU.h wlan_txpwrlimit_cfg_murata_1XK_JP.h wlan_txpwrlimit_cfg_murata_1XK_US.h wlan_txpwrlimit_cfg_murata_1XK_WW.h wlan_txpwrlimit_cfg_murata_1ZM_CA.h wlan_txpwrlimit_cfg_murata_1ZM_EU.h wlan_txpwrlimit_cfg_murata_1ZM_JP.h wlan_txpwrlimit_cfg_murata_1ZM_US.h wlan_txpwrlimit_cfg_murata_1ZM_WW.h wlan_txpwrlimit_cfg_murata_2DS_CA.h wlan_txpwrlimit_cfg_murata_2DS_EU.h wlan_txpwrlimit_cfg_murata_2DS_JP.h wlan_txpwrlimit_cfg_murata_2DS_US.h wlan_txpwrlimit_cfg_murata_2DS_WW.h
  group codec
    ../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
    ../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../components/codec/wm8960/: fsl_wm8960.h fsl_wm8960.c
  group codec/port
    ../../../../../components/codec/port/: fsl_codec_adapter.h
  group codec/port/wm8960
    ../../../../../components/codec/port/wm8960/: fsl_codec_wm8960_adapter.c fsl_codec_wm8960_adapter.h
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_cache.c fsl_cache.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_dcp.c fsl_dcp.h fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_gpio.h fsl_gpio.c fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart_edma.h fsl_lpuart_edma.c fsl_sai.h fsl_sai.c fsl_sai_edma.h fsl_sai_edma.c fsl_trng.c fsl_trng.h fsl_enet.h fsl_enet.c fsl_flexspi.c fsl_flexspi.h fsl_usdhc.c fsl_usdhc.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group startup
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group xip
    ../../../xip/: evkbmimxrt1060_flexspi_nor_config.c evkbmimxrt1060_flexspi_nor_config.h
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
  group fatfs/source
    ../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_usb_disk
    ../../../../../middleware/fatfs/source/fsl_usb_disk/: fsl_usb_disk.h fsl_usb_disk_freertos.c
  group lwip/port
    ../../../../../middleware/lwip/port/: enet_ethernetif.c ethernetif.c ethernetif.h ethernetif_mmac.c ethernetif_mmac.h ethernetif_priv.h enet_sanitychecks.h enet_ethernetif_kinetis.c sys_arch.c
  group lwip/port/arch
    ../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src/api
    ../../../../../middleware/lwip/src/api/: sockets.c netifapi.c netdb.c netbuf.c tcpip.c api_msg.c err.c if_api.c api_lib.c
  group lwip/src/core
    ../../../../../middleware/lwip/src/core/: memp.c def.c ip.c pbuf.c altcp.c tcp_out.c raw.c altcp_tcp.c sys.c init.c inet_chksum.c timeouts.c tcp_in.c netif.c mem.c udp.c tcp.c stats.c dns.c altcp_alloc.c
  group lwip/src/core/ipv6
    ../../../../../middleware/lwip/src/core/ipv6/: ethip6.c dhcp6.c ip6_addr.c nd6.c mld6.c icmp6.c ip6_frag.c ip6.c inet6.c
  group lwip/src/core/ipv4
    ../../../../../middleware/lwip/src/core/ipv4/: dhcp.c ip4.c autoip.c icmp.c acd.c etharp.c ip4_addr.c igmp.c ip4_frag.c
  group lwip/src/include/compat/stdc
    ../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/compat/posix
    ../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/sys
    ../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/posix/net
    ../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/lwip
    ../../../../../middleware/lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/priv
    ../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h mem_priv.h memp_priv.h memp_std.h api_msg.h nd6_priv.h tcpip_priv.h tcp_priv.h raw_priv.h sockets_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../middleware/lwip/src/include/lwip/prot/: ip6.h udp.h mld6.h ip4.h icmp.h igmp.h dhcp.h tcp.h autoip.h iana.h ieee.h dns.h icmp6.h ethernet.h nd6.h ip.h acd.h dhcp6.h etharp.h
  group lwip/src/include/netif
    ../../../../../middleware/lwip/src/include/netif/: bridgeif.h zepif.h lowpan6.h ieee802154.h ethernet.h lowpan6_common.h lowpan6_opts.h bridgeif_opts.h slipif.h lowpan6_ble.h etharp.h
  group lwip/src/include/netif/ppp
    ../../../../../middleware/lwip/src/include/netif/ppp/: ipv6cp.h pppapi.h magic.h ppp.h upap.h mppe.h pppol2tp.h pppoe.h ipcp.h pppdebug.h eap.h pppos.h ppp_opts.h pppcrypt.h vj.h chap-new.h eui64.h chap_ms.h ccp.h ecp.h lcp.h fsm.h ppp_impl.h chap-md5.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: sha1.h des.h md5.h md4.h arc4.h
  group lwip/src/netif
    ../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lwip/contrib/apps/ping
    ../../../../../middleware/lwip/contrib/apps/ping/: ping.h ping.c
  group mbedtls/include/mbedtls
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h psa_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/include/psa
    ../../../../../middleware/mbedtls/include/psa/: crypto.h crypto_builtin_composites.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group mbedtls/library
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cmac.c common.h constant_time.c constant_time_internal.h constant_time_invasive.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_invasive.h entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c mps_common.h mps_error.h mps_reader.c mps_reader.h mps_trace.c mps_trace.h net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c ssl_tls13_keys.h threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/port/ksdk
    ../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c ccm_alt.h ecp_alt.h ecp_alt.c ecp_curves_alt.c ecp_alt_ksdk.c threading_alt.h ksdk_mbedtls_config.h
  group sdmmc/host
    ../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
    ../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt ChangeLogKSDK.txt
  group sdmmc/src
    ../../../../../middleware/sdmmc/sdio/: fsl_sdio.c
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc/sdio/: fsl_sdio.h
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sdio
    ../../../../../middleware/sdmmc/sdio/: ChangeLogKSDK.txt
  group sdmmc/osa
    ../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group usb/host
    ../../../../../middleware/usb/host/: usb_host_ehci.c usb_host_ehci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c usb_host.h usb_host_hci.h usb_host_devices.h usb_host_framework.h
  group usb/host/class
    ../../../../../middleware/usb/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_msd.c usb_host_msd.h usb_host_msd_ufi.c
  group usb/phy
    ../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group usb/include
    ../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group freertos/freertos-kernel
    ../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/portable
    ../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos-kernel/portable/IAR/ARM_CM4F
    ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos-kernel/include
    ../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group wifi/incl
    ../../../../../middleware/wifi_nxp/incl/: WIFI_IW416_BOARD_AW_AM457_CAL_DATA_EXT.h wifi_cal_data_ext.h wm_utils.h wmerrno.h wmlog.h wmtypes.h
  group wifi/incl/wifidriver
    ../../../../../middleware/wifi_nxp/incl/wifidriver/: mlan_sdio_api.h wifi-decl.h wifi.h wifi_events.h
  group wifi/incl/port/os
    ../../../../../middleware/wifi_nxp/incl/port/os/: wm_os.h
  group wifi/wifidriver
    ../../../../../middleware/wifi_nxp/wifidriver/: sdio.c sdio.h firmware_dnld.c firmware_dnld.h mlan_sdio.c wifi-sdio.h
  group wifi/wifidriver/incl
    ../../../../../middleware/wifi_nxp/wifidriver/incl/: mlan_main_defs.h type_decls.h mlan_sdio_defs.h mlan_sdio.h mlan_decl.h mlan_ioctl.h
  group wifi/wifi_bt_firmware
    ../../../../../middleware/wifi_nxp/wifi_bt_firmware/: sd8801_wlan.h sduartIW416_wlan_bt.h sduart8987_wlan_bt.h sduart_nw61x.h wlan_bt_fw.h
  group wifi/port/os
    ../../../../../middleware/wifi_nxp/port/os/: os.c
  group littlefs
    ../../../../../middleware/littlefs/: lfs.c lfs_util.c lfs.h lfs_util.h
  group framework/Common
    ../../../../../middleware/wireless/framework/Common/: EmbeddedTypes.h fwk_hal_macros.h
  group framework/NVM/interface
    ../../../../../middleware/wireless/framework/NVM/Interface/: NVM_Interface.h
  group framework/NVM/source
    ../../../../../middleware/wireless/framework/NVM/Source/: NV_Flash.c NV_Flash.h
  group framework/FunctionLib
    ../../../../../middleware/wireless/framework/FunctionLib/: FunctionLib.c FunctionLib.h README.md
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
