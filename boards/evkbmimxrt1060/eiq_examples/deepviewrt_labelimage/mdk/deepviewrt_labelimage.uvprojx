# Keil uVision project deepviewrt_labelimage.uvprojx, settings and files
target deepviewrt_labelimage flexspi_nor_sdram_debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: deepviewrt_labelimage.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, DEBUG, CPU_MIMXRT1062DVL6A, _POSIX_C_SOURCE=200809L, ARM_MATH_CM7, __FPU_PRESENT=1, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SDK_DEBUGCONSOLE=1, FSL_RTOS_BM, SDK_OS_BAREMETAL, SDK_I2C_BASED_COMPONENT_USED=1, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../source;..;../../../../../devices/MIMXRT1062/utilities/debug_console_lite;../../../../../devices/MIMXRT1062/drivers;../../../../../components/ft5406_rt;../../../../../components/video/camera/device;../../../../../components/video/camera/receiver;../../../../../components/video/camera/device/sccb;../../../../../components/video/camera/device/ov7725;../../../../../components/video/camera/device/mt9m114;../../../../../components/video/camera;../../../../../components/video/camera/receiver/csi;../../../../../components/video;../../../../../components/video/i2c;../../../../../components/video/display/dc;../../../../../components/video/display/dc/elcdif;../../../../../middleware/eiq/deepviewrt/include;../../../../../components/lists;../../../../../components/uart;../../../../../devices/MIMXRT1062;../../../../../devices/MIMXRT1062/xip;../../../xip;../../../../../CMSIS/DSP/Include;../../../../../CMSIS/Core/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../source
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor_sdram.scf
  link misc: ../../../../../middleware/eiq/deepviewrt/lib/deepview-rt-mdk.lib ../../../../../CMSIS/DSP/Lib/ARM/arm_cortexM7lfdp_math.lib --remove --predefine="-D__stack_size__=0x10000" --predefine="-D__heap_size__=0x800000" --diag-warning=6242 --entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group source
    ../: main.c model.S
  group source/data
    ../source/data/: sample.jpg
  group source/models
    ../source/models/: mobilenet_v1_0.25_160.rtm mobilenet_v1_0.25_224_quant.rtm
  group board
    ../: pin_mux.h pin_mux.c cr_section_macros.h board_init.h board_init.c clock_config.c clock_config.h dcd.c dcd.h board.h board.c
    ./: retarget.c
  group doc
    ../doc/: readme.txt
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_cache.c fsl_cache.h fsl_elcdif.c fsl_elcdif.h fsl_lpi2c.c fsl_lpi2c.h fsl_csi.c fsl_csi.h fsl_flexram.c fsl_flexram.h fsl_pxp.c fsl_pxp.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_iomuxc.h fsl_flexram_allocate.c fsl_flexram_allocate.h
  group touchpanel
    ../../../../../components/ft5406_rt/: fsl_ft5406_rt.h fsl_ft5406_rt.c
  group video
    ../../../../../components/video/camera/device/: fsl_camera_device.h
    ../../../../../components/video/camera/receiver/: fsl_camera_receiver.h
    ../../../../../components/video/camera/device/sccb/: fsl_sccb.h fsl_sccb.c
    ../../../../../components/video/camera/device/ov7725/: fsl_ov7725.h fsl_ov7725.c
    ../../../../../components/video/camera/device/mt9m114/: fsl_mt9m114.h fsl_mt9m114.c
    ../../../../../components/video/camera/: fsl_camera.h
    ../../../../../components/video/camera/receiver/csi/: fsl_csi_camera_adapter.h fsl_csi_camera_adapter.c
    ../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../components/video/i2c/: fsl_video_i2c.h fsl_video_i2c.c
    ../../../../../components/video/display/dc/: fsl_dc_fb.h
    ../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.h fsl_dc_fb_elcdif.c
  group eiq/deepviewrt/include
    ../../../../../middleware/eiq/deepviewrt/include/: deepview_ops.h deepview_rpc.h deepview_rt.h mathrt.h stb_image.h stb_image_resize.h stb_image_write.h
  group eiq/deepviewrt
    ../../../../../middleware/eiq/deepviewrt/: readme.txt
  group eiq/deepviewrt/lib
    ../../../../../middleware/eiq/deepviewrt/lib/: LICENSE.txt
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group startup
    ../../../../../devices/MIMXRT1062/arm/: startup_MIMXRT1062.S
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkbmimxrt1060_flexspi_nor_config.c evkbmimxrt1060_flexspi_nor_config.h
  group CMSIS/DSP/Include
    ../../../../../CMSIS/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
target deepviewrt_labelimage flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: deepviewrt_labelimage.out
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, CPU_MIMXRT1062DVL6A, _POSIX_C_SOURCE=200809L, ARM_MATH_CM7, __FPU_PRESENT=1, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SDK_DEBUGCONSOLE=1, FSL_RTOS_BM, SDK_OS_BAREMETAL, SDK_I2C_BASED_COMPONENT_USED=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../source
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor_sdram.scf
  link misc: as above
