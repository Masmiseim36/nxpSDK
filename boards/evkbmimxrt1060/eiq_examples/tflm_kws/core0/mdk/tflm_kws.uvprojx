# Keil uVision project tflm_kws.uvprojx, settings and files
target tflm_kws flexspi_nor_sdram_debug (ARM-ADS)
  device: MIMXRT1062DVL6B NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: tflm_kws.out
  AfterMake: fromelf.exe --output "$Ltflm_kws.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, XIP_EXTERNAL_FLASH=1, USE_SDRAM=1, SKIP_SYSCLK_INIT=1, DATA_SECTION_IS_CACHEABLE=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1062DVL6B, MIMXRT1062_SERIES, DISABLEFLOAT16, TF_LITE_STATIC_MEMORY, KERNELS_OPTIMIZED_FOR_SPEED
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb -fno-exceptions
  c include: ..;../../../../xip;../../../../../../devices/MIMXRT1062/drivers;../../../../../../CMSIS/DSP/Include;../../../../../../CMSIS/DSP/PrivateInclude;../../../../../../CMSIS/DSP/Source/DistanceFunctions;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MIMXRT1062;../../../../../../devices/MIMXRT1062/periph;../../../../../../devices/MIMXRT1062/xip;../../../../../../devices/MIMXRT1062/utilities/debug_console_lite;../../../../../../devices/MIMXRT1062/utilities/str;../../../../../../components/uart;../../../../../../middleware/eiq/tensorflow-lite;../../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include;../../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp;../../../../../../middleware/eiq/tensorflow-lite/third_party/kissfft;../../../../../../middleware/eiq/tensorflow-lite/third_party/ruy;../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn;../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn/Include
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1062DVL6B, MIMXRT1062_SERIES
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor_sdram.scf
  link misc: ../../../../../../middleware/eiq/tensorflow-lite/lib/cm7/mdk/tflm.lib --remove --predefine=\"-DXIP_BOOT_HEADER_ENABLE=1\" --predefine=\"-DXIP_BOOT_HEADER_DCD_ENABLE=1\" --predefine=-D__heap_size__=0x8000 --predefine=-D__stack_size__=0x2000 --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: model_data.h model_ds_cnn_ops_micro.cpp get_top_n.cpp board_init.h get_top_n.h kws_mfcc.cpp kws_mfcc.hpp mfcc.cpp mfcc.hpp model.cpp model.h demo_info.cpp demo_info.h output_postproc.cpp output_postproc.h main.cpp audio_load.cpp audio.h audio_data.h demo_config.h labels.h off.wav train.py timer.c timer.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group xip
    ../../../../xip/: evkbmimxrt1060_flexspi_nor_config.c evkbmimxrt1060_flexspi_nor_config.h
    ../../../../: dcd.c dcd.h
    ../../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group drivers
    ../../../../../../devices/MIMXRT1062/drivers/: fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_gpc.c fsl_gpc.h fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_pmu.h fsl_pmu.c fsl_src.c fsl_src.h
  group CMSIS/DSP/Include
    ../../../../../../CMSIS/DSP/Include/: arm_common_tables.h arm_common_tables_f16.h arm_const_structs.h arm_const_structs_f16.h arm_helium_utils.h arm_math.h arm_math_f16.h arm_math_memory.h arm_math_types.h arm_math_types_f16.h arm_mve_tables.h arm_mve_tables_f16.h arm_vec_math.h arm_vec_math_f16.h
  group CMSIS/DSP/Include/dsp
    ../../../../../../CMSIS/DSP/Include/dsp/: basic_math_functions.h basic_math_functions_f16.h bayes_functions.h bayes_functions_f16.h complex_math_functions.h complex_math_functions_f16.h controller_functions.h controller_functions_f16.h debug.h distance_functions.h distance_functions_f16.h fast_math_functions.h fast_math_functions_f16.h filtering_functions.h filtering_functions_f16.h interpolation_functions.h interpolation_functions_f16.h matrix_functions.h matrix_functions_f16.h matrix_utils.h none.h quaternion_math_functions.h statistics_functions.h statistics_functions_f16.h support_functions.h support_functions_f16.h svm_defines.h svm_functions.h svm_functions_f16.h transform_functions.h transform_functions_f16.h utils.h window_functions.h
  group CMSIS/DSP/PrivateInclude
    ../../../../../../CMSIS/DSP/PrivateInclude/: arm_sorting.h arm_vec_fft.h arm_vec_filtering.h
  group CMSIS/DSP/Source/BasicMathFunctions
    ../../../../../../CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
  group CMSIS/DSP/Source/BayesFunctions
    ../../../../../../CMSIS/DSP/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
  group CMSIS/DSP/Source/CommonTables
    ../../../../../../CMSIS/DSP/Source/CommonTables/: CommonTables.c CommonTablesF16.c
  group CMSIS/DSP/Source/ComplexMathFunctions
    ../../../../../../CMSIS/DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
  group CMSIS/DSP/Source/ControllerFunctions
    ../../../../../../CMSIS/DSP/Source/ControllerFunctions/: ControllerFunctions.c
  group CMSIS/DSP/Source/DistanceFunctions
    ../../../../../../CMSIS/DSP/Source/DistanceFunctions/: DistanceFunctions.c arm_boolean_distance_template.h DistanceFunctionsF16.c
  group CMSIS/DSP/Source/FastMathFunctions
    ../../../../../../CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
  group CMSIS/DSP/Source/FilteringFunctions
    ../../../../../../CMSIS/DSP/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
  group CMSIS/DSP/Source/InterpolationFunctions
    ../../../../../../CMSIS/DSP/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
  group CMSIS/DSP/Source/MatrixFunctions
    ../../../../../../CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
  group CMSIS/DSP/Source/QuaternionMathFunctions
    ../../../../../../CMSIS/DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
  group CMSIS/DSP/Source/SVMFunctions
    ../../../../../../CMSIS/DSP/Source/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
  group CMSIS/DSP/Source/StatisticsFunctions
    ../../../../../../CMSIS/DSP/Source/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
  group CMSIS/DSP/Source/SupportFunctions
    ../../../../../../CMSIS/DSP/Source/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
  group CMSIS/DSP/Source/TransformFunctions
    ../../../../../../CMSIS/DSP/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
  group CMSIS/DSP/Source/WindowFunctions
    ../../../../../../CMSIS/DSP/Source/WindowFunctions/: WindowFunctions.c
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv7m_cachel1.h armv7m_mpu.h
  group device
    ../../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h MIMXRT1062_COMMON.h system_MIMXRT1062.c system_MIMXRT1062.h
  group device/periph
    ../../../../../../devices/MIMXRT1062/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_AIPSTZ.h PERI_AOI.h PERI_BEE.h PERI_CAN.h PERI_CCM.h PERI_CCM_ANALOG.h PERI_CM7_MCM.h PERI_CMP.h PERI_CSI.h PERI_CSU.h PERI_DCDC.h PERI_DCP.h PERI_DMA.h PERI_DMAMUX.h PERI_ENC.h PERI_ENET.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_KPP.h PERI_LCDIF.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_OCOTP.h PERI_PGC.h PERI_PIT.h PERI_PMU.h PERI_PWM.h PERI_PXP.h PERI_ROMC.h PERI_RTWDOG.h PERI_SEMC.h PERI_SNVS.h PERI_SPDIF.h PERI_SRC.h PERI_TEMPMON.h PERI_TMR.h PERI_TRNG.h PERI_TSC.h PERI_USB.h PERI_USBNC.h PERI_USBPHY.h PERI_USB_ANALOG.h PERI_USDHC.h PERI_WDOG.h PERI_XBARA.h PERI_XBARB.h PERI_XTALOSC24M.h
  group startup/arm
    ../../../../../../devices/MIMXRT1062/arm/: startup_MIMXRT1062.S
  group utilities
    ../../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
    ../../../../../../devices/MIMXRT1062/utilities/: fsl_memcpy.S
  group utilities/str
    ../../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group eiq/tensorflow-lite/tensorflow/compiler/mlir/lite/kernels/internal
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/compiler/mlir/lite/kernels/internal/: compatibility_macros.h
  group eiq/tensorflow-lite/tensorflow/compiler/mlir/lite/schema
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/compiler/mlir/lite/schema/: schema_generated.h schema_utils.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/: kernel_util.h op_macros.h padding.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/: common.h compatibility.h cppmath.h max.h min.h portable_tensor.h portable_tensor_utils.h quantization_util.h runtime_shape.h strided_slice_logic.h tensor_ctypes.h types.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/: add.h add_n.h arg_min_max.h batch_matmul.h batch_to_space_nd.h binary_function.h broadcast_args.h broadcast_to.h ceil.h comparisons.h concatenation.h conv.h cumsum.h depth_to_space.h depthwiseconv_float.h depthwiseconv_uint8.h dequantize.h div.h elu.h exp.h fill.h floor.h floor_div.h floor_mod.h fully_connected.h hard_swish.h l2normalization.h leaky_relu.h log_softmax.h logistic.h lstm_cell.h maximum_minimum.h mul.h neg.h pad.h pooling.h portable_tensor_utils.h portable_tensor_utils_impl.h prelu.h process_broadcast_shapes.h quantize.h reduce.h requantize.h resize_bilinear.h resize_nearest_neighbor.h round.h select.h slice.h softmax.h space_to_batch_nd.h space_to_depth.h strided_slice.h sub.h tanh.h transpose.h transpose_conv.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops/: add.h conv.h depthwise_conv.h fully_connected.h l2normalization.h logistic.h mean.h mul.h pooling.h tanh.h transpose_conv.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized/: neon_check.h
  group eiq/tensorflow-lite/tensorflow/lite/experimental/microfrontend/lib
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/experimental/microfrontend/lib/: bits.h fft.h fft_util.h filterbank.h filterbank_util.h frontend.h frontend_util.h kiss_fft_common.h kiss_fft_int16.h log_lut.h log_scale.h log_scale_util.h noise_reduction.h noise_reduction_util.h pcan_gain_control.h pcan_gain_control_util.h window.h window_util.h
  group eiq/tensorflow-lite/tensorflow/lite/schema
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/schema/: schema_generated.h schema_utils.h
  group eiq/tensorflow-lite/tensorflow/lite
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/: array.h builtin_op_data.h builtin_ops.h context_util.h portable_type_to_tflitetype.h
  group eiq/tensorflow-lite/tensorflow/lite/core/api
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/api/: error_reporter.h flatbuffer_conversions.h tensor_utils.h
  group eiq/tensorflow-lite/tensorflow/lite/core
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/: macros.h
  group eiq/tensorflow-lite/tensorflow/lite/core/c
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/c/: builtin_op_data.h c_api_types.h common.h
  group eiq/tensorflow-lite/tensorflow/lite/micro
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/: compatibility.h compression.h debug_log.h fake_micro_context.h flatbuffer_utils.h hexdump.h memory_helpers.h micro_allocation_info.h micro_allocator.h micro_arena_constants.h micro_common.h micro_context.h micro_graph.h micro_interpreter.h micro_interpreter_context.h micro_interpreter_graph.h micro_log.h micro_mutable_op_resolver.h micro_op_resolver.h micro_profiler.h micro_profiler_interface.h micro_resource_variable.h micro_time.h micro_utils.h mock_micro_graph.h recording_micro_allocator.h recording_micro_interpreter.h span.h static_vector.h system_setup.h test_helper_custom_ops.h test_helpers.h debug_log.cpp
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/: activation_utils.h activations.h add.h batch_matmul.h circular_buffer.h circular_buffer_flexbuffers_generated_data.h conv.h conv_test.h decompress.h depthwise_conv.h dequantize.h detection_postprocess_flexbuffers_generated_data.h ethosu.h fully_connected.h hard_swish.h kernel_runner.h kernel_util.h leaky_relu.h logical.h logistic.h lstm_eval.h lstm_eval_test.h lstm_shared.h maximum_minimum.h micro_ops.h micro_tensor_utils.h mul.h pad.h pooling.h prelu.h quantize.h reduce.h reshape.h softmax.h strided_slice.h sub.h svdf.h transpose.h transpose_conv.h unidirectional_sequence_lstm.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels/xtensa
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/xtensa/: lstm_eval.h xtensa.h xtensa_add.h xtensa_conv.h xtensa_depthwise_conv.h xtensa_fully_connected.h xtensa_pad.h xtensa_pooling.h xtensa_reduce.h xtensa_reshape.h xtensa_softmax.h xtensa_svdf.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/compression
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/compression/: metadata_saved.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/memory_planner
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.h linear_memory_planner.h memory_plan_struct.h micro_memory_planner.h non_persistent_buffer_planner_shim.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/arena_allocator
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/arena_allocator/: ibuffer_allocator.h non_persistent_arena_buffer_allocator.h persistent_arena_buffer_allocator.h recording_single_arena_buffer_allocator.h single_arena_buffer_allocator.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/tflite_bridge
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/tflite_bridge/: flatbuffer_conversions_bridge.h micro_error_reporter.h
  group eiq/tensorflow-lite/tensorflow/lite/c
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/c/: builtin_op_data.h c_api_types.h common.h
  group eiq/tensorflow-lite/tensorflow/compiler/mlir/lite/core/api
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/compiler/mlir/lite/core/api/: error_reporter.h
  group eiq/tensorflow-lite/tensorflow/compiler/mlir/lite/core/c
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/compiler/mlir/lite/core/c/: builtin_op_data.h tflite_types.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels/xtensa/hifimini
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/xtensa/hifimini/: fixedpoint_utils.h
  group eiq/tensorflow-lite/signal/micro/kernels
    ../../../../../../middleware/eiq/tensorflow-lite/signal/micro/kernels/: delay_flexbuffers_generated_data.h energy_flexbuffers_generated_data.h fft_auto_scale_kernel.h fft_flexbuffers_generated_data.h filter_bank_flexbuffers_generated_data.h filter_bank_log_flexbuffers_generated_data.h filter_bank_spectral_subtraction_flexbuffers_generated_data.h filter_bank_square_root.h framer_flexbuffers_generated_data.h irfft.h overlap_add_flexbuffers_generated_data.h pcan_flexbuffers_generated_data.h rfft.h stacker_flexbuffers_generated_data.h window_flexbuffers_generated_data.h
  group eiq/tensorflow-lite/signal/src
    ../../../../../../middleware/eiq/tensorflow-lite/signal/src/: circular_buffer.h complex.h energy.h fft_auto_scale.h filter_bank.h filter_bank_log.h filter_bank_spectral_subtraction.h filter_bank_square_root.h irfft.h log.h max_abs.h msb.h overlap_add.h pcan_argc_fixed.h rfft.h square_root.h window.h
  group eiq/tensorflow-lite/signal/src/kiss_fft_wrappers
    ../../../../../../middleware/eiq/tensorflow-lite/signal/src/kiss_fft_wrappers/: kiss_fft_common.h kiss_fft_float.h kiss_fft_int16.h kiss_fft_int32.h
  group eiq/tensorflow-lite/third_party/cmsis_nn/Include
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn/Include/: arm_nn_math_types.h arm_nn_tables.h arm_nn_types.h arm_nnfunctions.h arm_nnsupportfunctions.h
  group eiq/tensorflow-lite/third_party/cmsis_nn/Include/Internal
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn/Include/Internal/: arm_nn_compiler.h
  group eiq/tensorflow-lite/third_party/fft2d
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/fft2d/: fft.h fft2d.h
  group eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/: allocator.h array.h base.h buffer.h buffer_ref.h code_generator.h code_generators.h default_allocator.h detached_buffer.h file_manager.h flatbuffer_builder.h flatbuffers.h flatc.h flex_flat_util.h flexbuffers.h grpc.h hash.h idl.h minireflect.h reflection.h reflection_generated.h registry.h stl_emulation.h string.h struct.h table.h util.h vector.h vector_downward.h verifier.h
  group eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/pch
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/pch/: flatc_pch.h pch.h
  group eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint/: fixedpoint.h fixedpoint_neon.h fixedpoint_sse.h
  group eiq/tensorflow-lite/third_party/gemmlowp/internal
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/internal/: detect_platform.h
  group eiq/tensorflow-lite/third_party/ruy/ruy/profiler
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/ruy/profiler/: instrumentation.h
  group eiq/tensorflow-lite/third_party/kissfft
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/kissfft/: _kiss_fft_guts.h kiss_fft.h
  group eiq/tensorflow-lite/third_party/kissfft/tools
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/kissfft/tools/: kfc.h kiss_fftnd.h kiss_fftndr.h kiss_fftr.h
  group eiq/common/toolchains/mdk
    ../../../../../../middleware/eiq/common/toolchains/mdk/: retarget.c
  group doc
    ../: readme.md examples_shared_readme.md
target tflm_kws flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1062DVL6B NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: tflm_kws.out
  AfterMake: fromelf.exe --output "$Ltflm_kws.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, XIP_EXTERNAL_FLASH=1, USE_SDRAM=1, SKIP_SYSCLK_INIT=1, DATA_SECTION_IS_CACHEABLE=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1062DVL6B, MIMXRT1062_SERIES, DISABLEFLOAT16, TF_LITE_STATIC_MEMORY, KERNELS_OPTIMIZED_FOR_SPEED
  c misc: as above
  c include: as above
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1062DVL6B, MIMXRT1062_SERIES
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor_sdram.scf
  link misc: as above
