# Keil uVision project ncp_host.uvprojx, settings and files
target ncp_host flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1062DVL6B NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ncp_host.out
  AfterMake: fromelf.exe --output "$Lncp_host.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, XIP_BOOT_HEADER_ENABLE=1, XIP_EXTERNAL_FLASH=1, SDK_DEBUGCONSOLE_UART, USE_RTOS=1, OSA_USED, USB_HOST_CONFIG_LOW_POWER_MODE=1, PRINTF_ADVANCED_ENABLE=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1062DVL6B, MIMXRT1062_SERIES, SERIAL_PORT_TYPE_UART=1, TIMER_PORT_TYPE_PIT=1, WIFI_BOARD_RW610, MBEDTLS_CONFIG_FILE='\"ksdk_mbedtls_config.h\"', SDIO_ENABLED=1, SDK_OS_FREE_RTOS
  c misc: -include ../ncp_host_config.h -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../ble;../ble/ble_service;../../../xip;../../../../../devices/MIMXRT1062/drivers;../../../../../CMSIS/Core/Include;../../../../../CMSIS/Core/Include/m-profile;../../../../../devices/MIMXRT1062;../../../../../devices/MIMXRT1062/periph;../../../../../devices/MIMXRT1062/xip;../../../../../devices/MIMXRT1062/utilities/debug_console_lite;../../../../../components/lists;../../../../../devices/MIMXRT1062/utilities/str;../../../../../components/serial_manager;../../../../../components/gpio;../../../../../components/timer;../../../../../components/uart;../../../../../components/osa;../../../../../components/wifi_bt_module/incl;../../../../../middleware/mbedtls/include;../../../../../middleware/mbedtls/library;../../../../../middleware/mbedtls/port/ksdk;../../../../../middleware/usb/include;../../../../../middleware/usb/host;../../../../../middleware/usb/config/host/ehci;../../../../../middleware/usb/host/class;../../../../../middleware/usb/phy;../../../../../middleware/sdmmc/common;../../../../../middleware/sdmmc/osa;../../../../../middleware/sdmmc/sdio;../../../../../middleware/sdmmc/host/usdhc;../../../../../rtos/freertos/freertos-kernel/include;../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1062DVL6B, MIMXRT1062_SERIES, OSA_USED
  asm include: ..;../../../xip;../../../../../devices/MIMXRT1062/drivers;../../../../../CMSIS/Core/Include;../../../../../CMSIS/Core/Include/m-profile;../../../../../devices/MIMXRT1062;../../../../../devices/MIMXRT1062/periph;../../../../../devices/MIMXRT1062/xip;../../../../../devices/MIMXRT1062/utilities/debug_console_lite;../../../../../components/lists;../../../../../devices/MIMXRT1062/utilities/str;../../../../../components/serial_manager;../../../../../components/gpio;../../../../../components/timer;../../../../../components/uart;../../../../../components/osa;../../../../../components/wifi_bt_module/incl;../../../../../middleware/mbedtls/include;../../../../../middleware/mbedtls/library;../../../../../middleware/mbedtls/port/ksdk;../../../../../middleware/usb/include;../../../../../middleware/usb/host;../../../../../middleware/usb/config/host/ehci;../../../../../middleware/usb/host/class;../../../../../middleware/usb/phy;../../../../../middleware/sdmmc/common;../../../../../middleware/sdmmc/osa;../../../../../middleware/sdmmc/sdio;../../../../../middleware/sdmmc/host/usdhc;../../../../../rtos/freertos/freertos-kernel/include;../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: --remove --predefine=\"-DXIP_BOOT_HEADER_ENABLE=1\" --predefine=\"-D__stack_size__=0x400\" --predefine=\"-D__heap_size__=0x400\" --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: main.c ncp_host_app.h ncp_host_app.c ncp_host_command.h lwipopts.h lwippools.h FreeRTOSConfig.h ncp_host_app_system.c ncp_host_command_system.c ncp_host_app_wifi.c ncp_host_command_wifi.h ncp_host_command_wifi.c ncp_host_utils_wifi.h ncp_wifi_api.h ncp_wifi_api.c ncp_host_app_ot.c ncp_host_command_ot.c otopcode.c otopcode.h otopcode_private.h mbedtls_host.c mbedtls_host.h key_cert.h ncp_cmd_common.h ncp_intf_usb_host_cdc.c ncp_intf_usb_host_cdc.h ncp_usb_host_cdc.c ncp_usb_host_cdc.h usb_host_cdc_app.c usb_host_cdc_app.h usb_host_config.h ncp_intf_sdio_host.c ncp_intf_sdio_host.h ncp_intf_spi_master.c ncp_intf_spi_master.h ncp_crc.c ncp_crc.h mbedtls_common.c mbedtls_common.h ncp_tlv_adapter.c ncp_tlv_adapter.h ncp_adapter.h ncp_debug.h ncp_cmd_system.h ncp_cmd_wifi.h ncp_cmd_ble.h ncp_intf_pm.c ncp_intf_pm.h ncp_intf_uart.c ncp_intf_uart.h ncp_cmd_node.c ncp_cmd_node.h FreeRTOSConfigBoard.h sdmmc_config.c sdmmc_config.h app_config.h ncp_host_config.h FreeRTOSConfig_Gen.h fsl_os_abstraction_config.h mcux_config.h usb_host_config.h
  group source/ble
    ../ble/: ncp_host_app_ble.c ncp_host_command_ble.h ncp_host_command_ble.c
  group source/ble/ble_service
    ../ble/ble_service/: service.h ht.h htc.c hts.c hr.h hrc.c hrs.c bas.h bas.c
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group xip
    ../../../xip/: evkbmimxrt1060_flexspi_nor_config.c evkbmimxrt1060_flexspi_nor_config.h
    ../../../: dcd.c dcd.h
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_dcp.c fsl_dcp.h fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_gpc.c fsl_gpc.h fsl_gpio.h fsl_gpio.c fsl_lpspi_edma.h fsl_lpspi_edma.c fsl_lpspi.c fsl_lpspi.h fsl_lpuart.h fsl_lpuart.c fsl_pit.c fsl_pit.h fsl_pmu.h fsl_pmu.c fsl_src.c fsl_src.h fsl_trng.c fsl_trng.h fsl_usdhc.c fsl_usdhc.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv7m_cachel1.h armv7m_mpu.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h MIMXRT1062_COMMON.h system_MIMXRT1062.c system_MIMXRT1062.h
  group device/periph
    ../../../../../devices/MIMXRT1062/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_AIPSTZ.h PERI_AOI.h PERI_BEE.h PERI_CAN.h PERI_CCM.h PERI_CCM_ANALOG.h PERI_CM7_MCM.h PERI_CMP.h PERI_CSI.h PERI_CSU.h PERI_DCDC.h PERI_DCP.h PERI_DMA.h PERI_DMAMUX.h PERI_ENC.h PERI_ENET.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_KPP.h PERI_LCDIF.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_OCOTP.h PERI_PGC.h PERI_PIT.h PERI_PMU.h PERI_PWM.h PERI_PXP.h PERI_ROMC.h PERI_RTWDOG.h PERI_SEMC.h PERI_SNVS.h PERI_SPDIF.h PERI_SRC.h PERI_TEMPMON.h PERI_TMR.h PERI_TRNG.h PERI_TSC.h PERI_USB.h PERI_USBNC.h PERI_USBPHY.h PERI_USB_ANALOG.h PERI_USDHC.h PERI_WDOG.h PERI_XBARA.h PERI_XBARB.h PERI_XTALOSC24M.h
  group startup/arm
    ../../../../../devices/MIMXRT1062/arm/: startup_MIMXRT1062.S
  group drivers/freertos
    ../../../../../devices/MIMXRT1062/drivers/: fsl_lpuart_freertos.h fsl_lpuart_freertos.c
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
    ../../../../../devices/MIMXRT1062/utilities/: fsl_memcpy.S
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group utilities/str
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/gpio
    ../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group component/timer
    ../../../../../components/timer/: fsl_adapter_timer.h fsl_adapter_pit.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h
  group component/wifi_bt_module/incl
    ../../../../../components/wifi_bt_module/incl/: wifi_bt_module_config.h
  group mbedtls/include/mbedtls
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h psa_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/include/psa
    ../../../../../middleware/mbedtls/include/psa/: crypto.h crypto_builtin_composites.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group mbedtls/library
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum_internal.h bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cmac.c common.h constant_time.c constant_time_internal.h constant_time_invasive.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_invasive.h entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c mps_common.h mps_error.h mps_reader.c mps_reader.h mps_trace.c mps_trace.h net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c ssl_tls13_keys.h threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/port/ksdk
    ../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c ccm_alt.h ecp_alt.h ecp_alt.c ecp_curves_alt.c ecp_alt_ksdk.c threading_alt.h
  group usb/include
    ../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group usb/host
    ../../../../../middleware/usb/host/: usb_host.h usb_host_hci.h usb_host_devices.h usb_host_framework.h usb_host_ehci.c usb_host_ehci.h usb_host_hci.c usb_host_devices.c usb_host_framework.c
  group usb/host/class
    ../../../../../middleware/usb/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_cdc.c usb_host_cdc.h
  group usb/phy
    ../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group sdmmc/common
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h fsl_sdmmc_common.c
  group sdmmc/osa
    ../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group sdmmc/sdio
    ../../../../../middleware/sdmmc/sdio/: fsl_sdio.c fsl_sdio.h
  group sdmmc/host/usdhc
    ../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h fsl_sdmmc_host.h
  group sdmmc/host/usdhc/non_blocking
    ../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group freertos/freertos-kernel
    ../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable
    ../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/GCC/ARM_CM4F
    ../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
target ncp_host flexspi_nor_release (ARM-ADS)
  device: MIMXRT1062DVL6B NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ncp_host.out
  AfterMake: fromelf.exe --output "$Lncp_host.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, XIP_BOOT_HEADER_ENABLE=1, XIP_EXTERNAL_FLASH=1, SDK_DEBUGCONSOLE_UART, USE_RTOS=1, OSA_USED, USB_HOST_CONFIG_LOW_POWER_MODE=1, PRINTF_ADVANCED_ENABLE=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1062DVL6B, MIMXRT1062_SERIES, SERIAL_PORT_TYPE_UART=1, TIMER_PORT_TYPE_PIT=1, WIFI_BOARD_RW610, MBEDTLS_CONFIG_FILE='\"ksdk_mbedtls_config.h\"', SDIO_ENABLED=1, SDK_OS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: as above
