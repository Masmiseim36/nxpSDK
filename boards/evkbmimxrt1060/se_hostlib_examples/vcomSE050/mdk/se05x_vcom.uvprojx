# Keil uVision project se05x_vcom.uvprojx, settings and files
target se05x_vcom flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: se05x_vcom.out
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1062DVL6A, BOARD_USE_VIRTUALCOM=1, IMX_RT, USB_STACK_BM, SDK_DEBUGCONSOLE_UART, MBEDTLS_CONFIG_FILE='\"ksdk_mbedtls_config.h\"', MBEDTLS_USER_CONFIG_FILE='\"sss_ksdk_mbedtls_config.h\"', USB_ISR_REDIRECT, PRINTF_ADVANCED_ENABLE=1, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, USB_DEVICE_CONFIG_CDC_ACM=1, MBEDTLS, SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC, SERIAL_PORT_TYPE_UART=1, T1oI2C, T1oI2C_UM11225, SSS_USE_FTR_FILE, NO_SECURE_CHANNEL_SUPPORT, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../components/serial_manager;../../../../../middleware/se_hostlib/hostlib/hostLib/vcom/ksdk;../../../../../middleware/usb/device;../../../../../components/osa;../../../../../middleware/usb/include;../../../../../devices/MIMXRT1062/drivers;../../../../../middleware/mbedtls/include;../../../../../middleware/mbedtls/library;../../../../../middleware/mbedtls/port/ksdk;../../../../../middleware/se_hostlib/sss/plugin/mbedtls;../../../../../middleware/se_hostlib/sss/port/ksdk;../../../../../devices/MIMXRT1062;../../../../../devices/MIMXRT1062/utilities/str;../../../../../devices/MIMXRT1062/utilities/debug_console;../../../../../components/uart;../../../../../components/lists;../../../../../devices/MIMXRT1062/xip;../../../xip;../../../../../middleware/usb/output/source/device/class;../../../../../middleware/usb/output/source/device;../../../../../CMSIS/Core/Include;../../../../../middleware/usb/phy;../../../../../middleware/se_hostlib/hostlib/hostLib/inc;../../../../../middleware/se_hostlib/hostlib/hostLib/se05x/src;../../../../../middleware/se_hostlib/sss/inc;../../../../../middleware/se_hostlib;../../../../../middleware/se_hostlib/platform;../../../../../middleware/se_hostlib/hostlib/hostLib/platform/inc;../../../../../middleware/se_hostlib/hostlib/hostLib/platform/ksdk;../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom;../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/T1oI2C;../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/infra;../../../../../middleware/se_hostlib/sss/ex/inc;../../../../../middleware/se_hostlib/sss/ex/src;../../../../../middleware/se_hostlib/hostlib/hostLib/se05x_03_xx_xx;../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/log;../../../../../middleware/se_hostlib/hostlib/hostLib/mbedtls/inc
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: --remove --entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x8000"
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group source
    ../: fsl_sss_ftr.h smComT1oI2C.h smComSCI2C.h vcom2i2c.c vcom2i2c.h virtual_com.c virtual_com.h se_pit_config.c
  group doc
    ../: readme.txt
  group middleware/se_hostlib/hostlib/hostLib/vcom/ksdk
    ../../../../../middleware/se_hostlib/hostlib/hostLib/vcom/ksdk/: usb_device_descriptor.c usb_device_descriptor.h
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_port_uart.c fsl_component_serial_port_uart.h fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/serial_manager/usb_cdc_adapter
    ../: usb_device_config.h
  group usb/device/include
    ../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group usb/device/source
    ../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h usb_device_dci.h
    ../../../../../middleware/usb/output/source/device/: usb_device_ch9.c usb_device_ch9.h
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c
  group usb/device/source/ehci
    ../../../../../middleware/usb/device/: usb_device_ehci.c usb_device_ehci.h
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_cache.c fsl_cache.h fsl_trng.c fsl_trng.h fsl_lpi2c.c fsl_lpi2c.h fsl_dcp.c fsl_dcp.h fsl_pit.c fsl_pit.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group mbedtls/include/mbedtls
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h config_psa.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h psa_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/include/psa
    ../../../../../middleware/mbedtls/include/psa/: crypto.h crypto_builtin_composites.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_contexts_composites.h crypto_driver_contexts_primitives.h crypto_driver_common.h crypto_extra.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group mbedtls/library
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c chacha20.c chachapoly.c check_crypto_config.h cmac.c common.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_invasive.h entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c mps_common.h mps_error.h mps_reader.c mps_trace.c mps_trace.h memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_invasive.h ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c ssl_tls13_keys.h threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/port/ksdk
    ../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c ecp_alt.h ecp_alt.c ecp_curves_alt.c ecp_alt_ksdk.c threading_alt.h
  group se_hostlib/sss/plugin/mbedtls
    ../../../../../middleware/se_hostlib/sss/plugin/mbedtls/: ecdh_alt_ax.c ecdsa_verify_alt.c ecp_alt_sss.c sss_mbedtls.c sss_mbedtls_rsa.c ecdsa_verify_alt.h ecp_alt.h rsa_alt.h sss_mbedtls.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1062/arm/: startup_MIMXRT1062.S
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkbmimxrt1060_flexspi_nor_config.c evkbmimxrt1060_flexspi_nor_config.h
  group usb/device/class/cdc
    ../../../../../middleware/usb/output/source/device/class/: usb_device_cdc_acm.c usb_device_cdc_acm.h
  group usb/device/class
    ../../../../../middleware/usb/output/source/device/class/: usb_device_class.c usb_device_class.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group usb/phy
    ../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group usb/include
    ../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group se_hostlib/sss/port/ksdk
    ../../../../../middleware/se_hostlib/sss/port/ksdk/: fsl_sss_types.h fsl_sss_types.h sss_ksdk_mbedcrypto_config.h sss_ksdk_mbedtls_config.h
  group se_hostlib/hostlib/hostLib/inc
    ../../../../../middleware/se_hostlib/hostlib/hostLib/inc/: Applet_SE050_Ver.h HLSEAPI.h HLSEComm.h HLSECrypto.h HLSEMisc.h HLSEObjects.h HLSETypes.h PlugAndTrust_HostLib_Ver.h PlugAndTrust_Pkg_Ver.h SE_HAL_Lib.h a71ch_api.h a71ch_util.h a71cl_api.h a71cl_util.h ax_api.h ax_common.h ax_common_a71ch.h ax_common_a71cl.h ax_common_private.h ax_scp.h ax_scp_private.h ax_sss_scp.h ax_util.h ledHandler.h nxEnsure.h nxScp03_Apis.h nxScp03_Const.h nxScp03_Types.h scp.h se05x_const.h se05x_ecc_curves.h se05x_ecc_curves_inc.h se05x_ecc_curves_values.h se05x_enums.h se05x_ftr.h se05x_tlv.h sm_const.h
  group se_hostlib/hostlib/hostLib/se05x/src
    ../../../../../middleware/se_hostlib/hostlib/hostLib/se05x/src/: se05x_ECC_curves.c se05x_mw.c se05x_tlv.c
  group se_hostlib/sss/inc
    ../../../../../middleware/se_hostlib/sss/inc/: fsl_sscp.h fsl_sscp_a71ch.h fsl_sscp_a71cl.h fsl_sscp_commands.h fsl_sscp_mu.h fsl_sss_api.h fsl_sss_api_ver.h fsl_sss_config.h fsl_sss_ftr_default.h fsl_sss_keyid_map.h fsl_sss_lpc55s_apis.h fsl_sss_lpc55s_types.h fsl_sss_mbedtls_apis.h fsl_sss_mbedtls_types.h fsl_sss_openssl_apis.h fsl_sss_openssl_types.h fsl_sss_policy.h fsl_sss_se05x_apis.h fsl_sss_se05x_policy.h fsl_sss_se05x_scp03.h fsl_sss_se05x_types.h fsl_sss_sscp.h fsl_sss_sscp_config.h fsl_sss_user_apis.h fsl_sss_user_types.h fsl_sss_util_asn1_der.h fsl_sss_util_rsa_sign_utils.h
  group se_hostlib/sss/src
    ../../../../../middleware/se_hostlib/sss/src/: fsl_sss_apis.c fsl_sss_util_asn1_der.c fsl_sss_util_rsa_sign_utils.c
  group se_hostlib/sss/src/se05x
    ../../../../../middleware/se_hostlib/sss/src/se05x/: fsl_sss_se05x_apis.c fsl_sss_se05x_eckey.c fsl_sss_se05x_mw.c fsl_sss_se05x_policy.c fsl_sss_se05x_scp03.c
  group se_hostlib/hostlib/hostLib/platform/inc
    ../../../../../middleware/se_hostlib/hostlib/hostLib/platform/inc/: ax_reset.h i2c_a7.h se05x_apis.h se_pit_config.h se_reset_config.h sm_printf.h sm_timer.h
  group se_hostlib/hostlib/hostLib/platform/ksdk
    ../../../../../middleware/se_hostlib/hostlib/hostLib/platform/ksdk/: ax_reset.c i2c_frdm.c i2c_imxrt.c i2c_lpc54xxx.c i2c_lpc55sxx.c se05x_reset.c timer_kinetis.c timer_kinetis_bm.c timer_kinetis_freertos.c
  group se_hostlib/hostlib/hostLib/libCommon/smCom
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/: apduComm.h sci2c_cfg.h smCom.c smCom.h smComT1oI2C.c smComT1oI2C.h
  group se_hostlib/hostlib/hostLib/libCommon/smCom/T1oI2C
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/T1oI2C/: phEseStatus.h phEseTypes.h phNxpEsePal_i2c.h phNxpEseProto7816_3.h phNxpEse_Api.h phNxpEse_Internal.h phNxpEsePal_i2c.c phNxpEseProto7816_3.c phNxpEse_Api.c
  group se_hostlib/hostlib/hostLib/libCommon/infra
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/infra/: global_platf.c sm_connect.c a71_debug.h app_boot.h app_boot_nfc.h cm_commands.h global_platf.h sm_apdu.h sm_api.h sm_demo_utils.h sm_errors.h sm_types.h sm_apdu.c sm_errors.c sm_printf.c
  group se_hostlib/sss/ex/inc
    ../../../../../middleware/se_hostlib/sss/ex/inc/: ex_a71ch_scp03.h ex_scp03_puf.h ex_sss.h ex_sss_auth.h ex_sss_boot.h ex_sss_main_cc_inc.h ex_sss_main_freeRTOS_inc.h ex_sss_main_inc.h ex_sss_main_inc_frdmk64f.h ex_sss_main_inc_imx_rt.h ex_sss_main_inc_ksdk.h ex_sss_main_inc_linux.h ex_sss_main_inc_lpcxpresso55s.h ex_sss_main_inc_qn9090.h ex_sss_objid.h ex_sss_ports.h ex_sss_scp03_keys.h ex_sss_tp_scp03_keys.h
  group se_hostlib/sss/ex/src
    ../../../../../middleware/se_hostlib/sss/ex/src/: ex_sss_boot.c ex_sss_boot_connectstring.c ex_sss_boot_int.h ex_sss_se05x.c ex_sss_se05x_auth.c
  group se_hostlib/hostlib/hostLib/se05x_03_xx_xx
    ../../../../../middleware/se_hostlib/hostlib/hostLib/se05x_03_xx_xx/: se05x_APDU.c se05x_APDU.h se05x_APDU_apis.h se05x_APDU_impl.h se05x_04_xx_APDU_apis.h se05x_04_xx_APDU_impl.h
  group se_hostlib/hostlib/hostLib/libCommon/nxScp
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/nxScp/: nxScp03_Com.c
  group se_hostlib/hostlib/hostLib/libCommon/scp
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/scp/: scp.c
  group se_hostlib/hostlib/hostLib/libCommon/log
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/log/: nxLog.c nxLog.h nxLog_App.h nxLog_DefaultConfig.h nxLog_UseCases.h nxLog_VCOM.h nxLog_hostLib.h nxLog_mbedtls.h nxLog_scp.h nxLog_smCom.h nxLog_sscp.h nxLog_sss.h
  group se_hostlib/hostlib/hostLib/mbedtls/inc
    ../../../../../middleware/se_hostlib/hostlib/hostLib/mbedtls/inc/: ax_mbedtls.h
  group se_hostlib/hostlib/hostLib/mbedtls/src
    ../../../../../middleware/se_hostlib/hostlib/hostLib/mbedtls/src/: ecdh_alt.c rsa_alt.c
  group se_hostlib/sss/src/mbedtls
    ../../../../../middleware/se_hostlib/sss/src/mbedtls/: fsl_sss_mbedtls_apis.c
target se05x_vcom flexspi_nor_release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: se05x_vcom.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1062DVL6A, BOARD_USE_VIRTUALCOM=1, IMX_RT, USB_STACK_BM, SDK_DEBUGCONSOLE_UART, MBEDTLS_CONFIG_FILE='\"ksdk_mbedtls_config.h\"', MBEDTLS_USER_CONFIG_FILE='\"sss_ksdk_mbedtls_config.h\"', USB_ISR_REDIRECT, PRINTF_ADVANCED_ENABLE=1, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, USB_DEVICE_CONFIG_CDC_ACM=1, MBEDTLS, SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC, SERIAL_PORT_TYPE_UART=1, T1oI2C, T1oI2C_UM11225, SSS_USE_FTR_FILE, NO_SECURE_CHANNEL_SUPPORT, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: as above
