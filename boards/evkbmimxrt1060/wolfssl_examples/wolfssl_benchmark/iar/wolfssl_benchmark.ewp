# IAR project wolfssl_benchmark.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1062DVL6A; WOLFSSL_IMXRT_DCP; DCP_USE_DCACHE=0; WOLFSSL_USER_SETTINGS; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pe111,Pe177,Pe188
  ICCARM.IExtraOptions: --diag_suppress Pa084  --diag_suppress Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../devices/MIMXRT1062/drivers; ../../../../../middleware/wolfssl; ../../../../../devices/MIMXRT1062; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../devices/MIMXRT1062/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../devices/MIMXRT1062/xip; ../../../xip; ../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: wolfssl_benchmark.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x8000
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1062DVL6A; WOLFSSL_IMXRT_DCP; DCP_USE_DCACHE=0; WOLFSSL_USER_SETTINGS; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: main-bench.c user_settings.h common.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_dcp.c fsl_dcp.h fsl_trng.c fsl_trng.h fsl_cache.c fsl_cache.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group wolfssl
    ../../../../../middleware/wolfssl/: ChangeLog.md ChangeLogKSDK.txt README.md README LA_OPT_EVAL_DEMO_ONLY.htm
  group wolfssl/wolfcrypt/src
    ../../../../../middleware/wolfssl/wolfcrypt/src/: wc_port.c wc_encrypt.c random.c logging.c sp_int.c sp_cortexm.c ecc.c rsa.c aes.c asn.c sha.c sha256.c sha512.c sha3.c chacha.c md5.c hmac.c coding.c ge_low_mem.c hash.c pwdbased.c wolfmath.c misc.c ed25519.c fe_operations.c fe_low_mem.c
  group wolfssl/wolfcrypt/src/port/nxp
    ../../../../../middleware/wolfssl/wolfcrypt/src/port/nxp/: dcp_port.c
  group wolfssl/wolfcrypt/benchmark
    ../../../../../middleware/wolfssl/wolfcrypt/benchmark/: benchmark.h benchmark.c
  group wolfssl/wolfcrypt/test
    ../../../../../middleware/wolfssl/wolfcrypt/test/: test.h test.c
  group wolfssl/wolfssl
    ../../../../../middleware/wolfssl/wolfssl/: version.h certs_test.h
  group wolfssl/wolfssl/wolfcrypt
    ../../../../../middleware/wolfssl/wolfssl/wolfcrypt/: wc_port.h wc_encrypt.h random.h logging.h sp_int.h ecc.h rsa.h aes.h asn.h sha.h sha256.h sha512.h sha3.h chacha.h ed25519.h md5.h md2.h hmac.h coding.h hash.h pwdbased.h wolfmath.h settings.h visibility.h types.h error-crypt.h memory.h integer.h cpuid.h tfm.h md4.h misc.h asn_public.h ge_operations.h sp.h des3.h fe_operations.h rc2.h cryptocb.h arc4.h signature.h cmac.h poly1305.h camellia.h dh.h dsa.h srp.h idea.h hc128.h rabbit.h chacha20_poly1305.h ripemd.h
  group wolfssl/wolfssl/wolfcrypt/port/nxp
    ../../../../../middleware/wolfssl/wolfssl/wolfcrypt/port/nxp/: dcp_port.h
  group wolfssl/doc
    ../../../../../middleware/wolfssl/doc/: README.txt generate_documentation.sh README_DOXYGEN check_api.sh
  group wolfssl/doc/images
    ../../../../../middleware/wolfssl/doc/images/: wolfssl_logo.png
  group wolfssl/doc/formats/pdf
    ../../../../../middleware/wolfssl/doc/formats/pdf/: header.tex Doxyfile
  group wolfssl/doc/formats/html
    ../../../../../middleware/wolfssl/doc/formats/html/: footer.html Doxyfile mainpage.dox header.html
  group wolfssl/doc/formats/html/html_changes
    ../../../../../middleware/wolfssl/doc/formats/html/html_changes/: customdoxygen.css tabs.css menudata.js doxygen.css menu.js
  group wolfssl/doc/formats/html/html_changes/search
    ../../../../../middleware/wolfssl/doc/formats/html/html_changes/search/: search.js search.css
  group wolfssl/doc/dox_comments/header_files
    ../../../../../middleware/wolfssl/doc/dox_comments/header_files/: doxygen_pages.h ssl.h doxygen_groups.h logging.h types.h wc_encrypt.h signature.h blake2.h eccsi.h pem.h compress.h dh.h srp.h asn.h poly1305.h aes.h wolfio.h chacha.h random.h hmac.h rabbit.h wc_port.h bn.h des3.h sha256.h md5.h ecc.h tfm.h coding.h pkcs7.h pkcs11.h sha.h md4.h chacha20_poly1305.h dsa.h arc4.h sha512.h idea.h ripemd.h curve25519.h memory.h camellia.h error-crypt.h md2.h rsa.h asn_public.h hash.h ed25519.h hc128.h curve448.h evp.h ed448.h sakke.h pwdbased.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkbmimxrt1060_flexspi_nor_config.c evkbmimxrt1060_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
