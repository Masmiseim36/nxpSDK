# IAR project maestro_playback.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; PRINTF_FLOAT_ENABLE=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; OSA_USED; SHELL_TASK_STACK_SIZE=4000; SAI_XFER_QUEUE_SIZE=2; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1176DVMAA_cm7; SERIAL_PORT_TYPE_UART=1; SDK_I2C_BASED_COMPONENT_USED=1; CODEC_MULTI_ADAPTERS=1; CODEC_WM8962_ENABLE; USE_RTOS=1; STREAMER_ENABLE_AUDIO_PROC; SSRC_PROC=1; STREAMER_ENABLE_AUDIO_SINK; STREAMER_ENABLE_FILESRC; STREAMER_ENABLE_MEM_SINK; STREAMER_ENABLE_MEM_SRC; STREAMER_ENABLE_DECODER; MP3_DEC=1; WAV_DEC=1; FLAC_DEC=1; OGG_OPUS_DEC=1; HAVE_CONFIG_H; SD_ENABLED=1; SDK_OS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa050,Pa082,Pe188
  ICCARM.IExtraOptions: --align_sp_on_irq  --macro_positions_in_diagnostics  --header_context  --no_unaligned_access  --diag_suppress=Pa082,Pa050 --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../xip; ../../../../../../devices/MIMXRT1176/xip; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT1176; ../../../../../../devices/MIMXRT1176/periph; ../../../../../../devices/MIMXRT1176/drivers/cm7; ../../../../../../devices/MIMXRT1176/utilities; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1176/utilities/str; ../../../../../../devices/MIMXRT1176/utilities/debug_console; ../../../../../../devices/MIMXRT1176/utilities/shell; ../../../../../../components/serial_manager; ../../../../../../components/codec/i2c; ../../../../../../components/codec; ../../../../../../components/codec/port; ../../../../../../components/codec/port/wm8962; ../../../../../../components/codec/wm8962; ../../../../../../components/gpio; ../../../../../../components/i2c; ../../../../../../components/uart; ../../../../../../components/osa; ../../../../../../middleware/fatfs/source; ../../../../../../middleware/fatfs/template; ../../../../../../middleware/fatfs/source/fsl_sd_disk; ../../../../../../middleware/audio_voice/maestro/src/inc; ../../../../../../middleware/audio_voice/maestro/src/core/inc; ../../../../../../middleware/audio_voice/maestro/src/utils/inc; ../../../../../../middleware/audio_voice/maestro/src/elements; ../../../../../../middleware/audio_voice/maestro/src/devices; ../../../../../../middleware/audio_voice/maestro/components/decoders/mp3; ../../../../../../middleware/audio_voice/maestro/components/decoders/wav; ../../../../../../middleware/audio_voice/maestro/components/decoders/aac; ../../../../../../middleware/audio_voice/maestro/src/cci/inc; ../../../../../../middleware/audio_voice/maestro/src/parsers/cci; ../../../../../../middleware/audio_voice/maestro/src/cei/inc; ../../../../../../middleware/audio_voice/components/decoders/flac; ../../../../../../middleware/audio_voice/components/decoders/mp3; ../../../../../../middleware/audio_voice/components/decoders/wav; ../../../../../../middleware/audio_voice/components/ogg/src; ../../../../../../middleware/audio_voice/components/ogg/include/ogg; ../../../../../../middleware/audio_voice/components/opus/celt; ../../../../../../middleware/audio_voice/components/opus/include; ../../../../../../middleware/audio_voice/components/opus/silk; ../../../../../../middleware/audio_voice/components/opus/silk/fixed; ../../../../../../middleware/audio_voice/components/opus/src; ../../../../../../middleware/audio_voice/components/opusfile/include; ../../../../../../middleware/audio_voice/components/ssrc; ../../../../../../middleware/sdmmc/common; ../../../../../../middleware/sdmmc/osa; ../../../../../../middleware/sdmmc/sd; ../../../../../../middleware/sdmmc/host/usdhc; ../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F; ../../../../../../rtos/freertos/freertos-kernel/template
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT1176DVMAA_cm7; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; OSA_USED
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: maestro_playback.out
  ILINK.IlinkConfigDefines: __use_flash64MB__=1; __stack_size__=0x1000; __heap_size__=0x3000
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../middleware/audio_voice/components/decoders/flac/libs/cm7f/iar/release/libflac.a; ../../../../../../middleware/audio_voice/components/decoders/mp3/libs/cm7f/iar/release/libmp3.a; ../../../../../../middleware/audio_voice/components/decoders/wav/libs/cm7f/iar/release/libwav.a; ../../../../../../middleware/audio_voice/components/ssrc/libs/cm7f/iar/release/libssrc.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; PRINTF_FLOAT_ENABLE=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; OSA_USED; SHELL_TASK_STACK_SIZE=4000; SAI_XFER_QUEUE_SIZE=2; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1176DVMAA_cm7; SERIAL_PORT_TYPE_UART=1; SDK_I2C_BASED_COMPONENT_USED=1; CODEC_MULTI_ADAPTERS=1; CODEC_WM8962_ENABLE; USE_RTOS=1; STREAMER_ENABLE_AUDIO_PROC; SSRC_PROC=1; STREAMER_ENABLE_AUDIO_SINK; STREAMER_ENABLE_FILESRC; STREAMER_ENABLE_MEM_SINK; STREAMER_ENABLE_MEM_SRC; STREAMER_ENABLE_DECODER; MP3_DEC=1; WAV_DEC=1; FLAC_DEC=1; OGG_OPUS_DEC=1; HAVE_CONFIG_H; SD_ENABLED=1; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  group source
    ../: FreeRTOSConfigBoard.h sdmmc_config.c sdmmc_config.h app_definitions.h app.h app_streamer.c cmd.c main.c app_data.h app_streamer.h cmd.h main.h ssrc_proc.c ssrc_proc.h streamer_pcm.c streamer_pcm.h FreeRTOSConfig_Gen.h ffconf_gen.h fsl_debug_console_conf.h fsl_os_abstraction_config.h mcux_config.h
  group source/template
    ../../../../../../middleware/fatfs/template/: ffconf.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group xip
    ../../../../xip/: evkbmimxrt1170_flexspi_nor_config.c evkbmimxrt1170_flexspi_nor_config.h
    ../../../../: dcd.c dcd.h xmcd.c xmcd.h
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_anatop_ai.c fsl_anatop_ai.h fsl_memory.h fsl_dcdc.c fsl_dcdc.h fsl_gpc.c fsl_gpc.h fsl_pgmc.h fsl_pgmc.c fsl_pmu.h fsl_pmu.c fsl_soc_src.c fsl_soc_src.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_gpio.h fsl_gpio.c fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.h fsl_lpuart.c fsl_mu.h fsl_mu.c fsl_sai_edma.h fsl_sai_edma.c fsl_sai.h fsl_sai.c fsl_usdhc.c fsl_usdhc.h
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv7m_cachel1.h armv7m_mpu.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_COMMON.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group device/periph
    ../../../../../../devices/MIMXRT1176/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_ANADIG_LDO_SNVS.h PERI_ANADIG_LDO_SNVS_DIG.h PERI_ANADIG_MISC.h PERI_ANADIG_OSC.h PERI_ANADIG_PLL.h PERI_ANADIG_PMU.h PERI_ANADIG_TEMPSENSOR.h PERI_AOI.h PERI_ASRC.h PERI_AUDIO_PLL.h PERI_CAAM.h PERI_CAN.h PERI_CAN_WRAPPER.h PERI_CCM.h PERI_CCM_OBS.h PERI_CDOG.h PERI_CMP.h PERI_CSI.h PERI_DAC.h PERI_DCDC.h PERI_DCIC.h PERI_DMA.h PERI_DMAMUX.h PERI_DSI_HOST.h PERI_DSI_HOST_APB_PKT_IF.h PERI_DSI_HOST_DPI_INTFC.h PERI_DSI_HOST_NXP_FDSOI28_DPHY_INTFC.h PERI_EMVSIM.h PERI_ENC.h PERI_ENET.h PERI_ENET_QOS.h PERI_ETHERNET_PLL.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC_CPU_MODE_CTRL.h PERI_GPC_SET_POINT_CTRL.h PERI_GPC_STBY_CTRL.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IEE.h PERI_IEE_APC.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_LPSR.h PERI_IOMUXC_LPSR_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_IPS_DOMAIN.h PERI_KEY_MANAGER.h PERI_KPP.h PERI_LCDIF.h PERI_LCDIFV2.h PERI_LMEM.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_MCM.h PERI_MECC.h PERI_MIPI_CSI2RX.h PERI_MMCAU.h PERI_MU.h PERI_OCOTP.h PERI_OSC_RC_400M.h PERI_OTFAD.h PERI_PDM.h PERI_PGMC_BPC.h PERI_PGMC_CPC.h PERI_PGMC_MIF.h PERI_PGMC_PPC.h PERI_PHY_LDO.h PERI_PIT.h PERI_PUF.h PERI_PWM.h PERI_PXP.h PERI_RDC.h PERI_RDC_SEMAPHORE.h PERI_RTWDOG.h PERI_SEMA4.h PERI_SEMC.h PERI_SNVS.h PERI_SPDIF.h PERI_SRAM.h PERI_SRC.h PERI_SSARC_HP.h PERI_SSARC_LP.h PERI_TMPSNS.h PERI_TMR.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_VIDEO_MUX.h PERI_VIDEO_PLL.h PERI_VMBANDGAP.h PERI_WDOG.h PERI_XBARA.h PERI_XBARB.h PERI_XECC.h PERI_XRDC2.h
  group startup/iar
    ../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/: fsl_assert.h fsl_assert.c
    ../../../../../../devices/MIMXRT1176/utilities/shell/: fsl_shell.h fsl_shell.c
  group utilities/str
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console
    ../../../../../../devices/MIMXRT1176/utilities/debug_console/: fsl_debug_console.h fsl_debug_console.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/gpio
    ../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group component/i2c
    ../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c
  group codec
    ../../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
    ../../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../../components/codec/wm8962/: fsl_wm8962.h fsl_wm8962.c
  group codec/port
    ../../../../../../components/codec/port/: fsl_codec_adapter.c fsl_codec_adapter.h
  group codec/port/wm8962
    ../../../../../../components/codec/port/wm8962/: fsl_codec_wm8962_adapter.h fsl_codec_wm8962_adapter.c
  group fatfs/source
    ../../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_sd_disk
    ../../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group maestro/src/inc
    ../../../../../../middleware/audio_voice/maestro/src/inc/: audio_cfg.h error.h streamer_api.h streamer_element_properties.h streamer_message.h types.h
  group maestro/src/core/inc
    ../../../../../../middleware/audio_voice/maestro/src/core/inc/: pad.h pipeline.h streamer.h streamer_element.h
  group maestro/src/core/src
    ../../../../../../middleware/audio_voice/maestro/src/core/src/: pad.c pipeline.c streamer.c streamer_element.c streamer_msg.c
  group maestro/src/utils/inc
    ../../../../../../middleware/audio_voice/maestro/src/utils/inc/: general_utils.h maestro_logging.h file_utils.h
  group maestro/src/utils/src
    ../../../../../../middleware/audio_voice/maestro/src/utils/src/: general_utils.c maestro_logging.c file_utils.c
  group maestro/src/elements
    ../../../../../../middleware/audio_voice/maestro/src/elements/: audio_proc.c audio_proc.h audio_sink.c audio_sink.h file_src.c file_src.h mem_sink.c mem_sink.h mem_src.c mem_src.h decoder.c decoder.h decoder_pads.c decoder_pads.h
  group maestro/src/devices
    ../../../../../../middleware/audio_voice/maestro/src/devices/: audio_sink_default.c audio_sink_default.h
  group maestro/src/cci/inc
    ../../../../../../middleware/audio_voice/maestro/src/cci/inc/: cci_metadata.h ccidec.h codec_interface.h codec_interface_public_api.h errordefs.h
  group maestro/src/cci/src
    ../../../../../../middleware/audio_voice/maestro/src/cci/src/: ccidec.c codec_interface.c codecextractmetadata.c
  group maestro/src/parsers/cci
    ../../../../../../middleware/audio_voice/maestro/src/parsers/cci/: cci_codec_type_conversion.c
  group maestro/src/cei/inc
    ../../../../../../middleware/audio_voice/maestro/src/cei/inc/: cei.h cei_enctypes.h cei_table.h
  group maestro/components/decoders/mp3
    ../../../../../../middleware/audio_voice/maestro/components/decoders/mp3/: mp3_id3v2.h mp3_id3v2_internal.h mp3_metadata.h mp3_extractmetadata.c mp3_id3v2.c mp3_vbr.c
  group maestro/components/decoders/wav
    ../../../../../../middleware/audio_voice/maestro/components/decoders/wav/: wav_metadata.h wavedata.h wavedefs.h adpcm_extractmetadata.c wav_common.c
  group maestro/components/decoders/flac
    ../../../../../../middleware/audio_voice/maestro/components/decoders/flac/: flac_extractmetadata.c
  group maestro/components/decoders/opus
    ../../../../../../middleware/audio_voice/maestro/components/decoders/opus/: opus_extractmetadata.c
  group components/decoders/flac
    ../../../../../../middleware/audio_voice/components/decoders/flac/: flac_cci.h
  group components/decoders/mp3
    ../../../../../../middleware/audio_voice/components/decoders/mp3/: mp3_cci.h
  group components/decoders/wav
    ../../../../../../middleware/audio_voice/components/decoders/wav/: wav_cci.h
  group components/ogg/include/ogg
    ../../../../../../middleware/audio_voice/components/ogg/include/ogg/: memory.h ogg.h os_types.h
  group components/ogg/src
    ../../../../../../middleware/audio_voice/components/ogg/src/: framing.c memory.c crctable.h
  group components/opus/celt
    ../../../../../../middleware/audio_voice/components/opus/celt/: bands.c celt.c celt_decoder.c celt_encoder.c celt_lpc.c cwrs.c entcode.c entdec.c entenc.c kiss_fft.c laplace.c mathops.c mdct.c modes.c pitch.c quant_bands.c rate.c vq.c _kiss_fft_guts.h arch.h bands.h celt.h celt_lpc.h cpu_support.h cwrs.h ecintrin.h entcode.h entdec.h entenc.h fixed_c5x.h fixed_c6x.h fixed_debug.h fixed_generic.h float_cast.h kiss_fft.h laplace.h mathops.h mdct.h mfrngcod.h modes.h os_support.h pitch.h quant_bands.h rate.h stack_alloc.h static_modes_fixed.h static_modes_float.h vq.h
  group components/opus/include
    ../../../../../../middleware/audio_voice/components/opus/include/: config.h opus.h opus_cci.h opus_cci_raw.h opus_custom.h opus_defines.h opus_multistream.h opus_projection.h opus_types.h test_opus_common.h
  group components/opus/silk
    ../../../../../../middleware/audio_voice/components/opus/silk/: A2NLSF.c CNG.c HP_variable_cutoff.c LPC_analysis_filter.c LPC_fit.c LPC_inv_pred_gain.c LP_variable_cutoff.c NLSF2A.c NLSF_VQ.c NLSF_VQ_weights_laroia.c NLSF_decode.c NLSF_del_dec_quant.c NLSF_encode.c NLSF_stabilize.c NLSF_unpack.c NSQ.c NSQ_del_dec.c PLC.c VAD.c VQ_WMat_EC.c ana_filt_bank_1.c biquad_alt.c bwexpander.c bwexpander_32.c check_control_input.c code_signs.c control_SNR.c control_audio_bandwidth.c control_codec.c debug.c dec_API.c decode_core.c decode_frame.c decode_indices.c decode_parameters.c decode_pitch.c decode_pulses.c decoder_set_fs.c enc_API.c encode_indices.c encode_pulses.c gain_quant.c init_decoder.c init_encoder.c inner_prod_aligned.c interpolate.c lin2log.c log2lin.c pitch_est_tables.c process_NLSFs.c quant_LTP_gains.c resampler.c resampler_down2.c resampler_down2_3.c resampler_private_AR2.c resampler_private_IIR_FIR.c resampler_private_down_FIR.c resampler_private_up2_HQ.c resampler_rom.c shell_coder.c sigm_Q15.c sort.c stereo_LR_to_MS.c stereo_MS_to_LR.c stereo_decode_pred.c stereo_encode_pred.c stereo_find_predictor.c stereo_quant_pred.c sum_sqr_shift.c table_LSF_cos.c tables_LTP.c tables_NLSF_CB_NB_MB.c tables_NLSF_CB_WB.c tables_gain.c tables_other.c tables_pitch_lag.c tables_pulses_per_block.c API.h Inlines.h MacroCount.h MacroDebug.h NSQ.h PLC.h SigProc_FIX.h control.h debug.h define.h errors.h macros.h main.h pitch_est_defines.h resampler_private.h resampler_rom.h resampler_structs.h structs.h tables.h tuning_parameters.h typedef.h
  group components/opus/silk/fixed
    ../../../../../../middleware/audio_voice/components/opus/silk/fixed/: LTP_analysis_filter_FIX.c LTP_scale_ctrl_FIX.c apply_sine_window_FIX.c autocorr_FIX.c burg_modified_FIX.c corrMatrix_FIX.c encode_frame_FIX.c find_LPC_FIX.c find_LTP_FIX.c find_pitch_lags_FIX.c find_pred_coefs_FIX.c k2a_FIX.c k2a_Q16_FIX.c noise_shape_analysis_FIX.c pitch_analysis_core_FIX.c process_gains_FIX.c regularize_correlations_FIX.c residual_energy16_FIX.c residual_energy_FIX.c schur64_FIX.c schur_FIX.c vector_ops_FIX.c warped_autocorrelation_FIX.c main_FIX.h structs_FIX.h
  group components/opus/src
    ../../../../../../middleware/audio_voice/components/opus/src/: opus.c opus_cci.c opus_cci_raw.c opus_decoder.c opus_encoder.c opus_multistream.c opus_multistream_decoder.c opus_multistream_encoder.c repacketizer.c analysis.h mlp.h opus_private.h
  group components/opusfile/include
    ../../../../../../middleware/audio_voice/components/opusfile/include/: internal.h opusfile.h
  group components/opusfile/src
    ../../../../../../middleware/audio_voice/components/opusfile/src/: info.c internal.c opusfile.c stream.c
  group components/ssrc
    ../../../../../../middleware/audio_voice/components/ssrc/: SSRC.h LVC_Types.h
  group sdmmc/common
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h fsl_sdmmc_common.c
  group sdmmc/osa
    ../../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group sdmmc/sd
    ../../../../../../middleware/sdmmc/sd/: fsl_sd.c fsl_sd.h
  group sdmmc/host/usdhc
    ../../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h fsl_sdmmc_host.h
  group sdmmc/host/usdhc/non_blocking
    ../../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable/IAR/ARM_CM4F
    ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos-kernel/template
    ../../../../../../rtos/freertos/freertos-kernel/template/: FreeRTOSConfig.h
  group doc
    ../: readme.md example_board_readme.md
