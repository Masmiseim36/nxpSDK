# Keil uVision project usbx_host_hid_mouse.uvprojx, settings and files
target usbx_host_hid_mouse debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: usbx_host_hid_mouse.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, __CLANG_ARM, CPU_MIMXRT1176DVMAA_cm7, MIMXRT, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK, UX_OTG_SUPPORT, UX_INCLUDE_USER_DEFINE_FILE, NX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE, FSL_RTOS_THREADX
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../components/osa;../../../../../../middleware/usb/phy;../../../../../../rtos/azure-rtos/usbx/common/usbx_host_controllers/inc;../../../../../../components/lists;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../devices/MIMXRT1176/drivers;../../../../../../devices/MIMXRT1176;../../../../../../devices/MIMXRT1176/drivers/cm7;../../../../xip;../../../../../../devices/MIMXRT1176/xip;../../../../../../devices/MIMXRT1176/utilities;../../../../../../devices/MIMXRT1176/utilities/str;../../../../../../devices/MIMXRT1176/utilities/debug_console;../../../../../../rtos/azure-rtos/usbx/common/core/inc;../../../../../../rtos/azure-rtos/usbx/common/usbx_device_classes/inc;../../../../../../rtos/azure-rtos/usbx/common/usbx_host_classes/inc;../../../../../../rtos/azure-rtos/usbx/common/usbx_network/inc;../../../../../../rtos/azure-rtos/usbx/common/usbx_pictbridge/inc;../../../../../../rtos/azure-rtos/usbx/ports/cortex_m7/ac6/inc;../../../../../../rtos/azure-rtos/netxduo/addons/auto_ip;../../../../../../rtos/azure-rtos/netxduo/addons/cloud;../../../../../../rtos/azure-rtos/netxduo/addons/BSD;../../../../../../rtos/azure-rtos/netxduo/addons/dhcp;../../../../../../rtos/azure-rtos/netxduo/addons/dns;../../../../../../rtos/azure-rtos/netxduo/addons/ftp;../../../../../../rtos/azure-rtos/netxduo/addons/http;../../../../../../rtos/azure-rtos/netxduo/addons/lwm2m;../../../../../../rtos/azure-rtos/netxduo/addons/mdns;../../../../../../rtos/azure-rtos/netxduo/addons/mqtt;../../../../../../rtos/azure-rtos/netxduo/addons/nat;../../../../../../rtos/azure-rtos/netxduo/addons/pop3;../../../../../../rtos/azure-rtos/netxduo/addons/ppp;../../../../../../rtos/azure-rtos/netxduo/addons/pppoe;../../../../../../rtos/azure-rtos/netxduo/addons/ptp;../../../../../../rtos/azure-rtos/netxduo/addons/smtp;../../../../../../rtos/azure-rtos/netxduo/addons/snmp;../../../../../../rtos/azure-rtos/netxduo/addons/sntp;../../../../../../rtos/azure-rtos/netxduo/addons/telnet;../../../../../../rtos/azure-rtos/netxduo/addons/tftp;../../../../../../rtos/azure-rtos/netxduo/addons/web;../../../../../../rtos/azure-rtos/netxduo/addons/websocket;../../../../../../rtos/azure-rtos/netxduo/common/inc;../../../../../../rtos/azure-rtos/netxduo/crypto_libraries/inc;../../../../../../rtos/azure-rtos/netxduo/nx_secure/inc;../../../../../../rtos/azure-rtos/netxduo/nx_secure/ports;../../../../../../rtos/azure-rtos/netxduo/ports/cortex_m7/ac6/inc;../../../../../../rtos/azure-rtos/filex/common/inc;../../../../../../rtos/azure-rtos/filex/ports/generic/inc;../../../../../../rtos/azure-rtos/threadx/common/inc;../../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc;../../../../../../middleware/usb/include;../../../../../../CMSIS/Core/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_ram.scf
  link misc: ../../../../../../rtos/azure-rtos/binary/usbx/cortex_m7/mdk/libusbx.lib ../../../../../../rtos/azure-rtos/binary/netxduo/cortex_m7/mdk/libnetxduo.lib ../../../../../../rtos/azure-rtos/binary/filex/cortex_m7/mdk/libfilex.lib ../../../../../../rtos/azure-rtos/binary/threadx/cortex_m7/mdk/libthreadx.lib --remove --entry=Reset_Handler --diag_suppress 6314
  group board
    ../: pin_mux.c pin_mux.h board_setup.c board_setup.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group source
    ../: usbx_host_hid_mouse.c
  group azure-rtos/config
    ../: tx_user.h fx_user.h nx_user.h ux_user.h
  group ports
    ../: ux_hcd_interrupt_handler.c
  group doc
    ../: readme.md
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction_threadx.c fsl_os_abstraction_threadx.h fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction.h fsl_os_abstraction_config.h
  group usb/phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group azure-rtos/usbx/common/usbx_host_controllers/inc
    ../../../../../../rtos/azure-rtos/usbx/common/usbx_host_controllers/inc/: ux_hcd_ehci.h
  group azure-rtos/usbx/common/usbx_host_controllers/src
    ../../../../../../rtos/azure-rtos/usbx/common/usbx_host_controllers/src/: ux_hcd_ehci_asynchronous_endpoint_create.c ux_hcd_ehci_asynchronous_endpoint_destroy.c ux_hcd_ehci_asynch_td_process.c ux_hcd_ehci_controller_disable.c ux_hcd_ehci_done_queue_process.c ux_hcd_ehci_door_bell_wait.c ux_hcd_ehci_ed_clean.c ux_hcd_ehci_ed_obtain.c ux_hcd_ehci_endpoint_reset.c ux_hcd_ehci_entry.c ux_hcd_ehci_frame_number_get.c ux_hcd_ehci_frame_number_set.c ux_hcd_ehci_fsisochronous_td_obtain.c ux_hcd_ehci_fsisochronous_tds_process.c ux_hcd_ehci_hsisochronous_td_obtain.c ux_hcd_ehci_hsisochronous_tds_process.c ux_hcd_ehci_initialize.c ux_hcd_ehci_interrupt_endpoint_create.c ux_hcd_ehci_interrupt_endpoint_destroy.c ux_hcd_ehci_interrupt_handler.c ux_hcd_ehci_isochronous_endpoint_create.c ux_hcd_ehci_isochronous_endpoint_destroy.c ux_hcd_ehci_least_traffic_list_get.c ux_hcd_ehci_next_td_clean.c ux_hcd_ehci_periodic_descriptor_link.c ux_hcd_ehci_periodic_tree_create.c ux_hcd_ehci_poll_rate_entry_get.c ux_hcd_ehci_port_disable.c ux_hcd_ehci_port_reset.c ux_hcd_ehci_port_resume.c ux_hcd_ehci_port_status_get.c ux_hcd_ehci_port_suspend.c ux_hcd_ehci_power_down_port.c ux_hcd_ehci_power_on_port.c ux_hcd_ehci_power_root_hubs.c ux_hcd_ehci_register_read.c ux_hcd_ehci_register_write.c ux_hcd_ehci_regular_td_obtain.c ux_hcd_ehci_request_bulk_transfer.c ux_hcd_ehci_request_control_transfer.c ux_hcd_ehci_request_interrupt_transfer.c ux_hcd_ehci_request_isochronous_transfer.c ux_hcd_ehci_request_transfer_add.c ux_hcd_ehci_request_transfer.c ux_hcd_ehci_transfer_abort.c ux_hcd_ehci_transfer_request_process.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_dcdc.h fsl_dcdc.c fsl_gpio.h fsl_gpio.c fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_pmu.h fsl_pmu.c fsl_memory.h fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group startup
    ../../../../../../devices/MIMXRT1176/arm/: startup_MIMXRT1176_cm7.S
  group xip
    ../../../../xip/: evkbmimxrt1170_flexspi_nor_config.c evkbmimxrt1170_flexspi_nor_config.h
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1176/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group azure-rtos/usbx
    ../../../../../../rtos/azure-rtos/usbx/: LICENSE.txt LICENSED-HARDWARE.txt
  group azure-rtos/usbx/common/core/inc
    ../../../../../../rtos/azure-rtos/usbx/common/core/inc/: ux_api.h ux_class_audio10.h ux_class_audio20.h ux_dcd_sim_slave.h ux_device_class_dpump.h ux_device_stack.h ux_hcd_sim_host.h ux_host_class_dpump.h ux_host_stack.h ux_system.h ux_user_sample.h ux_utility.h
  group azure-rtos/usbx/common/usbx_device_classes/inc
    ../../../../../../rtos/azure-rtos/usbx/common/usbx_device_classes/inc/: ux_device_class_audio.h ux_device_class_audio10.h ux_device_class_audio20.h ux_device_class_ccid.h ux_device_class_cdc_acm.h ux_device_class_cdc_ecm.h ux_device_class_dfu.h ux_device_class_hid.h ux_device_class_pima.h ux_device_class_printer.h ux_device_class_rndis.h ux_device_class_storage.h ux_device_class_video.h
  group azure-rtos/usbx/common/usbx_host_classes/inc
    ../../../../../../rtos/azure-rtos/usbx/common/usbx_host_classes/inc/: ux_host_class_asix.h ux_host_class_audio.h ux_host_class_cdc_acm.h ux_host_class_cdc_ecm.h ux_host_class_gser.h ux_host_class_hid.h ux_host_class_hid_keyboard.h ux_host_class_hid_mouse.h ux_host_class_hid_remote_control.h ux_host_class_hub.h ux_host_class_pima.h ux_host_class_printer.h ux_host_class_prolific.h ux_host_class_storage.h ux_host_class_swar.h ux_host_class_video.h
  group azure-rtos/usbx/common/usbx_network/inc
    ../../../../../../rtos/azure-rtos/usbx/common/usbx_network/inc/: ux_network_driver.h
  group azure-rtos/usbx/common/usbx_pictbridge/inc
    ../../../../../../rtos/azure-rtos/usbx/common/usbx_pictbridge/inc/: ux_pictbridge.h
  group azure-rtos/usbx/ports/cortex_m7/ac6/inc
    ../../../../../../rtos/azure-rtos/usbx/ports/cortex_m7/ac6/inc/: ux_port.h
  group azure-rtos/usbx/support/windows_host_files
    ../../../../../../rtos/azure-rtos/usbx/support/windows_host_files/: CDC_ACM_Template.inf CDC_ACM_Template_Win7_64bit.inf CDC_Composite_Template.inf RNDIS_Template.inf
  group azure-rtos/netxduo/addons/auto_ip
    ../../../../../../rtos/azure-rtos/netxduo/addons/auto_ip/: nx_auto_ip.c nx_auto_ip.h
  group azure-rtos/netxduo/addons/cloud
    ../../../../../../rtos/azure-rtos/netxduo/addons/cloud/: nx_cloud.c nx_cloud.h
  group azure-rtos/netxduo/addons/dhcp
    ../../../../../../rtos/azure-rtos/netxduo/addons/dhcp/: nxd_dhcp_client.c nxd_dhcp_client.h nxd_dhcp_server.c nxd_dhcp_server.h nxd_dhcpv6_client.c nxd_dhcpv6_client.h nxd_dhcpv6_server.c nxd_dhcpv6_server.h
  group azure-rtos/netxduo/addons/dns
    ../../../../../../rtos/azure-rtos/netxduo/addons/dns/: nxd_dns.c nxd_dns.h
  group azure-rtos/netxduo/addons/ftp
    ../../../../../../rtos/azure-rtos/netxduo/addons/ftp/: nxd_ftp_client.c nxd_ftp_client.h nxd_ftp_server.c nxd_ftp_server.h
  group azure-rtos/netxduo/addons/http
    ../../../../../../rtos/azure-rtos/netxduo/addons/http/: nxd_http_client.c nxd_http_client.h nxd_http_server.c nxd_http_server.h
  group azure-rtos/netxduo/addons/lwm2m
    ../../../../../../rtos/azure-rtos/netxduo/addons/lwm2m/: nx_lwm2m_client.c nx_lwm2m_client.h
  group azure-rtos/netxduo/addons/mdns
    ../../../../../../rtos/azure-rtos/netxduo/addons/mdns/: nxd_mdns.c nxd_mdns.h
  group azure-rtos/netxduo/addons/mqtt
    ../../../../../../rtos/azure-rtos/netxduo/addons/mqtt/: nxd_mqtt_client.c nxd_mqtt_client.h
  group azure-rtos/netxduo/addons/nat
    ../../../../../../rtos/azure-rtos/netxduo/addons/nat/: nx_nat.c nx_nat.h
  group azure-rtos/netxduo/addons/pop3
    ../../../../../../rtos/azure-rtos/netxduo/addons/pop3/: nxd_pop3_client.c nxd_pop3_client.h
  group azure-rtos/netxduo/addons/ppp
    ../../../../../../rtos/azure-rtos/netxduo/addons/ppp/: nx_ppp.c nx_ppp.h
  group azure-rtos/netxduo/addons/pppoe
    ../../../../../../rtos/azure-rtos/netxduo/addons/pppoe/: nx_pppoe_client.c nx_pppoe_client.h nx_pppoe_server.c nx_pppoe_server.h
  group azure-rtos/netxduo/addons/ptp
    ../../../../../../rtos/azure-rtos/netxduo/addons/ptp/: nxd_ptp_client.c nxd_ptp_client.h
  group azure-rtos/netxduo/addons/smtp
    ../../../../../../rtos/azure-rtos/netxduo/addons/smtp/: nxd_smtp_client.c nxd_smtp_client.h
  group azure-rtos/netxduo/addons/snmp
    ../../../../../../rtos/azure-rtos/netxduo/addons/snmp/: nx_des.c nx_des.h nx_sha1.c nx_sha1.h nxd_snmp.c nxd_snmp.h
  group azure-rtos/netxduo/addons/sntp
    ../../../../../../rtos/azure-rtos/netxduo/addons/sntp/: nxd_sntp_client.c nxd_sntp_client.h
  group azure-rtos/netxduo/addons/telnet
    ../../../../../../rtos/azure-rtos/netxduo/addons/telnet/: nxd_telnet_client.c nxd_telnet_client.h nxd_telnet_server.c nxd_telnet_server.h
  group azure-rtos/netxduo/addons/tftp
    ../../../../../../rtos/azure-rtos/netxduo/addons/tftp/: nxd_tftp_client.c nxd_tftp_client.h nxd_tftp_server.c nxd_tftp_server.h
  group azure-rtos/netxduo/addons/web
    ../../../../../../rtos/azure-rtos/netxduo/addons/web/: nx_tcpserver.c nx_tcpserver.h nx_web_http_client.c nx_web_http_client.h nx_web_http_common.h nx_web_http_server.c nx_web_http_server.h
  group azure-rtos/netxduo/addons/websocket
    ../../../../../../rtos/azure-rtos/netxduo/addons/websocket/: nx_websocket_client.c nx_websocket_client.h
  group azure-rtos/netxduo/common/inc
    ../../../../../../rtos/azure-rtos/netxduo/common/inc/: nx_api.h nx_arp.h nx_http_proxy_client.h nx_icmp.h nx_icmpv4.h nx_icmpv6.h nx_igmp.h nx_ip.h nx_ipv4.h nx_ipv6.h nx_md5.h nx_mld.h nx_nd_cache.h nx_packet.h nx_rarp.h nx_system.h nx_tcp.h nx_udp.h nx_user_sample.h
  group azure-rtos/netxduo/crypto_libraries/inc
    ../../../../../../rtos/azure-rtos/netxduo/crypto_libraries/inc/: nx_crypto.h nx_crypto_3des.h nx_crypto_aes.h nx_crypto_cbc.h nx_crypto_ccm.h nx_crypto_const.h nx_crypto_ctr.h nx_crypto_des.h nx_crypto_dh.h nx_crypto_drbg.h nx_crypto_ec.h nx_crypto_ecdh.h nx_crypto_ecdsa.h nx_crypto_ecjpake.h nx_crypto_gcm.h nx_crypto_hkdf.h nx_crypto_hmac.h nx_crypto_hmac_md5.h nx_crypto_hmac_sha1.h nx_crypto_hmac_sha2.h nx_crypto_hmac_sha5.h nx_crypto_huge_number.h nx_crypto_md5.h nx_crypto_method_self_test.h nx_crypto_null.h nx_crypto_phash.h nx_crypto_pkcs1_v1.5.h nx_crypto_rsa.h nx_crypto_sha1.h nx_crypto_sha2.h nx_crypto_sha5.h nx_crypto_tls_prf_1.h nx_crypto_tls_prf_sha256.h nx_crypto_tls_prf_sha384.h nx_crypto_tls_prf_sha512.h nx_crypto_xcbc_mac.h
  group azure-rtos/netxduo/nx_secure/inc
    ../../../../../../rtos/azure-rtos/netxduo/nx_secure/inc/: nx_secure_crypto_table_self_test.h nx_secure_dtls.h nx_secure_dtls_api.h nx_secure_tls.h nx_secure_tls_api.h nx_secure_user_sample.h nx_secure_x509.h
  group azure-rtos/netxduo/nx_secure/ports
    ../../../../../../rtos/azure-rtos/netxduo/nx_secure/ports/: nx_secure_port.h
  group azure-rtos/netxduo/ports/cortex_m7/ac6/inc
    ../../../../../../rtos/azure-rtos/netxduo/ports/cortex_m7/ac6/inc/: nx_port.h
  group azure-rtos/filex/common/inc
    ../../../../../../rtos/azure-rtos/filex/common/inc/: fx_api.h fx_directory.h fx_directory_exFAT.h fx_fault_tolerant.h fx_file.h fx_media.h fx_system.h fx_unicode.h fx_user_sample.h fx_utility.h
  group azure-rtos/filex/ports/generic/inc
    ../../../../../../rtos/azure-rtos/filex/ports/generic/inc/: fx_port.h
  group azure-rtos/threadx/common/inc
    ../../../../../../rtos/azure-rtos/threadx/common/inc/: tx_api.h tx_block_pool.h tx_byte_pool.h tx_event_flags.h tx_initialize.h tx_mutex.h tx_queue.h tx_semaphore.h tx_thread.h tx_timer.h tx_trace.h tx_user_sample.h
  group azure-rtos/threadx/ports/common
    ../../../../../../rtos/azure-rtos/threadx/ports/common/: tx_initialize_low_level.c
  group azure-rtos/threadx/ports/cortex_m7/ac6/inc
    ../../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc/: tx_port.h
  group azure-rtos/threadx/ports/cortex_m7/ac6/src
    ../../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/src/: tx_thread_context_restore.S tx_thread_context_save.S tx_thread_interrupt_control.S tx_thread_interrupt_disable.S tx_thread_interrupt_restore.S tx_thread_schedule.S tx_thread_stack_build.S tx_thread_system_return.S tx_timer_interrupt.S
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
target usbx_host_hid_mouse flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: usbx_host_hid_mouse.out
  AfterMake: fromelf.exe --output "$Lusbx_host_hid_mouse.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, __CLANG_ARM, CPU_MIMXRT1176DVMAA_cm7, MIMXRT, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK, UX_OTG_SUPPORT, UX_INCLUDE_USER_DEFINE_FILE, NX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE, FSL_RTOS_THREADX
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor.scf
  link misc: ../../../../../../rtos/azure-rtos/binary/usbx/cortex_m7/mdk/libusbx.lib ../../../../../../rtos/azure-rtos/binary/netxduo/cortex_m7/mdk/libnetxduo.lib ../../../../../../rtos/azure-rtos/binary/filex/cortex_m7/mdk/libfilex.lib ../../../../../../rtos/azure-rtos/binary/threadx/cortex_m7/mdk/libthreadx.lib --remove --legacyalign --entry=Reset_Handler --diag_suppress 6314 --predefine="-D__use_flash64MB__=1" --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
target usbx_host_hid_mouse release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: usbx_host_hid_mouse.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, __CLANG_ARM, CPU_MIMXRT1176DVMAA_cm7, MIMXRT, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK, UX_OTG_SUPPORT, UX_INCLUDE_USER_DEFINE_FILE, NX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE, FSL_RTOS_THREADX
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_ram.scf
  link misc: as above
target usbx_host_hid_mouse flexspi_nor_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: usbx_host_hid_mouse.out
  AfterMake: as above
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, __CLANG_ARM, CPU_MIMXRT1176DVMAA_cm7, MIMXRT, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK, UX_OTG_SUPPORT, UX_INCLUDE_USER_DEFINE_FILE, NX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE, FSL_RTOS_THREADX
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor.scf
  link misc: as above
