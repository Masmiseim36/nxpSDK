# IAR project crank_storyboard_helloworld.ewp, settings and files
configuration flexspi_nor_sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=0; XIP_BOOT_HEADER_XMCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; SKIP_SYSCLK_INIT; FLEXRAM_CFG_ENABLE=1; GRE_TARGET_OS_freertos; GRE_TARGET_CPU_cortexm7; GRE_FEATURE_VFS_RESOURCES; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; CUSTOM_VGLITE_MEMORY_CONFIG=1; SDK_OS_FREE_RTOS; VG_COMMAND_CALL=1; VG_TARGET_FAST_CLEAR=0
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../cm7; ../../..; ..; ../../../../../devices/MIMXRT1176/drivers; ../../../../../components/ft5406_rt; ../../../../../components/video; ../../../../../components/video/display; ../../../../../components/video/display/rm68191; ../../../../../components/video/display/mipi_dsi_cmd; ../../../../../components/video/display/rm68200; ../../../../../components/video/display/dc/lcdifv2; ../../../../../components/gt911; ../../../../../components/video/display/dc/elcdif; ../../../../../devices/MIMXRT1176/utilities/str; ../../../../../devices/MIMXRT1176/utilities/debug_console_lite; ../../../../../components/video/display/fbdev; ../../../../../components/video/display/hx8394; ../../../../../middleware/Crank_Software/cortexM-vglite/include/freertos; ../../../../../middleware/Crank_Software/cortexM-vglite/include; ../../../../../devices/MIMXRT1176; ../../../../../components/uart; ../../../../../components/lists; ../../../../../devices/MIMXRT1176/xip; ../../../xip; ../../../../../devices/MIMXRT1176/drivers/cm7; ../../../xmcd; ../../../../../components/video/display/dc; ../../../../../rtos/freertos/freertos-kernel/include; ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F; ../../template/cm7; ../../../../../middleware/vglite/inc; ../../../../../middleware/vglite/font; ../../../../../middleware/vglite/font/mcufont/decoder; ../../../../../middleware/vglite/VGLite/rtos; ../../../../../middleware/vglite/VGLiteKernel; ../../../../../middleware/vglite/VGLiteKernel/rtos; ../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_CLEAR_BSS; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ../cm7; ../../..
  ILINK.IlinkOutputFile: crank_storyboard_helloworld.out
  ILINK.IlinkConfigDefines: __use_flash64MB__=1
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/Crank_Software/cortexM-vglite/lib/CM7-iar/libgre.a; ../../../../../middleware/Crank_Software/cortexM-vglite/lib/CM7-iar/libgreal.a; ../../../../../middleware/Crank_Software/cortexM-vglite/lib/CM7-iar/libsbimage.a; ../../../../../middleware/Crank_Software/cortexM-vglite/lib/CM7-iar/libsbvfs.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM7-iar/libgre-plugin-animation.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM7-iar/libgre-plugin-circle.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM7-iar/libgre-plugin-greio.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM7-iar/libgre-plugin-logger.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM7-iar/libgre-plugin-lua.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM7-iar/libgre-plugin-metrics.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM7-iar/libgre-plugin-poly.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM7-iar/libgre-plugin-trace.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM7-iar/libgre-plugin-screen-drag.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM7-iar/libgre-plugin-screen-path.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM7-iar/libgre-plugin-timer.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM7-iar/libgre-plugin-sbimage-soil.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM7-iar/libfont-plugin-freetype.a; ../../../../../middleware/Crank_Software/cortexM-vglite/plugins/CM7-iar/librender-plugin-vglite.a; ../../../../../middleware/Crank_Software/cortexM-vglite/lib/CM7-iar/liblogging-util.a; ../../../../../middleware/Crank_Software/cortexM-vglite/lib/CM7-iar/libgreio.a; ../../../../../middleware/Crank_Software/cortexM-vglite/lib/CM7-iar/libswrender.a; ../../../../../middleware/Crank_Software/cortexM-vglite/lib/CM7-iar/libsbfreetype.a; ../../../../../middleware/Crank_Software/cortexM-vglite/lib/CM7-iar/libsblua.a; ../../../../../middleware/Crank_Software/cortexM-vglite/lib/CM7-iar/libsoil.a; ../../../../../middleware/Crank_Software/cortexM-vglite/lib/CM7-iar/libpng.a; ../../../../../middleware/Crank_Software/cortexM-vglite/lib/CM7-iar/libsbz.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=0; XIP_BOOT_HEADER_XMCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; SKIP_SYSCLK_INIT; FLEXRAM_CFG_ENABLE=1; GRE_TARGET_OS_freertos; GRE_TARGET_CPU_cortexm7; GRE_FEATURE_VFS_RESOURCES; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; CUSTOM_VGLITE_MEMORY_CONFIG=1; SDK_OS_FREE_RTOS; VG_COMMAND_CALL=1; VG_TARGET_FAST_CLEAR=0
  AARM.ADefines: NDEBUG; __STARTUP_CLEAR_BSS; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../cm7/: display_support.h display_support.c pin_mux.c pin_mux.h vglite_support.c vglite_support.h touch.c touch.h
    ../: board.c board.h clock_config.c clock_config.h dcd.c dcd.h
    ../../../xmcd/: xmcd.c xmcd.h
  group source
    ../cm7/: HelloWorld.h sbengine_task_vglite.c sbengine_plugins.h storyboard_freertos.c FreeRTOSConfig.h
  group doc
    ../: readme.txt
  group evkbmimxrt1170
    ../: evkbmimxrt1170_connect_cm4_cm7side.jlinkscript
  group drivers
    ../../../../../devices/MIMXRT1176/drivers/: fsl_elcdif.c fsl_elcdif.h fsl_pxp.c fsl_pxp.h fsl_lpi2c.c fsl_lpi2c.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_soc_src.h fsl_soc_src.c fsl_snvs_hp.c fsl_snvs_hp.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_memory.h fsl_soc_mipi_csi2rx.h fsl_soc_mipi_csi2rx.c fsl_lcdifv2.c fsl_lcdifv2.h fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group touchpanel
    ../../../../../components/ft5406_rt/: fsl_ft5406_rt.h fsl_ft5406_rt.c
    ../../../../../components/gt911/: fsl_gt911.h fsl_gt911.c
  group video
    ../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../components/video/display/: fsl_display.h
    ../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
    ../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../components/video/display/dc/lcdifv2/: fsl_dc_fb_lcdifv2.h fsl_dc_fb_lcdifv2.c
    ../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.h fsl_dc_fb_elcdif.c
    ../../../../../components/video/display/fbdev/: fsl_fbdev.h fsl_fbdev.c
    ../../../../../components/video/display/hx8394/: fsl_hx8394.h fsl_hx8394.c
    ../../../../../components/video/display/dc/: fsl_dc_fb.h
  group utilities
    ../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group freertos/freertos-kernel
    ../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/portable
    ../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: heap_3.c ReadMe.url
  group freertos/freertos-kernel/portable/IAR/ARM_CM4F
    ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos-kernel/include
    ../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group device
    ../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group xip
    ../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkbmimxrt1170_flexspi_nor_config.c evkbmimxrt1170_flexspi_nor_config.h
  group vglite
    ../../../../../middleware/vglite/: ChangeLogKSDK.txt
  group vglite/inc
    ../../../../../middleware/vglite/inc/: vg_lite.h vg_lite_hal.h vg_lite_text.h
  group vglite/VGLite
    ../../../../../middleware/vglite/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_flat.h vg_lite_flat.c
  group vglite/VGLite/rtos
    ../../../../../middleware/vglite/VGLite/rtos/: vg_lite_os.h vg_lite_os.c
  group vglite/font
    ../../../../../middleware/vglite/font/: buf_reader.c buf_reader.h fonts.h rle_font_read.c vft_debug.c vft_debug.h vft_draw.c vft_draw.h vg_lite_text.c
  group vglite/font/mcufont
    ../../../../../middleware/vglite/font/mcufont/: LICENSE
  group vglite/font/mcufont/decoder
    ../../../../../middleware/vglite/font/mcufont/decoder/: mcufont.h mf_bwfont.c mf_bwfont.h mf_config.h mf_encoding.c mf_encoding.h mf_font.c mf_font.h mf_justify.c mf_justify.h mf_kerning.c mf_kerning.h mf_rlefont.c mf_rlefont.h mf_scaledfont.c mf_scaledfont.h mf_wordwrap.c mf_wordwrap.h
  group vglite/VGLiteKernel
    ../../../../../middleware/vglite/VGLiteKernel/: vg_lite_hw.h vg_lite_kernel.h vg_lite_kernel.c
  group vglite/VGLiteKernel/rtos
    ../../../../../middleware/vglite/VGLiteKernel/rtos/: vg_lite_hal.c vg_lite_platform.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
