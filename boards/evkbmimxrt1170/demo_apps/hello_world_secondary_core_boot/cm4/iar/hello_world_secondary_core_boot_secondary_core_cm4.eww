<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>hello_world_secondary_core_boot_secondary_core_cm4</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
      <member>
        <project>hello_world_secondary_core_boot_secondary_core_cm4</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
      <member>
        <project>hello_world_secondary_core_boot_secondary_core_cm4</project>
        <configuration>flexspi_nor_sdram_debug</configuration>
      </member>
      <member>
        <project>hello_world_secondary_core_boot_secondary_core_cm4</project>
        <configuration>flexspi_nor_sdram_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_debug</name>
      <member>
        <project>hello_world_secondary_core_boot_secondary_core_cm4</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_release</name>
      <member>
        <project>hello_world_secondary_core_boot_secondary_core_cm4</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_sdram_debug</name>
      <member>
        <project>hello_world_secondary_core_boot_secondary_core_cm4</project>
        <configuration>flexspi_nor_sdram_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_sdram_release</name>
      <member>
        <project>hello_world_secondary_core_boot_secondary_core_cm4</project>
        <configuration>flexspi_nor_sdram_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/hello_world_secondary_core_boot_secondary_core_cm4.ewp</path>
  </project>
</workspace>
