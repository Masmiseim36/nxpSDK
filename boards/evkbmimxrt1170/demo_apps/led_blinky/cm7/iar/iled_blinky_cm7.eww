<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>iled_blinky_cm7</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>iled_blinky_cm7</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>iled_blinky_cm7</project>
        <configuration>sdram_debug</configuration>
      </member>
      <member>
        <project>iled_blinky_cm7</project>
        <configuration>sdram_release</configuration>
      </member>
      <member>
        <project>iled_blinky_cm7</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
      <member>
        <project>iled_blinky_cm7</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>iled_blinky_cm7</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>iled_blinky_cm7</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdram_debug</name>
      <member>
        <project>iled_blinky_cm7</project>
        <configuration>sdram_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdram_release</name>
      <member>
        <project>iled_blinky_cm7</project>
        <configuration>sdram_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_debug</name>
      <member>
        <project>iled_blinky_cm7</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_release</name>
      <member>
        <project>iled_blinky_cm7</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/iled_blinky_cm7.ewp</path>
  </project>
</workspace>
