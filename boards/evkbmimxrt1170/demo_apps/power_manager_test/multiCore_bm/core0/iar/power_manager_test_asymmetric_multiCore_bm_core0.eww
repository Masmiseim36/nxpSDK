<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>power_manager_test_asymmetric_multiCore_bm_core0</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
      <member>
        <project>power_manager_test_asymmetric_multiCore_bm_core0</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_debug</name>
      <member>
        <project>power_manager_test_asymmetric_multiCore_bm_core0</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_release</name>
      <member>
        <project>power_manager_test_asymmetric_multiCore_bm_core0</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/power_manager_test_asymmetric_multiCore_bm_core0.ewp</path>
  </project>
</workspace>
