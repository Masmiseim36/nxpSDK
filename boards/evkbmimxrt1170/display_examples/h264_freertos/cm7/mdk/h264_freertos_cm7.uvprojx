# Keil uVision project h264_freertos_cm7.uvprojx, settings and files
target h264_freertos_cm7 flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1176DVMAB:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: h264_freertos_cm7.out
  AfterMake: fromelf.exe --output "$Lh264_freertos.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_SDRAM, XIP_BOOT_HEADER_DCD_ENABLE=1, DATA_SECTION_IS_CACHEABLE=1, DEBUG, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, SDK_I2C_BASED_COMPONENT_USED=1, CPU_MIMXRT1176DVMAB_cm7, MIMXRT1176_cm7_SERIES, OSA_USED, USE_RTOS=1, SD_ENABLED=1, __NXP_MSDK__, SDK_OS_FREE_RTOS
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb -fno-exceptions
  c include: ..;../../../../../../middleware/openh264/example/h264_freertos;../../../../../../middleware/openh264/example/h264_freertos/freertos_libraries/abstractions/posix/include;../../../../../../middleware/openh264/example/h264_freertos/freertos_libraries/abstractions/posix/include/FreeRTOS_POSIX/sys;../../../../../../middleware/openh264/example/h264_freertos/freertos_libraries/freertos_plus/standard/freertos_plus_posix/include;../../../../../../middleware/openh264/example/h264_freertos/freertos_libraries/c_sdk/standard/common/include/private;../../../../xip;../../../../../../devices/MIMXRT1176/xip;../../../../../../devices/MIMXRT1176/drivers;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MIMXRT1176;../../../../../../devices/MIMXRT1176/periph;../../../../../../devices/MIMXRT1176/drivers/cm7;../../../../../../devices/MIMXRT1176/utilities/debug_console_lite;../../../../../../components/lists;../../../../../../devices/MIMXRT1176/utilities/str;../../../../../../components/gpio;../../../../../../components/uart;../../../../../../components/osa;../../../../../../components/video;../../../../../../components/video/display/dc;../../../../../../components/video/display;../../../../../../components/video/display/fbdev;../../../../../../components/video/display/dc/elcdif;../../../../../../components/video/display/dc/lcdifv2;../../../../../../components/video/display/mipi_dsi_cmd;../../../../../../components/video/display/hx8394;../../../../../../components/video/display/rm68191;../../../../../../components/video/display/rm68200;../../../../../../components/video/display/rpi;../../../../../../components/touch/gt911;../../../../../../middleware/fatfs/source;../../../../../../middleware/fatfs/template;../../../../../../middleware/fatfs/source/fsl_sd_disk;../../../../../../middleware/sdmmc/common;../../../../../../middleware/sdmmc/osa;../../../../../../middleware/sdmmc/sd;../../../../../../middleware/sdmmc/host/usdhc;../../../../../../middleware/openh264/codec/api/wels;../../../../../../middleware/openh264/codec/common/inc;../../../../../../middleware/openh264/codec/decoder/core/inc;../../../../../../middleware/openh264/codec/decoder/plus/inc;../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1176DVMAB_cm7, MIMXRT1176_cm7_SERIES, OSA_USED
  asm include: ..;../../../../xip;../../../../../../devices/MIMXRT1176/xip;../../../../../../devices/MIMXRT1176/drivers;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MIMXRT1176;../../../../../../devices/MIMXRT1176/periph;../../../../../../devices/MIMXRT1176/drivers/cm7;../../../../../../devices/MIMXRT1176/utilities/debug_console_lite;../../../../../../components/lists;../../../../../../devices/MIMXRT1176/utilities/str;../../../../../../components/gpio;../../../../../../components/uart;../../../../../../components/osa;../../../../../../components/video;../../../../../../components/video/display/dc;../../../../../../components/video/display;../../../../../../components/video/display/fbdev;../../../../../../components/video/display/dc/elcdif;../../../../../../components/video/display/dc/lcdifv2;../../../../../../components/video/display/mipi_dsi_cmd;../../../../../../components/video/display/hx8394;../../../../../../components/video/display/rm68191;../../../../../../components/video/display/rm68200;../../../../../../components/video/display/rpi;../../../../../../components/touch/gt911;../../../../../../middleware/fatfs/source;../../../../../../middleware/fatfs/template;../../../../../../middleware/fatfs/source/fsl_sd_disk;../../../../../../middleware/sdmmc/common;../../../../../../middleware/sdmmc/osa;../../../../../../middleware/sdmmc/sd;../../../../../../middleware/sdmmc/host/usdhc;../../../../../../middleware/openh264/codec/api/wels;../../../../../../middleware/openh264/codec/common/inc;../../../../../../middleware/openh264/codec/decoder/core/inc;../../../../../../middleware/openh264/codec/decoder/plus/inc;../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.scf
  link misc: --remove --predefine=\"-DXIP_BOOT_HEADER_ENABLE=1\" --predefine=\"-D__use_flash64MB__=1\" --predefine=\"-D__stack_size__=0x1000\" --predefine=\"-D__heap_size__=0x1800000\" --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: h264_freertos.c FreeRTOS_POSIX_portable.h display.c display.h h264_dec.h h264_dec.cpp sdcard.c sdcard.h FreeRTOSConfig.h sdmmc_config.h sdmmc_config.c FreeRTOSConfigBoard.h display_support.h display_support.c FreeRTOSConfig_Gen.h ffconf_gen.h fsl_os_abstraction_config.h mcux_config.h
  group openh264/example/h264_freertos/freertos_libraries/abstractions/posix/include/FreeRTOS_POSIX
    ../../../../../../middleware/openh264/example/h264_freertos/freertos_libraries/abstractions/posix/include/FreeRTOS_POSIX/: errno.h fcntl.h mqueue.h pthread.h sched.h semaphore.h signal.h time.h unistd.h utils.h
  group openh264/example/h264_freertos/freertos_libraries/abstractions/posix/include/FreeRTOS_POSIX/sys
    ../../../../../../middleware/openh264/example/h264_freertos/freertos_libraries/abstractions/posix/include/FreeRTOS_POSIX/sys/: types.h
  group openh264/example/h264_freertos/freertos_libraries/freertos_plus/standard/freertos_plus_posix/include
    ../../../../../../middleware/openh264/example/h264_freertos/freertos_libraries/freertos_plus/standard/freertos_plus_posix/include/: FreeRTOS_POSIX.h FreeRTOS_POSIX_internal.h FreeRTOS_POSIX_portable_default.h FreeRTOS_POSIX_types.h
  group openh264/example/h264_freertos/freertos_libraries/freertos_plus/standard/freertos_plus_posix/source
    ../../../../../../middleware/openh264/example/h264_freertos/freertos_libraries/freertos_plus/standard/freertos_plus_posix/source/: FreeRTOS_POSIX_clock.c FreeRTOS_POSIX_mqueue.c FreeRTOS_POSIX_pthread.c FreeRTOS_POSIX_pthread_barrier.c FreeRTOS_POSIX_pthread_cond.c FreeRTOS_POSIX_pthread_mutex.c FreeRTOS_POSIX_sched.c FreeRTOS_POSIX_semaphore.c FreeRTOS_POSIX_timer.c FreeRTOS_POSIX_unistd.c FreeRTOS_POSIX_utils.c
  group openh264/example/h264_freertos/freertos_libraries/c_sdk/standard/common/include/private
    ../../../../../../middleware/openh264/example/h264_freertos/freertos_libraries/c_sdk/standard/common/include/private/: iot_doubly_linked_list.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group xip
    ../../../../xip/: evkbmimxrt1170_flexspi_nor_config.c evkbmimxrt1170_flexspi_nor_config.h
    ../../../../: dcd.c dcd.h xmcd.c xmcd.h
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_soc_mipi_csi2rx.c fsl_soc_mipi_csi2rx.h fsl_soc_mipi_dsi.h fsl_anatop_ai.c fsl_anatop_ai.h fsl_memory.h fsl_dcdc.c fsl_dcdc.h fsl_gpc.c fsl_gpc.h fsl_pgmc.h fsl_pgmc.c fsl_pmu.h fsl_pmu.c fsl_soc_src.c fsl_soc_src.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_elcdif.c fsl_elcdif.h fsl_gpio.h fsl_gpio.c fsl_lcdifv2.c fsl_lcdifv2.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.h fsl_lpuart.c fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_mu.h fsl_mu.c fsl_pxp.c fsl_pxp.h fsl_usdhc.c fsl_usdhc.h
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv7m_cachel1.h armv7m_mpu.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_COMMON.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group device/periph
    ../../../../../../devices/MIMXRT1176/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_ANADIG_LDO_SNVS.h PERI_ANADIG_LDO_SNVS_DIG.h PERI_ANADIG_MISC.h PERI_ANADIG_OSC.h PERI_ANADIG_PLL.h PERI_ANADIG_PMU.h PERI_ANADIG_TEMPSENSOR.h PERI_AOI.h PERI_ASRC.h PERI_AUDIO_PLL.h PERI_CAAM.h PERI_CAN.h PERI_CAN_WRAPPER.h PERI_CCM.h PERI_CCM_OBS.h PERI_CDOG.h PERI_CMP.h PERI_CSI.h PERI_DAC.h PERI_DCDC.h PERI_DCIC.h PERI_DMA.h PERI_DMAMUX.h PERI_DSI_HOST.h PERI_DSI_HOST_APB_PKT_IF.h PERI_DSI_HOST_DPI_INTFC.h PERI_DSI_HOST_NXP_FDSOI28_DPHY_INTFC.h PERI_EMVSIM.h PERI_ENC.h PERI_ENET.h PERI_ENET_QOS.h PERI_ETHERNET_PLL.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC_CPU_MODE_CTRL.h PERI_GPC_SET_POINT_CTRL.h PERI_GPC_STBY_CTRL.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IEE.h PERI_IEE_APC.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_LPSR.h PERI_IOMUXC_LPSR_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_IPS_DOMAIN.h PERI_KEY_MANAGER.h PERI_KPP.h PERI_LCDIF.h PERI_LCDIFV2.h PERI_LMEM.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_MCM.h PERI_MECC.h PERI_MIPI_CSI2RX.h PERI_MMCAU.h PERI_MU.h PERI_OCOTP.h PERI_OSC_RC_400M.h PERI_OTFAD.h PERI_PDM.h PERI_PGMC_BPC.h PERI_PGMC_CPC.h PERI_PGMC_MIF.h PERI_PGMC_PPC.h PERI_PHY_LDO.h PERI_PIT.h PERI_PUF.h PERI_PWM.h PERI_PXP.h PERI_RDC.h PERI_RDC_SEMAPHORE.h PERI_RTWDOG.h PERI_SEMA4.h PERI_SEMC.h PERI_SNVS.h PERI_SPDIF.h PERI_SRAM.h PERI_SRC.h PERI_SSARC_HP.h PERI_SSARC_LP.h PERI_TMPSNS.h PERI_TMR.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_VIDEO_MUX.h PERI_VIDEO_PLL.h PERI_VMBANDGAP.h PERI_WDOG.h PERI_XBARA.h PERI_XBARB.h PERI_XECC.h PERI_XRDC2.h
  group startup/arm
    ../../../../../../devices/MIMXRT1176/arm/: startup_MIMXRT1176_cm7.S
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
    ../../../../../../devices/MIMXRT1176/utilities/: fsl_memcpy.S
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group utilities/str
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/gpio
    ../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h
  group video
    ../../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../../components/video/display/dc/: fsl_dc_fb.h
    ../../../../../../components/video/display/: fsl_display.h
    ../../../../../../components/video/display/fbdev/: fsl_fbdev.h fsl_fbdev.c
    ../../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.h fsl_dc_fb_elcdif.c
    ../../../../../../components/video/display/dc/lcdifv2/: fsl_dc_fb_lcdifv2.h fsl_dc_fb_lcdifv2.c
    ../../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
    ../../../../../../components/video/display/hx8394/: fsl_hx8394.h fsl_hx8394.c
    ../../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../../components/video/display/rpi/: fsl_rpi.h fsl_rpi.c
  group touchpanel
    ../../../../../../components/touch/gt911/: fsl_gt911.h fsl_gt911.c
  group fatfs/source
    ../../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group source/template
    ../../../../../../middleware/fatfs/template/: ffconf.h
  group fatfs/source/fsl_sd_disk
    ../../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group sdmmc/common
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h fsl_sdmmc_common.c
  group sdmmc/osa
    ../../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group sdmmc/sd
    ../../../../../../middleware/sdmmc/sd/: fsl_sd.c fsl_sd.h
  group sdmmc/host/usdhc
    ../../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h fsl_sdmmc_host.h
  group sdmmc/host/usdhc/non_blocking
    ../../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group openh264/codec/api/wels
    ../../../../../../middleware/openh264/codec/api/wels/: codec_api.h codec_app_def.h codec_def.h codec_ver.h
  group openh264/codec/common/inc
    ../../../../../../middleware/openh264/codec/common/inc/: asmdefs_mmi.h copy_mb.h cpu.h cpu_core.h crt_util_safe_x.h deblocking_common.h expand_pic.h golomb_common.h intra_pred_common.h loongson_intrinsics.h ls_defines.h macros.h mc.h measure_time.h memory_align.h msa_macros.h sad_common.h typedefs.h utils.h version.h wels_common_defs.h wels_const_common.h welsCodecTrace.h WelsList.h WelsLock.h WelsTask.h WelsTaskThread.h WelsThread.h WelsThreadLib.h WelsThreadPool.h
  group openh264/codec/common/src
    ../../../../../../middleware/openh264/codec/common/src/: common_tables.cpp copy_mb.cpp cpu.cpp crt_util_safe_x.cpp deblocking_common.cpp expand_pic.cpp intra_pred_common.cpp mc.cpp memory_align.cpp sad_common.cpp utils.cpp welsCodecTrace.cpp WelsTaskThread.cpp WelsThread.cpp WelsThreadLib.cpp WelsThreadPool.cpp
  group openh264/codec/decoder/core/inc
    ../../../../../../middleware/openh264/codec/decoder/core/inc/: au_parser.h bit_stream.h cabac_decoder.h deblocking.h dec_frame.h dec_golomb.h decode_mb_aux.h decode_slice.h decoder.h decoder_context.h decoder_core.h error_code.h error_concealment.h fmo.h get_intra_predictor.h manage_dec_ref.h mb_cache.h memmgr_nal_unit.h mv_pred.h nal_prefix.h nalu.h parameter_sets.h parse_mb_syn_cabac.h parse_mb_syn_cavlc.h pic_queue.h picture.h rec_mb.h slice.h vlc_decoder.h wels_common_basis.h wels_const.h wels_decoder_thread.h
  group openh264/codec/decoder/core/src
    ../../../../../../middleware/openh264/codec/decoder/core/src/: au_parser.cpp bit_stream.cpp cabac_decoder.cpp deblocking.cpp decode_mb_aux.cpp decode_slice.cpp decoder.cpp decoder_core.cpp decoder_data_tables.cpp error_concealment.cpp fmo.cpp get_intra_predictor.cpp manage_dec_ref.cpp memmgr_nal_unit.cpp mv_pred.cpp parse_mb_syn_cabac.cpp parse_mb_syn_cavlc.cpp pic_queue.cpp rec_mb.cpp wels_decoder_thread.cpp
  group openh264/codec/decoder/plus/inc
    ../../../../../../middleware/openh264/codec/decoder/plus/inc/: welsDecoderExt.h
  group openh264/codec/decoder/plus/src
    ../../../../../../middleware/openh264/codec/decoder/plus/src/: welsDecoderExt.cpp
  group openh264
    ../../../../../../middleware/openh264/: LICENSE CODING_STYLE README.md RELEASES ChangeLogKSDK.txt
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/GCC/ARM_CM4F
    ../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
target h264_freertos_cm7 flexspi_nor_release (ARM-ADS)
  device: MIMXRT1176DVMAB:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: h264_freertos_cm7.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_SDRAM, XIP_BOOT_HEADER_DCD_ENABLE=1, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, SDK_I2C_BASED_COMPONENT_USED=1, CPU_MIMXRT1176DVMAB_cm7, MIMXRT1176_cm7_SERIES, OSA_USED, USE_RTOS=1, SD_ENABLED=1, __NXP_MSDK__, SDK_OS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: as above
  asm include: as above
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.scf
  link misc: as above
