# IAR project audio_profile.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1176DVMAA_cm7; MFLASH_FILE_BASEADDR=15466496; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; APPL_USE_STANDARD_IO; GATT_CLIENT; GATT_DB; FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0; IOT_WIFI_ENABLE_SAVE_NETWORK=1; FSL_OSA_MAIN_FUNC_ENABLE=0; HAL_UART_ADAPTER_FIFO=1; HAL_UART_ISR_PRIORITY=configLIBRARY_LOWEST_INTERRUPT_PRIORITY; FSL_FEATURE_FLASH_PAGE_SIZE_BYTES=4096; gMemManagerLight=0; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; PRINTF_FLOAT_ENABLE=1; MP3_DEC=1; STREAMER_ENABLE_FILESRC; STREAMER_ENABLE_DECODER; SDK_OS_FREE_RTOS; FSL_OSA_TASK_ENABLE=1; SDIO_ENABLED=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING=1; MBEDTLS_USER_CONFIG_FILE="aws_mbedtls_config.h"; SDK_DEBUGCONSOLE_UART=1; CONFIG_BT_BREDR=1; CONFIG_BT_PERIPHERAL=1; CONFIG_BT_CENTRAL=1; CONFIG_BT_SMP=1; BT_BLE_PLATFORM_INIT_ESCAPE; CONTROLLER_INIT_ESCAPE; LPUART_RING_BUFFER_SIZE=1024U; AUDIO_SINK_BUFFER_NUM=2; HAL_UART_DMA_ENABLE=1; HAL_AUDIO_DMA_INIT_ENABLE=0; LFS_NO_INTRINSICS=1; LFS_NO_ERROR=1; CONFIG_ARM=1; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_UART=1; SD_ENABLED; CASCFG_PLATFORM_FREERTOS; FSL_OS_SELECTED=SDK_OS_FREERTOS; CRYPTO_USE_DRIVER_CAAM; CACHE_MODE_WRITE_THROUGH=1; LOG_ENABLE_ASYNC_MODE=1; LOG_MAX_ARGUMENT_COUNT=10; LOG_ENABLE_OVERWRITE=0; MQTT_AGENT_DO_NOT_USE_CUSTOM_CONFIG; DEBUG_CONSOLE_RX_ENABLE=0; MBEDTLS_CONFIG_FILE="ksdk_mbedtls_config.h"; LWIP_DNS=1; LWIP_NETIF_HOSTNAME=1; LWIP_NETIF_STATUS_CALLBACK=1; LWIP_IGMP=1; MBEDTLS_THREADING_ALT; MBEDTLS_THREADING_C
  ICCARM.CCDiagSuppress: Pa050,Pa082,Pe186,Pe815,Pa167,Pe177,Pe546,Pa082,Pa050,Pa167,Pe177,Pe191,Pe546
  ICCARM.PreInclude: ../app_bluetooth_config.h
  ICCARM.CCIncludePath2: ..; ../../../../../../middleware/edgefast_bluetooth/examples/audio_profile; ../config_files; ../../../..; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../devices/MIMXRT1176; ../../../../../../components/uart; ../../../../../../devices/MIMXRT1176/utilities; ../../../../../../devices/MIMXRT1176/utilities/str; ../../../../../../devices/MIMXRT1176/utilities/debug_console; ../../../../../../devices/MIMXRT1176/xip; ../../../../xip; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../middleware/sdmmc/host/usdhc; ../../../../../../middleware/sdmmc/sdio; ../../../../../../devices/MIMXRT1176/drivers/cm7; ../../../../../../middleware/sdmmc/sd; ../../../../../../middleware/maestro/config; ../../../../../../middleware/maestro/inc; ../../../../../../middleware/maestro/streamer/cci/include; ../../../../../../middleware/maestro/streamer/core; ../../../../../../middleware/maestro/streamer/decoders/cci_dec; ../../../../../../middleware/maestro/streamer/devices; ../../../../../../middleware/maestro/streamer/elements; ../../../../../../middleware/maestro/streamer/encoders/opus; ../../../../../../middleware/maestro/streamer/encoders/cei; ../../../../../../middleware/usb/host; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/host/class; ../../../../../../middleware/usb/phy; ../../../../../../middleware/fatfs/source/fsl_usb_disk; ../../../../../../middleware/fatfs/source; ../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/platform; ../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind; ../../../../../../components/flash/mflash/mimxrt1170evkb; ../../../../../../components/flash/mflash; ../../../../../../middleware/mbedtls/include; ../../../../../../middleware/mbedtls/library; ../../../../../../middleware/mbedtls/port/ksdk; ../../../../../../middleware/wifi_nxp/incl; ../../../../../../middleware/wifi_nxp/incl/wlcmgr; ../../../../../../middleware/wifi_nxp/wifidriver; ../../../../../../middleware/wifi_nxp/wifidriver/incl; ../../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if; ../../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if/incl; ../../../../../../middleware/wifi_nxp/certs; ../../../../../../middleware/wifi_nxp/firmware_dnld; ../../../../../../middleware/wifi_nxp/sdio_nxp_abs; ../../../../../../middleware/wifi_nxp/sdio_nxp_abs/incl; ../../../../../../components/gpio; ../../../../../../components/osa; ../../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits; ../../../../../../components/wifi_bt_module/Murata/tx_pwr_limits; ../../../../../../components/wifi_bt_module/u-blox/tx_pwr_limits; ../../../../../../middleware/aws_iot/device-shadow/source/include; ../../../../../../middleware/wireless/ethermind/bluetooth/export/eOSAL; ../../../../../../middleware/wireless/ethermind/bluetooth/export/include; ../../../../../../middleware/wireless/ethermind/bluetooth/export/vendor; ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/att; ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avctp; ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avdtp; ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/bnep; ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/dbase; ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/hci_1.2; ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/mcap; ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/obex; ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/rfcomm; ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sdp; ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sm; ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/smp; ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/aes_cmac; ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/at_parser; ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/object_parser; ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/racp; ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/storage; ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/xml_parser; ../../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth; ../../../../../../middleware/wireless/ethermind/port/pal/mcux/ethal; ../../../../../../middleware/wireless/ethermind/port/pal/mcux/sbc; ../../../../../../middleware/wireless/ethermind/port/osal/src/freertos; ../../../../../../middleware/wireless/ethermind/port/pal/mcux; ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/sbc; ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/config; ../../../../../../middleware/wireless/ethermind/bluetooth/export/extension; ../../../../../../middleware/edgefast_bluetooth/include; ../../../../../../middleware/edgefast_bluetooth/source/porting; ../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/host; ../../../../../../components/edgefast_wifi/include; ../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F; ../../../../../../rtos/freertos/corejson/source/include; ../../../../../../rtos/freertos/coremqtt/source/include; ../../../../../../rtos/freertos/coremqtt/source/interface; ../../../../../../rtos/freertos/coremqtt-agent/source/include; ../../../../../../rtos/freertos/corepkcs11/source/include; ../../../../../../rtos/freertos/corepkcs11/source/dependency/3rdparty/mbedtls_utils; ../../../../../../middleware/aws_iot/iot-reference/examples/common/kvstore; ../../../../../../middleware/aws_iot/iot-reference/examples/common/logging; ../../../../../../middleware/aws_iot/iot-reference/examples/common/mqtt_agent; ../../../../../../middleware/aws_iot/iot-reference/Middleware/FreeRTOS/mqtt-agent-interface/include; ../../../../../../middleware/aws_iot/iot-reference/Middleware/FreeRTOS/transport_mbedtls; ../../../../../../middleware/wifi_nxp/dhcpd; ../../../../../../middleware/wifi_nxp/incl/port/lwip; ../../../../../../middleware/wifi_nxp/port/lwip; ../../../../../../middleware/wifi_nxp/incl/port/lwip/hooks; ../../../../../../middleware/lwip/port; ../../../../../../middleware/lwip/src; ../../../../../../middleware/lwip/src/include; ../../../../../../middleware/pkcs11; ../../../../../../devices/MIMXRT1176/utilities/shell; ../../../../../../components/internal_flash; ../../../../../../middleware/littlefs; ../../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth/controller; ../../../../../../CMSIS/Core/Include; ../../../../../../middleware/sdmmc/common; ../../../../../../middleware/sdmmc/osa; ../../../../../../middleware/maestro/template; ../../../../../../middleware/wifi_nxp/incl/wifidriver; ../../../../../../middleware/wifi_nxp/incl/port/os; ../../../../../../middleware/wifi_nxp/wifi_bt_firmware; ../../../../../../components/wifi_bt_module/incl; ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/8801; ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/IW416; ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/8987; ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/nw61x; ../../../../../../middleware/wifi_nxp/fwdnld_intf_abs; ../../../../../../components/log; ../../../../../../middleware/edgefast_bluetooth/output/templates/config/mbedtls; ../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/crypto; ../../../../../../rtos/freertos/backoffalgorithm/source/include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../../../..
  ILINK.IlinkOutputFile: audio_profile.out
  ILINK.IlinkConfigDefines: __use_flash64MB__=1; __stack_size__=0x1000; __heap_size__=0x400
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../middleware/maestro/libs/cm7f/iar/release/libmp3.a; ../../../../../../middleware/maestro/libs/cm7f/iar/release/libwav.a; ../../../../../../middleware/maestro/libs/cm7f/iar/release/libflac.a; ../../../../../../middleware/maestro/libs/cm7f/iar/release/libssrc.a; ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_a2dp.a; ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_avrcp.a; ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_bip.a; ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_bpp.a; ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_core.a; ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_ctn.a; ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_ftp.a; ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_ga.a; ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_gatt.a; ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_hfp.a; ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_hid.a; ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_map.a; ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_opp.a; ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_pan.a; ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_pbap.a; ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_protocol.a; ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_sap.a; ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_spp.a; ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_bt_util.a; ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_sbc_common.a; ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_sbc_decoder.a; ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/iar/libethermind_sbc_encoder.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: LFS_NO_ASSERT; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; MFLASH_FILE_BASEADDR=15466496; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; APPL_USE_STANDARD_IO; GATT_CLIENT; GATT_DB; FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0; IOT_WIFI_ENABLE_SAVE_NETWORK=1; FSL_OSA_MAIN_FUNC_ENABLE=0; HAL_UART_ADAPTER_FIFO=1; HAL_UART_ISR_PRIORITY=configLIBRARY_LOWEST_INTERRUPT_PRIORITY; FSL_FEATURE_FLASH_PAGE_SIZE_BYTES=4096; gMemManagerLight=0; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; PRINTF_FLOAT_ENABLE=1; MP3_DEC=1; STREAMER_ENABLE_FILESRC; STREAMER_ENABLE_DECODER; SDK_OS_FREE_RTOS; FSL_OSA_TASK_ENABLE=1; SDIO_ENABLED=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING=1; MBEDTLS_USER_CONFIG_FILE="aws_mbedtls_config.h"; SDK_DEBUGCONSOLE_UART=1; CONFIG_BT_BREDR=1; CONFIG_BT_PERIPHERAL=1; CONFIG_BT_CENTRAL=1; CONFIG_BT_SMP=1; BT_BLE_PLATFORM_INIT_ESCAPE; CONTROLLER_INIT_ESCAPE; LPUART_RING_BUFFER_SIZE=1024U; AUDIO_SINK_BUFFER_NUM=2; HAL_UART_DMA_ENABLE=1; HAL_AUDIO_DMA_INIT_ENABLE=0; LFS_NO_INTRINSICS=1; LFS_NO_ERROR=1; CONFIG_ARM=1; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_UART=1; SD_ENABLED; CASCFG_PLATFORM_FREERTOS; FSL_OS_SELECTED=SDK_OS_FREERTOS; CRYPTO_USE_DRIVER_CAAM; CACHE_MODE_WRITE_THROUGH=1; LOG_ENABLE_ASYNC_MODE=1; LOG_MAX_ARGUMENT_COUNT=10; LOG_ENABLE_OVERWRITE=0; MQTT_AGENT_DO_NOT_USE_CUSTOM_CONFIG; DEBUG_CONSOLE_RX_ENABLE=0; MBEDTLS_CONFIG_FILE="ksdk_mbedtls_config.h"; LWIP_DNS=1; LWIP_NETIF_HOSTNAME=1; LWIP_NETIF_STATUS_CALLBACK=1; LWIP_IGMP=1; MBEDTLS_THREADING_ALT; MBEDTLS_THREADING_C
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: app_bluetooth_config.h wifi_config.h aws_dev_mode_key_provisioning.h aws_dev_mode_key_provisioning.c edgefast_bluetooth_config.h edgefast_bluetooth_debug_config.h cmd.c cmd.h main.c app_music_control.c app_music_control.h FreeRTOSConfig.h app_a2dp.c app_a2dp.h app_common.c app_common.h shadow_device_task.c shadow_update_task.c aws_clientcredential.h aws_clientcredential_keys.h core_mqtt_config.h core_pkcs11_config.h demo_config.h kvstore_config.h shadow_config.h audio.conf.h audio_cfg.h os_cfg.h app_streamer.c app_streamer.h streamer_pcm.c streamer_pcm.h usb_host_fatfs.c usb_host_fatfs.h usb_host_config.h ffconf.h wifi_bt_module_config.h
    ../config_files/: aws_mbedtls_config.h lwipopts.h wifi_config.h iot_pkcs11_pal.c
    ../../../../../../middleware/edgefast_bluetooth/output/templates/config/mbedtls/: mbedtls_config_client.h
  group board
    ../: sdmmc_config.c sdmmc_config.h pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h wifi_bt_config.c wifi_bt_config.h dcd.c dcd.h
  group doc
    ../: readme.md
  group bt_ble/port/pal/mcux
    ../../../../../../middleware/wireless/ethermind/port/pal/mcux/: EM_platform.c EM_platform.h
  group bt_ble/port/pal/mcux/bluetooth
    ../../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth/: hci_uart.c hci_uart.h hci_uart_internal.h BT_assert.h BT_config.h BT_debug.h BT_debug_api.h BT_fops.h BT_os.h BT_status_pl.c BT_storage_pl.c BT_storage_pl.h BT_timer.h btsnoop_pl.c btsnoop_pl.h sco_audio_pl.c sco_audio_pl.h ctn_pl.c ctn_pl.h ftp_pl.c ftp_pl.h hci_uart_internal.h ht_read_task_pl.c map_pl.c map_pl.h obex_pl.c obex_pl.h pbap_pl.c pbap_pl.h write_task_extern_pl.h write_task_pl.c write_task_pl.h littlefs_pl.c littlefs_pl.h fw_loader_uart.c fw_loader_uart.h
  group bt_ble/port/pal/mcux/bluetooth/controller
    ../../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth/controller/: controller.h controller_wifi_nxp.c controller_hci_uart.h
  group bt_ble/port/pal/mcux/edgefast_support
    ../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/platform/: bt_ble_platform.c bt_ble_platform.h bt_ble_settings.c bt_ble_settings.h host_msd_fatfs.c host_msd_fatfs.h
    ../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/: bt_db_gen.c
  group bt_ble/port/pal/mcux/ethal
    ../../../../../../middleware/wireless/ethermind/port/pal/mcux/ethal/: ethal_assert.h ethal_config.c ethal_config.h ethal_debug.c ethal_debug.h ethal_debug_api.h ethal_debug_internal.h ethal_fops.c ethal_fops.h ethal_os.c ethal_os.h ethal_serial.c ethal_serial.h ethal_timer.c ethal_timer.h ethal_timer_internal.h
  group bt_ble/port/pal/mcux/sbc
    ../../../../../../middleware/wireless/ethermind/port/pal/mcux/sbc/: sbc_os.h
  group bt_ble/port/osal/src/freertos
    ../../../../../../middleware/wireless/ethermind/port/osal/src/freertos/: EM_assert.h EM_config.c EM_config.h EM_debug.c EM_debug.h EM_debug_api.h EM_debug_internal.h EM_fops.c EM_fops.h EM_os.c EM_os.h EM_serial.c EM_serial.h EM_timer.c EM_timer.h EM_timer_internal.h
  group bt_ble/bluetooth/export/eOSAL
    ../../../../../../middleware/wireless/ethermind/bluetooth/export/eOSAL/: eBT_assert.h eBT_config.h eBT_debug_api.h eBT_fops.h eBT_os.h eBT_serial.h eBT_timer.h
  group bt_ble/bluetooth/export/include
    ../../../../../../middleware/wireless/ethermind/bluetooth/export/include/: BT_a2dp_api.h BT_analyzer.h BT_api.h BT_assigned_numbers.h BT_at_parser_api.h BT_att_api.h BT_avctp_api.h BT_avdtp_api.h BT_avrcp_api.h BT_avrcp_ca_api.h BT_bip_api.h BT_bnep_api.h BT_bottom_half.h BT_bpp_api.h BT_common.h BT_ctn_api.h BT_dbase_api.h BT_device_queue.h BT_error.h BT_ftp_api.h BT_gap_api.h BT_gatt_db_api.h BT_hci_api.h BT_hdp_api.h BT_hfp_ag_api.h BT_hfp_unit_api.h BT_hid_device_api.h BT_hid_host_api.h BT_irobex_api.h BT_jpl_api.h BT_map_api.h BT_mcap_api.h BT_obex_api.h BT_opp_api.h BT_pan_api.h BT_pbap_api.h BT_racp.h BT_rfcomm_api.h BT_sap_api.h BT_sdp_api.h BT_security.h BT_sm_api.h BT_smp_api.h BT_snoop.h BT_spp_api.h BT_status.h BT_storage.h BT_version.h fsm_defines.h fsm_engine.h gatt_defines.h hci_transport.h l2cap.h write_task.h
  group bt_ble/bluetooth/export/vendor
    ../../../../../../middleware/wireless/ethermind/bluetooth/export/vendor/: vendor_specific_commands.h vendor_specific_init.c vendor_specific_init.h
  group bt_ble/bluetooth/export/extension
    ../../../../../../middleware/wireless/ethermind/bluetooth/export/extension/: aes_cmac_pl.c aes_cmac_pl.h BT_common_pl.c BT_common_pl.h device_queue_pl.c device_queue_pl.h sm_pl.c sm_pl.h sm_ssp_pl.c sm_ssp_pl.h smp_pl.c smp_pl.h gatt_db_pl.c gatt_db_pl.h
  group bt_ble/bluetooth/private/protocols/att
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/att/: att.h
  group bt_ble/bluetooth/private/protocols/avctp
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avctp/: avctp.h
  group bt_ble/bluetooth/private/protocols/avdtp
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avdtp/: avdtp.h
  group bt_ble/bluetooth/private/protocols/bnep
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/bnep/: bnep.h
  group bt_ble/bluetooth/private/protocols/dbase
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/dbase/: database.h
  group bt_ble/bluetooth/private/protocols/hci_1.2
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/hci_1.2/: hci_h.h
  group bt_ble/bluetooth/private/protocols/mcap
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/mcap/: mcap.h
  group bt_ble/bluetooth/private/protocols/obex
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/obex/: obex.h
  group bt_ble/bluetooth/private/protocols/rfcomm
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/rfcomm/: rfcomm.h
  group bt_ble/bluetooth/private/protocols/sdp
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sdp/: sdp.h
  group bt_ble/bluetooth/private/protocols/sm
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sm/: sm.h sm_extern.h sm_internal.h
  group bt_ble/bluetooth/private/protocols/smp
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/smp/: smp.h smp_extern.h smp_fsm.h smp_fsm_engine.h smp_internal.h
  group bt_ble/bluetooth/private/utils/aes_cmac
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/aes_cmac/: aes_cmac.h
  group bt_ble/bluetooth/private/utils/at_parser
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/at_parser/: at_parser_hsp_hfp.h
  group bt_ble/bluetooth/private/utils/object_parser
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/object_parser/: object_parser_api.h tokenizer.h
  group bt_ble/bluetooth/private/utils/racp
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/racp/: racp.h
  group bt_ble/bluetooth/private/utils/storage
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/storage/: storage.h
  group bt_ble/bluetooth/private/utils/xml_parser
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/xml_parser/: xml_common_defines.h xml_encoder.h xml_parser.h
  group bt_ble/bluetooth/private/utils/sbc
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/sbc/: sbc_api.h
  group bt_ble/bluetooth/private/lib/config
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/config/: BT_features.h BT_limits.h db_gen.h
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_iomuxc.h fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_flexspi.c fsl_flexspi.h fsl_caam.c fsl_caam.h fsl_lpuart_edma.h fsl_lpuart_edma.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_anatop_ai.h fsl_anatop_ai.c fsl_usdhc.c fsl_usdhc.h fsl_memory.h
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group startup
    ../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/gpio
    ../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h fsl_os_abstraction_config.h
  group component/wifi_bt_module/AzureWave/tx_pwr_limits
    ../../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits/: wlan_txpwrlimit_cfg_WW.h wlan_txpwrlimit_cfg_WW_rw610.h
  group component/wifi_bt_module/Murata/tx_pwr_limits
    ../../../../../../components/wifi_bt_module/Murata/tx_pwr_limits/: wlan_txpwrlimit_cfg_murata_1XK_WW.h wlan_txpwrlimit_cfg_murata_1ZM_WW.h wlan_txpwrlimit_cfg_murata_2DS_WW.h wlan_txpwrlimit_cfg_murata_2EL_WW.h
  group component/wifi_bt_module/u-blox/tx_pwr_limits
    ../../../../../../components/wifi_bt_module/u-blox/tx_pwr_limits/: wlan_txpwrlimit_cfg_jody_w5_WW.h
  group component/wifi_bt_module/incl
    ../../../../../../components/wifi_bt_module/incl/: wifi_bt_module_config.h
  group component/internal_flash
    ../../../../../../components/internal_flash/: fsl_adapter_flash.h
  group component/internal_flash/evkbmimxrt1170
    ../../../../../../components/internal_flash/evkbmimxrt1170/: fsl_adapter_flexspi_nor_flash.c
  group component/log
    ../../../../../../components/log/: fsl_component_log.h fsl_component_log_config.h fsl_component_log.c fsl_component_log_backend_debugconsole.c fsl_component_log_backend_debugconsole.h
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1176/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1176/utilities/shell/: fsl_shell.c fsl_shell.h
  group xip
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkbmimxrt1170_flexspi_nor_config.c evkbmimxrt1170_flexspi_nor_config.h
  group sdmmc/host
    ../../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt ChangeLogKSDK.txt
    ../../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group sdmmc/src
    ../../../../../../middleware/sdmmc/sdio/: fsl_sdio.c
    ../../../../../../middleware/sdmmc/sd/: fsl_sd.c
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../../middleware/sdmmc/sdio/: fsl_sdio.h
    ../../../../../../middleware/sdmmc/sd/: fsl_sd.h
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sdio
    ../../../../../../middleware/sdmmc/sdio/: ChangeLogKSDK.txt
  group sdmmc/sd
    ../../../../../../middleware/sdmmc/sd/: ChangeLogKSDK.txt
  group sdmmc/osa
    ../../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group maestro/inc
    ../../../../../../middleware/maestro/inc/: error.h file_utils.h general_utils.h maestro_logging.h ringbuffer.h streamer_api.h streamer_element_properties.h streamer_message.h
  group maestro/config
    ../../../../../../middleware/maestro/config/: audio_cfg.h
  group maestro/streamer/cci/include
    ../../../../../../middleware/maestro/streamer/cci/include/: LVC_Types.h cci_metadata.h codec_interface.h codec_interface_public_api.h errordefs.h ssrc_head.h
  group maestro/streamer/cci/metadata/src/mp3
    ../../../../../../middleware/maestro/streamer/cci/metadata/src/mp3/: mp3_extractmetadata.c mp3_id3v2.c mp3_vbr.c mp3_id3v2.h mp3_id3v2_internal.h mp3_metadata.h
  group maestro/streamer/cci/metadata/src/adpcm
    ../../../../../../middleware/maestro/streamer/cci/metadata/src/adpcm/: adpcm_extractmetadata.c wav_common.c wav_metadata.h wavedata.h wavedefs.h
  group maestro/streamer/cci/metadata/src/opus
    ../../../../../../middleware/maestro/streamer/cci/metadata/src/opus/: opus_extractmetadata.c
  group maestro/streamer/cci/metadata/src/aac
    ../../../../../../middleware/maestro/streamer/cci/metadata/src/aac/: aac_extractmetadata.c
  group maestro/streamer/cci/metadata/src/flac
    ../../../../../../middleware/maestro/streamer/cci/metadata/src/flac/: flac_extractmetadata.c
  group maestro/streamer/core
    ../../../../../../middleware/maestro/streamer/core/: pad.h pipeline.h streamer.h streamer_element.h pad.c pipeline.c streamer.c streamer_element.c streamer_msg.c
  group maestro/streamer/decoders/cci_dec
    ../../../../../../middleware/maestro/streamer/decoders/cci_dec/: ccidec.h ccidec.c codec_interface.c codecextractmetadata.c
  group maestro/streamer/devices
    ../../../../../../middleware/maestro/streamer/devices/: audio_sink_pcmrtos.h audio_src_pcmrtos.h audio_sink_pcmrtos.c audio_src_pcmrtos.c
  group maestro/streamer/elements
    ../../../../../../middleware/maestro/streamer/elements/: audio_proc.h audio_sink.h audio_src.h decoder.h decoder_pads.h encoder.h file_sink.h file_src_freertos.h mem_sink.h mem_src.h netbuf_src.h vit_sink.h audio_proc.c audio_sink.c audio_src.c decoder.c decoder_pads.c file_sink.c file_src_freertos.c mem_sink.c vit_sink.c mem_src.c netbuf_src.c encoder.c
  group maestro/streamer/encoders/cei
    ../../../../../../middleware/maestro/streamer/encoders/cei/: cei.h cei_enctypes.h cei_table.h
  group maestro/streamer/encoders/opus
    ../../../../../../middleware/maestro/streamer/encoders/opus/: opusenc_cei.h opusenc_cei.c
  group maestro/streamer/parsers/cci
    ../../../../../../middleware/maestro/streamer/parsers/cci/: cci_codec_type_conversion.c
  group maestro/streamer/utils
    ../../../../../../middleware/maestro/streamer/utils/: file_utils.c general_utils.c maestro_logging.c ringbuffer.c
  group usb/host
    ../../../../../../middleware/usb/host/: usb_host_ehci.c usb_host_ehci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c usb_host.h usb_host_hci.h usb_host_devices.h usb_host_framework.h
  group usb/host/class
    ../../../../../../middleware/usb/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_msd.c usb_host_msd.h usb_host_msd_ufi.c
  group usb/phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group fatfs/source
    ../../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_usb_disk
    ../../../../../../middleware/fatfs/source/fsl_usb_disk/: fsl_usb_disk.h fsl_usb_disk_freertos.c
  group flash/mflash
    ../../../../../../components/flash/mflash/: mflash_file.h mflash_file.c mflash_common.h
  group flash/mflash/mimxrt1170evkb
    ../../../../../../components/flash/mflash/mimxrt1170evkb/: mflash_drv.h mflash_drv.c
  group mbedtls/include/mbedtls
    ../../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h psa_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/include/psa
    ../../../../../../middleware/mbedtls/include/psa/: crypto.h crypto_builtin_composites.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group mbedtls/library
    ../../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cmac.c common.h constant_time.c constant_time_internal.h constant_time_invasive.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_invasive.h entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c mps_common.h mps_error.h mps_reader.c mps_reader.h mps_trace.c mps_trace.h net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c ssl_tls13_keys.h threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/port/ksdk
    ../../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c ccm_alt.h ecp_alt.h ecp_alt.c ecp_curves_alt.c ecp_alt_ksdk.c threading_alt.h ksdk_mbedtls_config.h
  group wifi/wifidriver
    ../../../../../../middleware/wifi_nxp/wifidriver/: wifi-sdio.c mlan_11ac.c mlan_11ax.c mlan_11d.c mlan_11h.c mlan_11n.c mlan_11n_aggr.c mlan_11n_rxreorder.c mlan_11v.c mlan_action.c mlan_11k.c mlan_mbo.c mlan_api.c mlan_cfp.c mlan_cmdevt.c mlan_glue.c mlan_init.c mlan_join.c mlan_misc.c mlan_scan.c mlan_shim.c mlan_sta_cmd.c mlan_sta_cmdresp.c mlan_sta_event.c mlan_sta_ioctl.c mlan_sta_rx.c mlan_txrx.c mlan_uap_cmdevent.c mlan_uap_ioctl.c mlan_wmm.c wifi-debug.c wifi-debug.h wifi-internal.h wifi-mem.c wifi-uap.c wifi.c wifi_common.h wifi_pwrmgr.c wifi-wps.c wifi-sdio.h sdio.c sdio.h
  group wifi/wifidriver/incl
    ../../../../../../middleware/wifi_nxp/wifidriver/incl/: mlan.h mlan_11ac.h mlan_11ax.h mlan_11h.h mlan_11n.h mlan_11n_aggr.h mlan_11n_rxreorder.h mlan_11v.h mlan_action.h mlan_11k.h mlan_mbo.h mlan_api.h mlan_fw.h mlan_ieee.h mlan_init.h mlan_join.h mlan_main.h mlan_meas.h mlan_remap_mem_operations.h mlan_uap.h mlan_util.h mlan_wmm.h type_decls.h mlan_decl.h mlan_ioctl.h mlan_main_defs.h
  group wifi/wifidriver/wpa_supp_if
    ../../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if/: wifi_nxp.c rtos_wpa_supp_if.c wifi_nxp_internal.c
  group wifi/wifidriver/wpa_supp_if/incl
    ../../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if/incl/: rtos_wpa_supp_if.h wifi_nxp_internal.h
  group wifi/incl
    ../../../../../../middleware/wifi_nxp/incl/: dhcp-server.h wmstats.h wifi_cal_data_ext.h wm_utils.h wmerrno.h wmlog.h wmtypes.h WIFI_IW416_BOARD_AW_AM457_CAL_DATA_EXT.h
  group wifi/incl/wlcmgr
    ../../../../../../middleware/wifi_nxp/incl/wlcmgr/: wlan.h wlan_11d.h
  group wifi/incl/wifidriver
    ../../../../../../middleware/wifi_nxp/incl/wifidriver/: wifi_nxp.h wifi-decl.h wifi.h wifi_events.h
  group wifi/incl/port/lwip
    ../../../../../../middleware/wifi_nxp/incl/port/lwip/: wm_net.h
  group wifi/incl/port/lwip/hooks
    ../../../../../../middleware/wifi_nxp/incl/port/lwip/hooks/: lwip_default_hooks.h
  group wifi/incl/port/os
    ../../../../../../middleware/wifi_nxp/incl/port/os/: wm_os.h
  group wifi/certs
    ../../../../../../middleware/wifi_nxp/certs/: ca-cert.h client-cert.h client-key.h server-cert.h server-key.h dh-param.h
  group wifi/dhcpd
    ../../../../../../middleware/wifi_nxp/dhcpd/: dhcp-bootp.h dhcp-priv.h dhcp-server-main.c dhcp-server.c dns-server.c dns.h
  group wifi/port/lwip
    ../../../../../../middleware/wifi_nxp/port/lwip/: net.c netif_decl.h wifi_netif.c
  group wifi/port/lwip/hooks
    ../../../../../../middleware/wifi_nxp/port/lwip/hooks/: lwip_default_hooks.c
  group wifi/port/os
    ../../../../../../middleware/wifi_nxp/port/os/: os.c
  group wifi/wlcmgr
    ../../../../../../middleware/wifi_nxp/wlcmgr/: wlan.c wlan_txpwrlimit_cfg.c
  group wifi/sdio_nxp_abs
    ../../../../../../middleware/wifi_nxp/sdio_nxp_abs/: mlan_sdio.c fwdnld_sdio.c
  group wifi/sdio_nxp_abs/incl
    ../../../../../../middleware/wifi_nxp/sdio_nxp_abs/incl/: fwdnld_sdio.h mlan_sdio_defs.h mlan_sdio.h mlan_sdio_api.h
  group wifi/wifi_bt_firmware
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/: wlan_bt_fw.h
  group wifi/wifi_bt_firmware/8801
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/8801/: sd8801_wlan.h
  group wifi/wifi_bt_firmware/IW416
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/IW416/: sduartIW416_wlan_bt.h sdIW416_wlan.h uartIW416_bt.h
  group wifi/wifi_bt_firmware/8987
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/8987/: sduart8987_wlan_bt.h sd8987_wlan.h uart8987_bt.h
  group wifi/wifi_bt_firmware/nw61x
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/nw61x/: sduart_nw61x_se.h sd_nw61x_se.h uart_nw61x_se.h
  group wifi/firmware_dnld
    ../../../../../../middleware/wifi_nxp/firmware_dnld/: firmware_dnld.c firmware_dnld.h
  group wifi/fwdnld_intf_abs
    ../../../../../../middleware/wifi_nxp/fwdnld_intf_abs/: fwdnld_intf_abs.c fwdnld_intf_abs.h
  group aws_iot/device-shadow/source
    ../../../../../../middleware/aws_iot/device-shadow/source/: shadow.c
  group aws_iot/device-shadow/source/include
    ../../../../../../middleware/aws_iot/device-shadow/source/include/: shadow.h shadow_config_defaults.h
  group aws_iot/iot-reference/examples/common/kvstore
    ../../../../../../middleware/aws_iot/iot-reference/examples/common/kvstore/: kvstore.c kvstore.h
  group aws_iot/iot-reference/examples/common/logging
    ../../../../../../middleware/aws_iot/iot-reference/examples/common/logging/: logging.c logging.h logging_levels.h
  group aws_iot/iot-reference/examples/common/mqtt_agent
    ../../../../../../middleware/aws_iot/iot-reference/examples/common/mqtt_agent/: mqtt_agent_task.c mqtt_agent_task.h
  group aws_iot/iot-reference/mqtt-agent-interface
    ../../../../../../middleware/aws_iot/iot-reference/Middleware/FreeRTOS/mqtt-agent-interface/: freertos_agent_message.c freertos_command_pool.c
  group aws_iot/iot-reference/mqtt-agent-interface/include
    ../../../../../../middleware/aws_iot/iot-reference/Middleware/FreeRTOS/mqtt-agent-interface/include/: freertos_agent_message.h freertos_command_pool.h
  group aws_iot/iot-reference/FreeRTOS/transport_mbedtls
    ../../../../../../middleware/aws_iot/iot-reference/Middleware/FreeRTOS/transport_mbedtls/: using_mbedtls.c using_mbedtls.h
  group edgefast/bluetooth/include
    ../../../../../../middleware/edgefast_bluetooth/include/: toolchain.h
  group edgefast/bluetooth/include/sys
    ../../../../../../middleware/edgefast_bluetooth/include/sys/: util.h util_internal.h util_loops.h util_macro.h printk.h check.h byteorder.h ring_buffer.h ffs.h atomic.h slist.h dlist.h work_queue.h
  group edgefast/bluetooth/include/zephyr
    ../../../../../../middleware/edgefast_bluetooth/include/zephyr/: types.h
  group edgefast/bluetooth/include/bluetooth
    ../../../../../../middleware/edgefast_bluetooth/include/bluetooth/: a2dp.h avrcp.h a2dp_codec_sbc.h addr.h att.h avdtp.h bluetooth.h direction.h buf.h l2cap.h rfcomm.h spp.h sdp.h conn.h crypto.h gap.h gatt.h hci.h byteorder.h hci_types.h ead.h hci_raw.h hci_vs.h hfp_hf.h hfp_ag.h iso.h testing.h uuid.h
  group edgefast/bluetooth/include/net
    ../../../../../../middleware/edgefast_bluetooth/include/net/: buf.h
  group edgefast/bluetooth/include/toolchain
    ../../../../../../middleware/edgefast_bluetooth/include/toolchain/: common.h gcc.h iar.h armcc.h
  group edgefast/bluetooth/porting
    ../../../../../../middleware/edgefast_bluetooth/source/porting/: ring_buffer.c porting.c porting.h utf8.c atomic_c.c slist.c buf.c work_queue.c
  group edgefast/bluetooth/porting/errno
    ../../../../../../middleware/edgefast_bluetooth/source/porting/errno/: errno.h
  group edgefast/bluetooth/porting/fifo
    ../../../../../../middleware/edgefast_bluetooth/source/porting/fifo/: fifo.c fifo.h
  group edgefast/bluetooth/source/host
    ../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/host/: bt_pal_a2dp.c bt_pal_a2dp_internal.h bt_pal_avrcp.c bt_pal_avrcp_al_api.h bt_pal_avrcp_al_internal.c bt_pal_avrcp_al_internal.h bt_pal_avrcp_al_api.c bt_pal_avrcp_internal.h bt_pal_at.h bt_pal_att_internal.h bt_pal_avdtp_internal.h bt_pal_conn.c bt_pal_conn_internal.h bt_pal_data.c bt_pal_ead.c bt_pal_crypto.c bt_pal_crypto_internal.h bt_pal_gatt_internal.h bt_pal_hci_core.c bt_pal_hci_core.h bt_pal_adv.c bt_pal_adv.h bt_pal_br.c bt_pal_br.h bt_pal_id.c bt_pal_id.h bt_pal_scan.c bt_pal_scan.h bt_pal_ecc.c bt_pal_ecc.h bt_pal_addr.c bt_pal_addr_internal.h bt_pal_buf.c bt_pal_direction.c bt_pal_direction_internal.h bt_pal_hci_ecc.h bt_pal_keys.c bt_pal_keys.h bt_pal_keys_br.c bt_pal_l2cap.c bt_pal_l2cap_br.c bt_pal_l2cap_internal.h bt_pal_monitor.c bt_pal_monitor.h bt_pal_rfcomm.c bt_pal_rfcomm_internal.h bt_pal_spp.c bt_pal_rpa.c bt_pal_rpa.h bt_pal_settings.h bt_pal_settings.c bt_pal_sdp.c bt_pal_sdp_internal.h bt_pal_smp.c bt_pal_smp.h bt_pal_ssp.c bt_pal_ssp.h bt_pal_uuid.c bt_pal_hfp_ag.c bt_pal_hfp_hf.c bt_pal_hfp_internal.h
  group edgefast/bluetooth/source/host/a2dp_codec/sbc
    ../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/host/a2dp_codec/sbc/: a2dp_codec_sbc.c
  group edgefast/bluetooth/common
    ../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/common/: addr.c
  group edgefast/bluetooth/crypto
    ../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/crypto/: bt_crypto.c bt_crypto.h
  group edgefast_wifi/source
    ../../../../../../components/edgefast_wifi/source/: wpl_nxp.c
  group edgefast_wifi/include
    ../../../../../../components/edgefast_wifi/include/: wpl.h
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/IAR/ARM_CM4F
    ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/corejson/source
    ../../../../../../rtos/freertos/corejson/source/: core_json.c
  group freertos/corejson/source/include
    ../../../../../../rtos/freertos/corejson/source/include/: core_json.h
  group freertos/coremqtt/source
    ../../../../../../rtos/freertos/coremqtt/source/: core_mqtt.c core_mqtt_serializer.c core_mqtt_state.c
  group freertos/coremqtt/source/include
    ../../../../../../rtos/freertos/coremqtt/source/include/: core_mqtt.h core_mqtt_config_defaults.h core_mqtt_default_logging.h core_mqtt_serializer.h core_mqtt_state.h
  group freertos/coremqtt/source/interface
    ../../../../../../rtos/freertos/coremqtt/source/interface/: transport_interface.h
  group freertos/coremqtt-agent/source
    ../../../../../../rtos/freertos/coremqtt-agent/source/: core_mqtt_agent_command_functions.c core_mqtt_agent.c
  group freertos/coremqtt-agent/source/include
    ../../../../../../rtos/freertos/coremqtt-agent/source/include/: core_mqtt_agent.h core_mqtt_agent_command_functions.h core_mqtt_agent_config_defaults.h core_mqtt_agent_default_logging.h core_mqtt_agent_message_interface.h
  group freertos/corepkcs11/source
    ../../../../../../rtos/freertos/corepkcs11/source/: core_pkcs11.c core_pki_utils.c
  group freertos/corepkcs11/source/include
    ../../../../../../rtos/freertos/corepkcs11/source/include/: core_pkcs11.h core_pkcs11_config_defaults.h core_pkcs11_pal.h core_pki_utils.h
  group freertos/corepkcs11/source/portable/mbedtls
    ../../../../../../rtos/freertos/corepkcs11/source/portable/mbedtls/: core_pkcs11_mbedtls.c
  group freertos/corepkcs11/source/dependency/3rdparty/mbedtls_utils
    ../../../../../../rtos/freertos/corepkcs11/source/dependency/3rdparty/mbedtls_utils/: mbedtls_utils.c mbedtls_utils.h
  group freertos/backoffalgorithm/source
    ../../../../../../rtos/freertos/backoffalgorithm/source/: backoff_algorithm.c
  group freertos/backoffalgorithm/source/include
    ../../../../../../rtos/freertos/backoffalgorithm/source/include/: backoff_algorithm.h
  group lwip/port
    ../../../../../../middleware/lwip/port/: sys_arch.c
  group lwip/port/arch
    ../../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src/api
    ../../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/core
    ../../../../../../middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/src/core/ipv4
    ../../../../../../middleware/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/src/core/ipv6
    ../../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip/src/include/compat/posix
    ../../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/compat/posix/net
    ../../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/sys
    ../../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/stdc
    ../../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/lwip
    ../../../../../../middleware/lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/priv
    ../../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../../middleware/lwip/src/include/lwip/prot/: acd.h autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip/src/include/netif
    ../../../../../../middleware/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lwip/src/include/netif/ppp
    ../../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip/src/netif
    ../../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group pkcs11
    ../../../../../../middleware/pkcs11/: README.md pkcs11t.h pkcs11f.h pkcs11.h LICENSE.md CONTRIBUTING.md
  group littlefs
    ../../../../../../middleware/littlefs/: lfs.c lfs_util.c lfs.h lfs_util.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
