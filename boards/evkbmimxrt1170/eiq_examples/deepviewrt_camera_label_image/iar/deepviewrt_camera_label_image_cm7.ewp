# IAR project deepviewrt_camera_label_image_cm7.ewp, settings and files
configuration flexspi_nor_sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=0; XIP_BOOT_HEADER_XMCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; SDK_DEBUGCONSOLE_UART; _POSIX_C_SOURCE=200809L; ARM_MATH_CM7; __FPU_PRESENT=1; SDK_I2C_BASED_COMPONENT_USED=1; MCUXPRESSO_SDK; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1
  ICCARM.CCDiagSuppress: Pe111,Pe191,Pe167,Pe177,Pe236,Pe546,Pe550,Pa082,Pa050
  ICCARM.CCIncludePath2: ../source; ..; ../../../../../middleware/eiq/common; ../source/image; ../source/video; ../source/common; ../source/gprintf; ../../../../../components/video/camera/device; ../../../../../components/video/camera/receiver; ../../../../../components/video/camera/device/sccb; ../../../../../components/video/camera/device/ov5640; ../../../../../components/video/display/rm68191; ../../../../../components/video/display/rm68200; ../../../../../components/video/display/hx8394; ../../../../../components/video/camera; ../../../../../components/video/camera/receiver/csi; ../../../../../devices/MIMXRT1176/drivers; ../../../../../components/video; ../../../../../components/video/display/dc; ../../../../../components/video/display/dc/elcdif; ../../../../../components/video/display/dc/lcdifv2; ../../../../../components/video/display; ../../../../../components/video/display/mipi_dsi_cmd; ../../../../../devices/MIMXRT1176/utilities/str; ../../../../../devices/MIMXRT1176/utilities/debug_console_lite; ../../../../../middleware/eiq/deepviewrt/include; ../../../../../components/lists; ../../../../../components/uart; ../../../../../devices/MIMXRT1176; ../../../../../devices/MIMXRT1176/xip; ../../../xip; ../../../xmcd; ../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ../source
  ILINK.IlinkOutputFile: deepviewrt_camera_label_image_cm7.out
  ILINK.IlinkKeepSymbols: deepview_rtm_start
  ILINK.IlinkConfigDefines: __use_flash64MB__=1; __stack_size__=0x10000; __heap_size__=0x800000
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
  ILINK.IlinkExtraOptions: --diag_suppress=Lt009
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/eiq/deepviewrt/lib/deepview-rt-iar.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=0; XIP_BOOT_HEADER_XMCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; SDK_DEBUGCONSOLE_UART; _POSIX_C_SOURCE=200809L; ARM_MATH_CM7; __FPU_PRESENT=1; SDK_I2C_BASED_COMPONENT_USED=1; MCUXPRESSO_SDK; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: main.c demo_config.h image_data.h
    ../source/: timer.h timer.c
  group source/image
    ../source/image/: image_draw.c image_capture.c image_resize_nearest.c image_decode_raw.c image_utils.h image.h image_conv_rotate.c
  group source/video
    ../source/video/: eiq_camera_conf.c eiq_display_conf.c eiq_camera.h eiq_camera_conf.h eiq_display.h eiq_display_conf.h eiq_pxp.h eiq_video_worker.h eiq_camera.c eiq_display.c eiq_pxp.c eiq_video_worker.c
  group source/common
    ../source/common/: eiq_common.h eiq_iui.h eiq_iworker.h
  group source/gprintf
    ../source/gprintf/: chgui.h font.h chgui.c
  group startup
    ../startup/: demo_config.h
    ../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group board
    ../: pin_mux.c pin_mux.h board_init.c board_init.h board.c board.h dcd.c dcd.h clock_config.c clock_config.h board.c board.h
    ./: retarget.c
    ../../../xmcd/: xmcd.c xmcd.h
  group video
    ../../../../../components/video/camera/device/: fsl_camera_device.h
    ../../../../../components/video/camera/receiver/: fsl_camera_receiver.h
    ../../../../../components/video/camera/device/sccb/: fsl_sccb.h fsl_sccb.c
    ../../../../../components/video/camera/device/ov5640/: fsl_ov5640.h fsl_ov5640.c
    ../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../components/video/display/hx8394/: fsl_hx8394.h fsl_hx8394.c
    ../../../../../components/video/camera/: fsl_camera.h
    ../../../../../components/video/camera/receiver/csi/: fsl_csi_camera_adapter.h fsl_csi_camera_adapter.c
    ../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../components/video/display/dc/: fsl_dc_fb.h
    ../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.h fsl_dc_fb_elcdif.c
    ../../../../../components/video/display/dc/lcdifv2/: fsl_dc_fb_lcdifv2.h fsl_dc_fb_lcdifv2.c
    ../../../../../components/video/display/: fsl_display.h
    ../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
  group drivers
    ../../../../../devices/MIMXRT1176/drivers/: fsl_csi.c fsl_csi.h fsl_elcdif.c fsl_elcdif.h fsl_pxp.c fsl_pxp.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_gpio.h fsl_gpio.c fsl_lpi2c.c fsl_lpi2c.h fsl_mipi_csi2rx.c fsl_mipi_csi2rx.h fsl_soc_mipi_csi2rx.h fsl_soc_mipi_csi2rx.c fsl_soc_src.h fsl_soc_src.c fsl_lpuart.h fsl_lpuart.c fsl_dcdc.h fsl_dcdc.c fsl_pmu.h fsl_pmu.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_iomuxc.h fsl_memory.h fsl_lcdifv2.c fsl_lcdifv2.h fsl_soc_mipi_dsi.h fsl_anatop_ai.h fsl_anatop_ai.c
  group utilities
    ../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c fsl_assert.h
  group eiq/deepviewrt
    ../../../../../middleware/eiq/deepviewrt/: readme.txt
  group eiq/deepviewrt/include
    ../../../../../middleware/eiq/deepviewrt/include/: deepview_ops.h deepview_rpc.h deepview_rt.h mathrt.h stb_image.h stb_image_resize.h stb_image_write.h
  group eiq/deepviewrt/lib
    ../../../../../middleware/eiq/deepviewrt/lib/: LICENSE.txt
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group device
    ../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group xip
    ../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkbmimxrt1170_flexspi_nor_config.c evkbmimxrt1170_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
  group doc
    ../: readme.md
