<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/tflm_lib_cm7.ewp</path>
  </project>
</workspace>
