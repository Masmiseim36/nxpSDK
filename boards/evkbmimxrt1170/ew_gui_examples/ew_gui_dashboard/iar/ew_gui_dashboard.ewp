# IAR project ew_gui_dashboard.ewp, settings and files
configuration flexspi_nor_sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=0; XIP_BOOT_HEADER_XMCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; SKIP_SYSCLK_INIT; EW_SURFACE_ROTATION=90; EW_USE_FREE_RTOS=1; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; VG_COMMAND_CALL=1; VG_TARGET_FAST_CLEAR=0; SDK_OS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../vglite_examples/vglite_support; ..; ../cm7; ../GeneratedCode; ../../../../../devices/MIMXRT1176/drivers; ../../../../../components/ft5406_rt; ../../../../../components/video; ../../../../../components/video/display; ../../../../../components/video/display/rm68191; ../../../../../components/video/display/mipi_dsi_cmd; ../../../../../components/video/display/rm68200; ../../../../../components/video/display/dc/lcdifv2; ../../../../../components/gt911; ../../../../../components/video/display/dc/elcdif; ../../../../../devices/MIMXRT1176/utilities/str; ../../../../../devices/MIMXRT1176/utilities/debug_console_lite; ../../../../../components/video/display/fbdev; ../../../../../middleware/vglite/inc; ../../../../../middleware/vglite/font; ../../../../../middleware/vglite/font/mcufont/decoder; ../../../../../middleware/vglite/VGLite/rtos; ../../../../../middleware/vglite/VGLiteKernel; ../../../../../middleware/vglite/VGLiteKernel/rtos; ../../../../../components/video/display/hx8394; ../../../../../middleware/EmbeddedWizard/TargetSpecific/evkbmimxrt1170; ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkbmimxrt1170/RGB565; ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkbmimxrt1170/RTE; ../../../../../devices/MIMXRT1176; ../../../../../components/uart; ../../../../../components/lists; ../../../../../devices/MIMXRT1176/xip; ../../../xip; ../../../../../devices/MIMXRT1176/drivers/cm7; ../../../xmcd; ../../../../../components/video/display/dc; ../../../../../rtos/freertos/freertos-kernel/include; ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F; ../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_CLEAR_BSS; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ../cm7
  ILINK.IlinkOutputFile: ew_gui_dashboard.out
  ILINK.IlinkConfigDefines: __use_flash64MB__=1
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkbmimxrt1170/RTE/libewrte-m7-iar.a; ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkbmimxrt1170/RGB565/libewgfx-m7-r90-iar.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=0; XIP_BOOT_HEADER_XMCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; SKIP_SYSCLK_INIT; EW_SURFACE_ROTATION=90; EW_USE_FREE_RTOS=1; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; VG_COMMAND_CALL=1; VG_TARGET_FAST_CLEAR=0; SDK_OS_FREE_RTOS
  AARM.ADefines: NDEBUG; __STARTUP_CLEAR_BSS; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../: display_support.h display_support.c ewconfig.h ewdef.h pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
    ../../../vglite_examples/vglite_support/: vglite_support.h vglite_support.c
    ../../../xmcd/: xmcd.c xmcd.h
  group source
    ../: main.c ewmain.c ewmain.h DeviceDriver.c DeviceDriver.h
    ../cm7/: FreeRTOSConfig.h
  group GeneratedCode
    ../GeneratedCode/: Application.c Core.c Dashboard.c Effects.c Graphics.c Resources.c Templates.c Views.c WidgetSet.c Application.h Core.h Dashboard.h Effects.h Graphics.h Resources.h Templates.h Views.h WidgetSet.h _ApplicationApplication.h _CoreCursorEvent.h _CoreCursorGrabEvent.h _CoreCursorHit.h _CoreDialogContext.h _CoreDragEvent.h _CoreEvent.h _CoreGroup.h _CoreKeyEvent.h _CoreKeyPressHandler.h _CoreLayoutContext.h _CoreLayoutLineContext.h _CoreLayoutQuadContext.h _CoreLineView.h _CoreModalContext.h _CoreOutline.h _CoreQuadView.h _CoreRectView.h _CoreResource.h _CoreRoot.h _CoreSimpleTouchHandler.h _CoreTask.h _CoreTaskQueue.h _CoreTime.h _CoreTimer.h _CoreView.h _DashboardAnimationClass.h _DashboardArrows.h _DashboardBattery.h _DashboardBatteryEnergy.h _DashboardBatteryFrame.h _DashboardCircle0.h _DashboardCircle1.h _DashboardCircle2.h _DashboardCircle3.h _DashboardCircle4.h _DashboardCircle5.h _DashboardClock.h _DashboardColorsClass.h _DashboardDashboard.h _DashboardDashboardV1.h _DashboardDashboardV2.h _DashboardDemoMode.h _DashboardDeviceClass.h _DashboardFontL.h _DashboardFontLightL.h _DashboardFontLightM.h _DashboardFontLightXL.h _DashboardFontXL.h _DashboardFontXXL.h _DashboardGauge.h _DashboardGaugeDisplay.h _DashboardGaugeGlowSegment.h _DashboardGaugeIndicator.h _DashboardGaugeLabels.h _DashboardGaugeNeedle.h _DashboardIcons.h _DashboardLeftBottomGloomV1.h _DashboardLeftGlowV2.h _DashboardLeftWing2V2.h _DashboardLeftWingV2.h _DashboardLogo.h _DashboardMap.h _DashboardMapFading.h _DashboardNavigation.h _DashboardNavigationHints.h _DashboardOffIcon.h _DashboardPosition.h _DashboardRightBottomGloomV1.h _DashboardRightGlowV2.h _DashboardRightWing2V2.h _DashboardRightWingV2.h _DashboardStartEngine.h _DashboardStartEngineGloom.h _DashboardStartEngineStates.h _DashboardStartScreen.h _DashboardSwitchIcon.h _DashboardTopGloomV1.h _DashboardVertValueBar.h _EffectsEffect.h _EffectsEffectTimerClass.h _EffectsFadeInOutTransition.h _EffectsFader.h _EffectsFaderTask.h _EffectsFloatEffect.h _EffectsInt32Effect.h _EffectsOpacityFader.h _EffectsPointEffect.h _EffectsPositionFader.h _EffectsShowHideTransition.h _EffectsTimingList.h _EffectsTransition.h _EffectsVisibilityFader.h _GraphicsArcPath.h _GraphicsCanvas.h _GraphicsPath.h _GraphicsWarpMatrix.h _ResourcesBitmap.h _ResourcesDefaultFont.h _ResourcesFont.h _ResourcesWhiteBitmapStripe.h _TemplatesHorizontalValueBar.h _TemplatesVerticalValueBar.h _ViewsFillPath.h _ViewsFrame.h _ViewsImage.h _ViewsLine.h _ViewsRectangle.h _ViewsStrokePath.h _ViewsText.h _ViewsWallpaper.h _ViewsWarpGroup.h _ViewsWarpImage.h _ViewsWarpView.h _WidgetSetPushButton.h _WidgetSetPushButtonConfig.h _WidgetSetToggleButton.h _WidgetSetToggleButtonConfig.h _WidgetSetValueDisplay.h _WidgetSetValueDisplayConfig.h _WidgetSetWidgetConfig.h ewlocale.h
  group doc
    ../: readme.md
  group evkbmimxrt1170
    ../: evkbmimxrt1170_connect_cm4_cm7side.jlinkscript
  group drivers
    ../../../../../devices/MIMXRT1176/drivers/: fsl_elcdif.c fsl_elcdif.h fsl_pxp.c fsl_pxp.h fsl_lpi2c.c fsl_lpi2c.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_soc_src.h fsl_soc_src.c fsl_snvs_hp.c fsl_snvs_hp.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_gpc.h fsl_gpc.c fsl_mu.h fsl_mu.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_memory.h fsl_soc_mipi_dsi.h fsl_soc_mipi_csi2rx.h fsl_soc_mipi_csi2rx.c fsl_lcdifv2.c fsl_lcdifv2.h fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group touchpanel
    ../../../../../components/ft5406_rt/: fsl_ft5406_rt.h fsl_ft5406_rt.c
    ../../../../../components/gt911/: fsl_gt911.h fsl_gt911.c
  group video
    ../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../components/video/display/: fsl_display.h
    ../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
    ../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../components/video/display/dc/lcdifv2/: fsl_dc_fb_lcdifv2.h fsl_dc_fb_lcdifv2.c
    ../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.h fsl_dc_fb_elcdif.c
    ../../../../../components/video/display/fbdev/: fsl_fbdev.h fsl_fbdev.c
    ../../../../../components/video/display/hx8394/: fsl_hx8394.h fsl_hx8394.c
    ../../../../../components/video/display/dc/: fsl_dc_fb.h
  group utilities
    ../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c fsl_assert.h
  group freertos/freertos-kernel
    ../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/portable
    ../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos-kernel/portable/IAR/ARM_CM4F
    ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos-kernel/include
    ../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group vglite
    ../../../../../middleware/vglite/: ChangeLogKSDK.txt
  group vglite/inc
    ../../../../../middleware/vglite/inc/: vg_lite.h vg_lite_hal.h vg_lite_text.h nxp_support.h
  group vglite/VGLite
    ../../../../../middleware/vglite/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c nxp_support.c vg_lite_flat.h vg_lite_flat.c
  group vglite/VGLite/rtos
    ../../../../../middleware/vglite/VGLite/rtos/: vg_lite_os.h vg_lite_os.c
  group vglite/font
    ../../../../../middleware/vglite/font/: buf_reader.c buf_reader.h fonts.h rle_font_read.c vft_debug.c vft_debug.h vft_draw.c vft_draw.h vg_lite_text.c
  group vglite/font/mcufont
    ../../../../../middleware/vglite/font/mcufont/: LICENSE
  group vglite/font/mcufont/decoder
    ../../../../../middleware/vglite/font/mcufont/decoder/: mcufont.h mf_bwfont.c mf_bwfont.h mf_config.h mf_encoding.c mf_encoding.h mf_font.c mf_font.h mf_justify.c mf_justify.h mf_kerning.c mf_kerning.h mf_rlefont.c mf_rlefont.h mf_scaledfont.c mf_scaledfont.h mf_wordwrap.c mf_wordwrap.h
  group vglite/VGLiteKernel
    ../../../../../middleware/vglite/VGLiteKernel/: vg_lite_hw.h vg_lite_kernel.h vg_lite_kernel.c
  group vglite/VGLiteKernel/rtos
    ../../../../../middleware/vglite/VGLiteKernel/rtos/: vg_lite_hal.c vg_lite_platform.h
  group EmbeddedWizard/TargetSpecific/evkbmimxrt1170
    ../../../../../middleware/EmbeddedWizard/TargetSpecific/evkbmimxrt1170/: ew_bsp_clock.c ew_bsp_console.c ew_bsp_display.c ew_bsp_event.c ew_bsp_inout.c ew_bsp_system.c ew_bsp_touch.c ew_bsp_clock.h ew_bsp_console.h ew_bsp_display.h ew_bsp_event.h ew_bsp_inout.h ew_bsp_system.h ew_bsp_touch.h
  group EmbeddedWizard/PlatformPackage/evkbmimxrt1170/RGB565
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkbmimxrt1170/RGB565/: ewextbmp.h ewextfnt.h ewextgfx.h ewextpxl_RGB565.h ewgfx.h ewgfxcore.h ewgfxdefs.h ewgfxdriver.h ewgfxlinks.h ewgfxres.h ewgfxtasks.h
  group EmbeddedWizard/PlatformPackage/evkbmimxrt1170/RTE
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkbmimxrt1170/RTE/: ewextrte.c ewextrte.h ewrte.h
  group device
    ../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group xip
    ../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkbmimxrt1170_flexspi_nor_config.c evkbmimxrt1170_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
