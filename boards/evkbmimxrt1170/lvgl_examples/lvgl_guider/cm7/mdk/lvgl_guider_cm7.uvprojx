# Keil uVision project lvgl_guider_cm7.uvprojx, settings and files
target lvgl_guider_cm7 flexspi_nor_sdram_debug (ARM-ADS)
  device: MIMXRT1176DVMAB:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: lvgl_guider_cm7.out
  AfterMake: fromelf.exe --output "$Llvgl_guider.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, XIP_EXTERNAL_FLASH=1, USE_SDRAM=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_XMCD_ENABLE=1, SKIP_SYSCLK_INIT=1, DATA_SECTION_IS_CACHEABLE=1, GCID_REV_CID=gc355/0x0_1216, CUSTOM_VGLITE_MEMORY_CONFIG=0, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, SDK_I2C_BASED_COMPONENT_USED=1, CPU_MIMXRT1176DVMAB_cm7, MIMXRT1176_cm7_SERIES, LV_CONF_INCLUDE_SIMPLE=1, SDK_OS_FREE_RTOS
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb  -fms-extensions -fno-exceptions
  c include: ..;../generated;../custom;../generated/guider_customer_fonts;../../../../xip;../../../../../../devices/MIMXRT1176/xip;../../../../../../devices/MIMXRT1176/drivers;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MIMXRT1176;../../../../../../devices/MIMXRT1176/periph;../../../../../../devices/MIMXRT1176/drivers/cm7;../../../../../../devices/MIMXRT1176/utilities/debug_console_lite;../../../../../../devices/MIMXRT1176/utilities/str;../../../../../../components/uart;../../../../../../components/video;../../../../../../components/video/display/dc;../../../../../../components/video/display;../../../../../../components/video/display/fbdev;../../../../../../components/video/display/dc/elcdif;../../../../../../components/video/display/dc/lcdifv2;../../../../../../components/video/display/mipi_dsi_cmd;../../../../../../components/video/display/hx8394;../../../../../../components/video/display/rm68191;../../../../../../components/video/display/rm68200;../../../../../../components/video/display/rpi;../../../../../../components/touch/gt911;../../../../../../components/touch/ft5406_rt;../../../../../../middleware/vglite/driver/inc;../../../../../../middleware/vglite/driver/VGLite;../../../../../../middleware/vglite/driver/VGLite/rtos;../../../../../../middleware/vglite/driver/VGLite/Series/gc555/0x423_ECO;../../../../../../middleware/vglite/driver/VGLite/Series/gc355/0x0_1216;../../../../../../middleware/vglite/driver/VGLite/Series/gc255/0x40A;../../../../../../middleware/vglite/driver/VGLiteKernel;../../../../../../middleware/vglite/driver/VGLiteKernel/rtos;../../../../../../middleware/lvgl;../../../../../../middleware/lvgl/src/draw/nxp/vglite;../../../../../../middleware/lvgl/template;../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F;../../../../../../rtos/freertos/freertos-kernel/template
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1176DVMAB_cm7, MIMXRT1176_cm7_SERIES
  asm include: ..;../../../../xip;../../../../../../devices/MIMXRT1176/xip;../../../../../../devices/MIMXRT1176/drivers;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MIMXRT1176;../../../../../../devices/MIMXRT1176/periph;../../../../../../devices/MIMXRT1176/drivers/cm7;../../../../../../devices/MIMXRT1176/utilities/debug_console_lite;../../../../../../devices/MIMXRT1176/utilities/str;../../../../../../components/uart;../../../../../../components/video;../../../../../../components/video/display/dc;../../../../../../components/video/display;../../../../../../components/video/display/fbdev;../../../../../../components/video/display/dc/elcdif;../../../../../../components/video/display/dc/lcdifv2;../../../../../../components/video/display/mipi_dsi_cmd;../../../../../../components/video/display/hx8394;../../../../../../components/video/display/rm68191;../../../../../../components/video/display/rm68200;../../../../../../components/video/display/rpi;../../../../../../components/touch/gt911;../../../../../../components/touch/ft5406_rt;../../../../../../middleware/vglite/driver/inc;../../../../../../middleware/vglite/driver/VGLite;../../../../../../middleware/vglite/driver/VGLite/rtos;../../../../../../middleware/vglite/driver/VGLite/Series/gc555/0x423_ECO;../../../../../../middleware/vglite/driver/VGLite/Series/gc355/0x0_1216;../../../../../../middleware/vglite/driver/VGLite/Series/gc255/0x40A;../../../../../../middleware/vglite/driver/VGLiteKernel;../../../../../../middleware/vglite/driver/VGLiteKernel/rtos;../../../../../../middleware/lvgl;../../../../../../middleware/lvgl/src/draw/nxp/vglite;../../../../../../middleware/lvgl/template;../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F;../../../../../../rtos/freertos/freertos-kernel/template
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.scf
  link misc: --remove --predefine=\"-DXIP_BOOT_HEADER_ENABLE=1\" --predefine=\"-DXIP_BOOT_HEADER_XMCD_ENABLE=1\" --predefine=\"-D__use_flash64MB__=1\" --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: lvgl_guider.c lv_conf_ext.h lvgl_demo_utils.c lvgl_demo_utils.h lvgl_freertos.c lvgl_freertos.h FreeRTOSConfig_frag.h pin_mux.c pin_mux.h hardware_init.c app.h display_support.h display_support.c vglite_support.h vglite_support.c lv_conf.h lvgl_support.h lvgl_support.c FreeRTOSConfig_Gen.h mcux_config.h
  group generated/guider_customer_fonts
    ../generated/guider_customer_fonts/: guider_customer_fonts.h
  group generated
    ../generated/: gui_guider.c gui_guider.h events_init.c events_init.h setup_scr_screen.c widgets_init.c widgets_init.h
  group custom
    ../custom/: custom.c custom.h
  group board
    ../: board.h board.c clock_config.h clock_config.c
  group xip
    ../../../../xip/: evkbmimxrt1170_flexspi_nor_config.c evkbmimxrt1170_flexspi_nor_config.h
    ../../../../: dcd.c dcd.h xmcd.c xmcd.h
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_soc_mipi_csi2rx.c fsl_soc_mipi_csi2rx.h fsl_soc_mipi_dsi.h fsl_anatop_ai.c fsl_anatop_ai.h fsl_memory.h fsl_dcdc.c fsl_dcdc.h fsl_gpc.c fsl_gpc.h fsl_pgmc.h fsl_pgmc.c fsl_pmu.h fsl_pmu.c fsl_soc_src.c fsl_soc_src.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_elcdif.c fsl_elcdif.h fsl_gpio.h fsl_gpio.c fsl_lcdifv2.c fsl_lcdifv2.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.h fsl_lpuart.c fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_mu.h fsl_mu.c fsl_pxp.c fsl_pxp.h
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv7m_cachel1.h armv7m_mpu.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_COMMON.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group device/periph
    ../../../../../../devices/MIMXRT1176/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_ANADIG_LDO_SNVS.h PERI_ANADIG_LDO_SNVS_DIG.h PERI_ANADIG_MISC.h PERI_ANADIG_OSC.h PERI_ANADIG_PLL.h PERI_ANADIG_PMU.h PERI_ANADIG_TEMPSENSOR.h PERI_AOI.h PERI_ASRC.h PERI_AUDIO_PLL.h PERI_CAAM.h PERI_CAN.h PERI_CAN_WRAPPER.h PERI_CCM.h PERI_CCM_OBS.h PERI_CDOG.h PERI_CMP.h PERI_CSI.h PERI_DAC.h PERI_DCDC.h PERI_DCIC.h PERI_DMA.h PERI_DMAMUX.h PERI_DSI_HOST.h PERI_DSI_HOST_APB_PKT_IF.h PERI_DSI_HOST_DPI_INTFC.h PERI_DSI_HOST_NXP_FDSOI28_DPHY_INTFC.h PERI_EMVSIM.h PERI_ENC.h PERI_ENET.h PERI_ENET_QOS.h PERI_ETHERNET_PLL.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC_CPU_MODE_CTRL.h PERI_GPC_SET_POINT_CTRL.h PERI_GPC_STBY_CTRL.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IEE.h PERI_IEE_APC.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_LPSR.h PERI_IOMUXC_LPSR_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_IPS_DOMAIN.h PERI_KEY_MANAGER.h PERI_KPP.h PERI_LCDIF.h PERI_LCDIFV2.h PERI_LMEM.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_MCM.h PERI_MECC.h PERI_MIPI_CSI2RX.h PERI_MMCAU.h PERI_MU.h PERI_OCOTP.h PERI_OSC_RC_400M.h PERI_OTFAD.h PERI_PDM.h PERI_PGMC_BPC.h PERI_PGMC_CPC.h PERI_PGMC_MIF.h PERI_PGMC_PPC.h PERI_PHY_LDO.h PERI_PIT.h PERI_PUF.h PERI_PWM.h PERI_PXP.h PERI_RDC.h PERI_RDC_SEMAPHORE.h PERI_RTWDOG.h PERI_SEMA4.h PERI_SEMC.h PERI_SNVS.h PERI_SPDIF.h PERI_SRAM.h PERI_SRC.h PERI_SSARC_HP.h PERI_SSARC_LP.h PERI_TMPSNS.h PERI_TMR.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_VIDEO_MUX.h PERI_VIDEO_PLL.h PERI_VMBANDGAP.h PERI_WDOG.h PERI_XBARA.h PERI_XBARB.h PERI_XECC.h PERI_XRDC2.h
  group startup/arm
    ../../../../../../devices/MIMXRT1176/arm/: startup_MIMXRT1176_cm7.S
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
    ../../../../../../devices/MIMXRT1176/utilities/: fsl_memcpy.S
  group utilities/str
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group video
    ../../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../../components/video/display/dc/: fsl_dc_fb.h
    ../../../../../../components/video/display/: fsl_display.h
    ../../../../../../components/video/display/fbdev/: fsl_fbdev.h fsl_fbdev.c
    ../../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.h fsl_dc_fb_elcdif.c
    ../../../../../../components/video/display/dc/lcdifv2/: fsl_dc_fb_lcdifv2.h fsl_dc_fb_lcdifv2.c
    ../../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
    ../../../../../../components/video/display/hx8394/: fsl_hx8394.h fsl_hx8394.c
    ../../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../../components/video/display/rpi/: fsl_rpi.h fsl_rpi.c
  group touchpanel
    ../../../../../../components/touch/gt911/: fsl_gt911.h fsl_gt911.c
    ../../../../../../components/touch/ft5406_rt/: fsl_ft5406_rt.h fsl_ft5406_rt.c
  group vglite/inc
    ../../../../../../middleware/vglite/driver/inc/: vg_lite.h
  group vglite/VGLite
    ../../../../../../middleware/vglite/driver/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_stroke.c vg_lite_options.h vg_lite_context.h
  group vglite/VGLite/rtos
    ../../../../../../middleware/vglite/driver/VGLite/rtos/: vg_lite_os.c
  group vglite/VGLite/Series/gc555/0x423_ECO
    ../../../../../../middleware/vglite/driver/VGLite/Series/gc555/0x423_ECO/: vg_lite_options.h
  group vglite/VGLite/Series/gc355/0x0_1216
    ../../../../../../middleware/vglite/driver/VGLite/Series/gc355/0x0_1216/: vg_lite_options.h
  group vglite/VGLite/Series/gc255/0x40A
    ../../../../../../middleware/vglite/driver/VGLite/Series/gc255/0x40A/: vg_lite_options.h
  group vglite/VGLiteKernel
    ../../../../../../middleware/vglite/driver/VGLiteKernel/: vg_lite_hal.h vg_lite_hw.h vg_lite_kernel.c vg_lite_kernel.h vg_lite_option.h vg_lite_type.h vg_lite_debug.h
  group vglite/VGLiteKernel/rtos
    ../../../../../../middleware/vglite/driver/VGLiteKernel/rtos/: vg_lite_hal.c vg_lite_platform.h
  group vglite
    ../../../../../../middleware/vglite/driver/: RELEASE_NOTES.txt LICENSE.txt
  group lvgl/src
    ../../../../../../middleware/lvgl/src/: lv_init.c lv_api_map_v8.h lv_api_map_v9_0.h lv_api_map_v9_1.h lv_conf_internal.h lv_conf_kconfig.h lv_init.h lvgl.h lvgl_private.h
  group lvgl/src/core
    ../../../../../../middleware/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_global.h lv_group.h lv_group_private.h lv_obj.h lv_obj_class.h lv_obj_class_private.h lv_obj_draw.h lv_obj_draw_private.h lv_obj_event.h lv_obj_event_private.h lv_obj_pos.h lv_obj_private.h lv_obj_property.h lv_obj_scroll.h lv_obj_scroll_private.h lv_obj_style.h lv_obj_style_gen.h lv_obj_style_private.h lv_obj_tree.h lv_refr.h lv_refr_private.h
  group lvgl/src/display
    ../../../../../../middleware/lvgl/src/display/: lv_display.c lv_display.h lv_display_private.h
  group lvgl/src/draw
    ../../../../../../middleware/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c lv_draw.h lv_draw_arc.h lv_draw_buf.h lv_draw_buf_private.h lv_draw_image.h lv_draw_image_private.h lv_draw_label.h lv_draw_label_private.h lv_draw_line.h lv_draw_mask.h lv_draw_mask_private.h lv_draw_private.h lv_draw_rect.h lv_draw_rect_private.h lv_draw_triangle.h lv_draw_triangle_private.h lv_draw_vector.h lv_draw_vector_private.h lv_image_decoder.h lv_image_decoder_private.h lv_image_dsc.h
  group lvgl/src/draw/nxp/pxp
    ../../../../../../middleware/lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c lv_draw_pxp.h lv_pxp_cfg.h lv_pxp_osa.h lv_pxp_utils.h
  group lvgl/src/draw/nxp/vglite
    ../../../../../../middleware/lvgl/src/draw/nxp/vglite/: lv_draw_buf_vglite.c lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_border.c lv_draw_vglite_fill.c lv_draw_vglite_img.c lv_draw_vglite_label.c lv_draw_vglite_layer.c lv_draw_vglite_line.c lv_draw_vglite_triangle.c lv_vglite_buf.c lv_vglite_matrix.c lv_vglite_path.c lv_vglite_utils.c lv_draw_vglite.h lv_vglite_buf.h lv_vglite_matrix.h lv_vglite_path.h lv_vglite_utils.h
  group lvgl/src/draw/sdl
    ../../../../../../middleware/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl.h
  group lvgl/src/draw/sw/blend
    ../../../../../../middleware/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c lv_draw_sw_blend.h lv_draw_sw_blend_private.h lv_draw_sw_blend_to_al88.h lv_draw_sw_blend_to_argb8888.h lv_draw_sw_blend_to_i1.h lv_draw_sw_blend_to_l8.h lv_draw_sw_blend_to_rgb565.h lv_draw_sw_blend_to_rgb888.h
  group lvgl/src/draw/sw
    ../../../../../../middleware/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c lv_draw_sw.h lv_draw_sw_gradient.h lv_draw_sw_gradient_private.h lv_draw_sw_mask.h lv_draw_sw_mask_private.h lv_draw_sw_private.h
  group lvgl/src/drivers/display/drm
    ../../../../../../middleware/lvgl/src/drivers/display/drm/: lv_linux_drm.c lv_linux_drm.h
  group lvgl/src/drivers/display/fb
    ../../../../../../middleware/lvgl/src/drivers/display/fb/: lv_linux_fbdev.c lv_linux_fbdev.h
  group lvgl/src/drivers/display/ili9341
    ../../../../../../middleware/lvgl/src/drivers/display/ili9341/: lv_ili9341.c lv_ili9341.h
  group lvgl/src/drivers/display/lcd
    ../../../../../../middleware/lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c lv_lcd_generic_mipi.h
  group lvgl/src/drivers/display/st7735
    ../../../../../../middleware/lvgl/src/drivers/display/st7735/: lv_st7735.c lv_st7735.h
  group lvgl/src/drivers/display/st7789
    ../../../../../../middleware/lvgl/src/drivers/display/st7789/: lv_st7789.c lv_st7789.h
  group lvgl/src/drivers/display/st7796
    ../../../../../../middleware/lvgl/src/drivers/display/st7796/: lv_st7796.c lv_st7796.h
  group lvgl/src/drivers/evdev
    ../../../../../../middleware/lvgl/src/drivers/evdev/: lv_evdev.c lv_evdev.h
  group lvgl/src/drivers/libinput
    ../../../../../../middleware/lvgl/src/drivers/libinput/: lv_libinput.c lv_xkb.c lv_libinput.h lv_libinput_private.h lv_xkb.h lv_xkb_private.h
  group lvgl/src/drivers/nuttx
    ../../../../../../middleware/lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c lv_nuttx_cache.h lv_nuttx_entry.h lv_nuttx_fbdev.h lv_nuttx_image_cache.h lv_nuttx_lcd.h lv_nuttx_libuv.h lv_nuttx_profiler.h lv_nuttx_touchscreen.h
  group lvgl/src/drivers/sdl
    ../../../../../../middleware/lvgl/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_window.c lv_sdl_keyboard.h lv_sdl_mouse.h lv_sdl_mousewheel.h lv_sdl_private.h lv_sdl_window.h
  group lvgl/src/drivers/windows
    ../../../../../../middleware/lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c lv_windows_context.h lv_windows_display.h lv_windows_input.h lv_windows_input_private.h
  group lvgl/src/drivers/x11
    ../../../../../../middleware/lvgl/src/drivers/x11/: lv_x11_display.c lv_x11_input.c lv_x11.h
  group lvgl/src/drivers/glfw
    ../../../../../../middleware/lvgl/src/drivers/glfw/: lv_glfw_window.c lv_opengles_debug.c lv_opengles_driver.c lv_opengles_texture.c lv_glfw_window.h lv_glfw_window_private.h lv_opengles_debug.h lv_opengles_driver.h lv_opengles_texture.h
  group lvgl/src/drivers/qnx
    ../../../../../../middleware/lvgl/src/drivers/qnx/: lv_qnx.c lv_qnx.h
  group lvgl/src/drivers/wayland
    ../../../../../../middleware/lvgl/src/drivers/wayland/: lv_wayland.c lv_wayland_smm.c lv_wayland.h lv_wayland_smm.h
  group lvgl/src/font
    ../../../../../../middleware/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_binfont_loader.h lv_font.h lv_font_fmt_txt.h lv_font_fmt_txt_private.h lv_symbol_def.h
  group lvgl/src/indev
    ../../../../../../middleware/lvgl/src/indev/: lv_indev.c lv_indev_scroll.c lv_indev.h lv_indev_private.h lv_indev_scroll.h
  group lvgl/src/layouts/flex
    ../../../../../../middleware/lvgl/src/layouts/flex/: lv_flex.c lv_flex.h
  group lvgl/src/layouts/grid
    ../../../../../../middleware/lvgl/src/layouts/grid/: lv_grid.c lv_grid.h
  group lvgl/src/layouts
    ../../../../../../middleware/lvgl/src/layouts/: lv_layout.c lv_layout.h lv_layout_private.h
  group lvgl/src/libs/barcode
    ../../../../../../middleware/lvgl/src/libs/barcode/: code128.c lv_barcode.c code128.h lv_barcode.h lv_barcode_private.h
  group lvgl/src/libs/bin_decoder
    ../../../../../../middleware/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c lv_bin_decoder.h
  group lvgl/src/libs/bmp
    ../../../../../../middleware/lvgl/src/libs/bmp/: lv_bmp.c lv_bmp.h
  group lvgl/src/libs/ffmpeg
    ../../../../../../middleware/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c lv_ffmpeg.h lv_ffmpeg_private.h
  group lvgl/src/libs/freetype
    ../../../../../../middleware/lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c ftmodule.h ftoption.h lv_freetype.h lv_freetype_private.h
  group lvgl/src/libs/fsdrv
    ../../../../../../middleware/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_rawfs.c lv_fs_stdio.c lv_fs_win32.c lv_fsdrv.h
  group lvgl/src/libs/gif
    ../../../../../../middleware/lvgl/src/libs/gif/: gifdec.c lv_gif.c gifdec.h gifdec_mve.h lv_gif.h lv_gif_private.h
  group lvgl/src/libs/libjpeg_turbo
    ../../../../../../middleware/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c lv_libjpeg_turbo.h
  group lvgl/src/libs/libpng
    ../../../../../../middleware/lvgl/src/libs/libpng/: lv_libpng.c lv_libpng.h
  group lvgl/src/libs/lodepng
    ../../../../../../middleware/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c lodepng.h lv_lodepng.h
  group lvgl/src/libs/lz4
    ../../../../../../middleware/lvgl/src/libs/lz4/: lz4.c lz4.h
  group lvgl/src/libs/qrcode
    ../../../../../../middleware/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c lv_qrcode.h lv_qrcode_private.h qrcodegen.h
  group lvgl/src/libs/rle
    ../../../../../../middleware/lvgl/src/libs/rle/: lv_rle.c lv_rle.h
  group lvgl/src/libs/rlottie
    ../../../../../../middleware/lvgl/src/libs/rlottie/: lv_rlottie.c lv_rlottie.h lv_rlottie_private.h
  group lvgl/src/libs/tiny_ttf
    ../../../../../../middleware/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c lv_tiny_ttf.h stb_rect_pack.h stb_truetype_htcw.h
  group lvgl/src/libs/tjpgd
    ../../../../../../middleware/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c lv_tjpgd.h tjpgd.h tjpgdcnf.h
  group lvgl/src/misc/cache
    ../../../../../../middleware/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c lv_cache_lru_rb.c lv_image_cache.c lv_image_header_cache.c lv_cache.h lv_cache_entry.h lv_cache_entry_private.h lv_cache_lru_rb.h lv_cache_private.h lv_image_cache.h lv_image_header_cache.h
  group lvgl/src/misc
    ../../../../../../middleware/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_utils.c lv_anim.h lv_anim_private.h lv_anim_timeline.h lv_area.h lv_area_private.h lv_array.h lv_assert.h lv_async.h lv_bidi.h lv_bidi_private.h lv_color.h lv_color_op.h lv_color_op_private.h lv_event.h lv_event_private.h lv_fs.h lv_fs_private.h lv_ll.h lv_log.h lv_lru.h lv_math.h lv_matrix.h lv_palette.h lv_profiler.h lv_profiler_builtin.h lv_profiler_builtin_private.h lv_rb.h lv_rb_private.h lv_style.h lv_style_gen.h lv_style_private.h lv_templ.h lv_text.h lv_text_ap.h lv_text_private.h lv_timer.h lv_timer_private.h lv_types.h lv_utils.h
  group lvgl/src/osal
    ../../../../../../middleware/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_windows.c lv_cmsis_rtos2.h lv_freertos.h lv_linux_private.h lv_mqx.h lv_os.h lv_os_none.h lv_os_private.h lv_pthread.h lv_rtthread.h lv_windows.h
  group lvgl/src/others/file_explorer
    ../../../../../../middleware/lvgl/src/others/file_explorer/: lv_file_explorer.c lv_file_explorer.h lv_file_explorer_private.h
  group lvgl/src/others/fragment
    ../../../../../../middleware/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c lv_fragment.h lv_fragment_private.h
  group lvgl/src/others/gridnav
    ../../../../../../middleware/lvgl/src/others/gridnav/: lv_gridnav.c lv_gridnav.h
  group lvgl/src/others/ime
    ../../../../../../middleware/lvgl/src/others/ime/: lv_ime_pinyin.c lv_ime_pinyin.h lv_ime_pinyin_private.h
  group lvgl/src/others/imgfont
    ../../../../../../middleware/lvgl/src/others/imgfont/: lv_imgfont.c lv_imgfont.h
  group lvgl/src/others/monkey
    ../../../../../../middleware/lvgl/src/others/monkey/: lv_monkey.c lv_monkey.h lv_monkey_private.h
  group lvgl/src/others/observer
    ../../../../../../middleware/lvgl/src/others/observer/: lv_observer.c lv_observer.h lv_observer_private.h
  group lvgl/src/others/snapshot
    ../../../../../../middleware/lvgl/src/others/snapshot/: lv_snapshot.c lv_snapshot.h
  group lvgl/src/others/sysmon
    ../../../../../../middleware/lvgl/src/others/sysmon/: lv_sysmon.c lv_sysmon.h lv_sysmon_private.h
  group lvgl/src/others/vg_lite_tvg
    ../../../../../../middleware/lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c vg_lite.h
  group lvgl/src/stdlib/builtin
    ../../../../../../middleware/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c lv_tlsf.h lv_tlsf_private.h
  group lvgl/src/stdlib/clib
    ../../../../../../middleware/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
  group lvgl/src/stdlib
    ../../../../../../middleware/lvgl/src/stdlib/: lv_mem.c lv_mem.h lv_mem_private.h lv_sprintf.h lv_string.h
  group lvgl/src/stdlib/micropython
    ../../../../../../middleware/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
  group lvgl/src/stdlib/rtthread
    ../../../../../../middleware/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
  group lvgl/src/themes/default
    ../../../../../../middleware/lvgl/src/themes/default/: lv_theme_default.c lv_theme_default.h
  group lvgl/src/themes
    ../../../../../../middleware/lvgl/src/themes/: lv_theme.c lv_theme.h lv_theme_private.h
  group lvgl/src/themes/mono
    ../../../../../../middleware/lvgl/src/themes/mono/: lv_theme_mono.c lv_theme_mono.h
  group lvgl/src/themes/simple
    ../../../../../../middleware/lvgl/src/themes/simple/: lv_theme_simple.c lv_theme_simple.h
  group lvgl/src/tick
    ../../../../../../middleware/lvgl/src/tick/: lv_tick.c lv_tick.h lv_tick_private.h
  group lvgl/src/widgets/animimage
    ../../../../../../middleware/lvgl/src/widgets/animimage/: lv_animimage.c lv_animimage.h lv_animimage_private.h
  group lvgl/src/widgets/arc
    ../../../../../../middleware/lvgl/src/widgets/arc/: lv_arc.c lv_arc.h lv_arc_private.h
  group lvgl/src/widgets/bar
    ../../../../../../middleware/lvgl/src/widgets/bar/: lv_bar.c lv_bar.h lv_bar_private.h
  group lvgl/src/widgets/button
    ../../../../../../middleware/lvgl/src/widgets/button/: lv_button.c lv_button.h lv_button_private.h
  group lvgl/src/widgets/buttonmatrix
    ../../../../../../middleware/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c lv_buttonmatrix.h lv_buttonmatrix_private.h
  group lvgl/src/widgets/calendar
    ../../../../../../middleware/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c lv_calendar.h lv_calendar_chinese.h lv_calendar_chinese_private.h lv_calendar_header_arrow.h lv_calendar_header_dropdown.h lv_calendar_private.h
  group lvgl/src/widgets/carousel
    ../../../../../../middleware/lvgl/src/widgets/carousel/: lv_carousel.c lv_carousel.h lv_carousel_private.h
  group lvgl/src/widgets/canvas
    ../../../../../../middleware/lvgl/src/widgets/canvas/: lv_canvas.c lv_canvas.h lv_canvas_private.h
  group lvgl/src/widgets/chart
    ../../../../../../middleware/lvgl/src/widgets/chart/: lv_chart.c lv_chart.h lv_chart_private.h
  group lvgl/src/widgets/checkbox
    ../../../../../../middleware/lvgl/src/widgets/checkbox/: lv_checkbox.c lv_checkbox.h lv_checkbox_private.h
  group lvgl/src/widgets/dropdown
    ../../../../../../middleware/lvgl/src/widgets/dropdown/: lv_dropdown.c lv_dropdown.h lv_dropdown_private.h
  group lvgl/src/widgets/image
    ../../../../../../middleware/lvgl/src/widgets/image/: lv_image.c lv_image.h lv_image_private.h
  group lvgl/src/widgets/imagebutton
    ../../../../../../middleware/lvgl/src/widgets/imagebutton/: lv_imagebutton.c lv_imagebutton.h lv_imagebutton_private.h
  group lvgl/src/widgets/keyboard
    ../../../../../../middleware/lvgl/src/widgets/keyboard/: lv_keyboard.c lv_keyboard.h lv_keyboard_private.h
  group lvgl/src/widgets/label
    ../../../../../../middleware/lvgl/src/widgets/label/: lv_label.c lv_label.h lv_label_private.h
  group lvgl/src/widgets/led
    ../../../../../../middleware/lvgl/src/widgets/led/: lv_led.c lv_led.h lv_led_private.h
  group lvgl/src/widgets/line
    ../../../../../../middleware/lvgl/src/widgets/line/: lv_line.c lv_line.h lv_line_private.h
  group lvgl/src/widgets/list
    ../../../../../../middleware/lvgl/src/widgets/list/: lv_list.c lv_list.h
  group lvgl/src/widgets/lottie
    ../../../../../../middleware/lvgl/src/widgets/lottie/: lv_lottie.c lv_lottie.h lv_lottie_private.h
  group lvgl/src/widgets/menu
    ../../../../../../middleware/lvgl/src/widgets/menu/: lv_menu.c lv_menu.h lv_menu_private.h
  group lvgl/src/widgets/msgbox
    ../../../../../../middleware/lvgl/src/widgets/msgbox/: lv_msgbox.c lv_msgbox.h lv_msgbox_private.h
  group lvgl/src/widgets/objx_templ
    ../../../../../../middleware/lvgl/src/widgets/objx_templ/: lv_objx_templ.c lv_objx_templ.h
  group lvgl/src/widgets/roller
    ../../../../../../middleware/lvgl/src/widgets/roller/: lv_roller.c lv_roller.h lv_roller_private.h
  group lvgl/src/widgets/scale
    ../../../../../../middleware/lvgl/src/widgets/scale/: lv_scale.c lv_scale.h lv_scale_private.h
  group lvgl/src/widgets/slider
    ../../../../../../middleware/lvgl/src/widgets/slider/: lv_slider.c lv_slider.h lv_slider_private.h
  group lvgl/src/widgets/span
    ../../../../../../middleware/lvgl/src/widgets/span/: lv_span.c lv_span.h lv_span_private.h
  group lvgl/src/widgets/spinbox
    ../../../../../../middleware/lvgl/src/widgets/spinbox/: lv_spinbox.c lv_spinbox.h lv_spinbox_private.h
  group lvgl/src/widgets/spinner
    ../../../../../../middleware/lvgl/src/widgets/spinner/: lv_spinner.c lv_spinner.h
  group lvgl/src/widgets/switch
    ../../../../../../middleware/lvgl/src/widgets/switch/: lv_switch.c lv_switch.h lv_switch_private.h
  group lvgl/src/widgets/table
    ../../../../../../middleware/lvgl/src/widgets/table/: lv_table.c lv_table.h lv_table_private.h
  group lvgl/src/widgets/tabview
    ../../../../../../middleware/lvgl/src/widgets/tabview/: lv_tabview.c lv_tabview.h lv_tabview_private.h
  group lvgl/src/widgets/textarea
    ../../../../../../middleware/lvgl/src/widgets/textarea/: lv_textarea.c lv_textarea.h lv_textarea_private.h
  group lvgl/src/widgets/tileview
    ../../../../../../middleware/lvgl/src/widgets/tileview/: lv_tileview.c lv_tileview.h lv_tileview_private.h
  group lvgl/src/widgets/win
    ../../../../../../middleware/lvgl/src/widgets/win/: lv_win.c lv_win.h lv_win_private.h
  group lvgl/src/draw/sw/arm2d
    ../../../../../../middleware/lvgl/src/draw/sw/arm2d/: lv_draw_sw_arm2d.h lv_draw_sw_helium.h
  group lvgl/src/draw/sw/blend/arm2d
    ../../../../../../middleware/lvgl/src/draw/sw/blend/arm2d/: lv_blend_arm2d.h
  group lvgl/src/draw/sw/blend/neon
    ../../../../../../middleware/lvgl/src/draw/sw/blend/neon/: lv_blend_neon.h
  group lvgl/src/drivers
    ../../../../../../middleware/lvgl/src/drivers/: lv_drivers.h
  group lvgl/src/drivers/display/tft_espi
    ../../../../../../middleware/lvgl/src/drivers/display/tft_espi/: lv_tft_espi.h
  group lvgl/src/libs/thorvg
    ../../../../../../middleware/lvgl/src/libs/thorvg/: config.h thorvg.h thorvg_capi.h thorvg_lottie.h tvgAnimation.h tvgArray.h tvgBinaryDesc.h tvgCanvas.h tvgCommon.h tvgCompressor.h tvgFill.h tvgFrameModule.h tvgInlist.h tvgIteratorAccessor.h tvgLines.h tvgLoadModule.h tvgLoader.h tvgLock.h tvgLottieBuilder.h tvgLottieExpressions.h tvgLottieInterpolator.h tvgLottieLoader.h tvgLottieModel.h tvgLottieParser.h tvgLottieParserHandler.h tvgLottieProperty.h tvgMath.h tvgPaint.h tvgPicture.h tvgRawLoader.h tvgRender.h tvgSaveModule.h tvgScene.h tvgShape.h tvgStr.h tvgSvgCssStyle.h tvgSvgLoader.h tvgSvgLoaderCommon.h tvgSvgPath.h tvgSvgSceneBuilder.h tvgSvgUtil.h tvgSwCommon.h tvgSwRasterAvx.h tvgSwRasterC.h tvgSwRasterNeon.h tvgSwRasterTexmap.h tvgSwRenderer.h tvgTaskScheduler.h tvgText.h tvgXmlParser.h
  group lvgl
    ../../../../../../middleware/lvgl/: lv_conf_template.h lv_version.h lvgl.h
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/GCC/ARM_CM4F
    ../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos/freertos-kernel/template
    ../../../../../../rtos/freertos/freertos-kernel/template/: FreeRTOSConfig.h
  group doc
    ../: readme.md lvgl_examples_readme.md examples_shared_readme.md
target lvgl_guider_cm7 flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1176DVMAB:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: lvgl_guider_cm7.out
  AfterMake: fromelf.exe --output "$Llvgl_guider.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, XIP_EXTERNAL_FLASH=1, USE_SDRAM=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_XMCD_ENABLE=1, SKIP_SYSCLK_INIT=1, DATA_SECTION_IS_CACHEABLE=1, GCID_REV_CID=gc355/0x0_1216, CUSTOM_VGLITE_MEMORY_CONFIG=0, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, SDK_I2C_BASED_COMPONENT_USED=1, CPU_MIMXRT1176DVMAB_cm7, MIMXRT1176_cm7_SERIES, LV_CONF_INCLUDE_SIMPLE=1, SDK_OS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.scf
  link misc: as above
