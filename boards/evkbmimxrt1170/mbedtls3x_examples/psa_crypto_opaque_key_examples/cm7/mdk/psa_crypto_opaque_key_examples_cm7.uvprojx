# Keil uVision project psa_crypto_opaque_key_examples_cm7.uvprojx, settings and files
target psa_crypto_opaque_key_examples_cm7 debug (ARM-ADS)
  device: MIMXRT1176DVMAB:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: psa_crypto_opaque_key_examples_cm7.out
  AfterMake: fromelf.exe --output "$Lpsa_crypto_opaque_key_examples.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, MULADDC_CANNOT_USE_R7, MBEDTLS_USER_CONFIG_FILE='\"mbedtls_user_config.h\"', MBEDTLS_CONFIG_FILE='\"mcux_mbedtls_psa_crypto_opaque_config.h\"', SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1176DVMAB_cm7, MIMXRT1176_cm7_SERIES, CRYPTO_USE_DRIVER_CAAM, CACHE_MODE_WRITE_THROUGH=1, PSA_CRYPTO_DRIVER_CAAM, MBEDTLS_PSA_ITS_RAM
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../xip;../../../../../../devices/MIMXRT1176/xip;../../../../../../devices/MIMXRT1176/drivers;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MIMXRT1176;../../../../../../devices/MIMXRT1176/periph;../../../../../../devices/MIMXRT1176/drivers/cm7;../../../../../../devices/MIMXRT1176/utilities/debug_console_lite;../../../../../../devices/MIMXRT1176/utilities/str;../../../../../../components/uart;../../../../../../components/psa_crypto_driver/osal;../../../../../../components/psa_crypto_driver/osal/baremetal;../../../../../../components/psa_crypto_driver/caam;../../../../../../components/psa_crypto_driver/caam/include;../../../../../../components/psa_crypto_driver/caam/common/include;../../../../../../middleware/mbedtls3x/include;../../../../../../middleware/mbedtls3x/library;../../../../../../middleware/mbedtls3x/port
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1176DVMAB_cm7, MIMXRT1176_cm7_SERIES
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_ram_ocram.scf
  link misc: --remove --predefine="-D__stack_size__=0x4000" --predefine="-D__heap_size__=0x1c000" --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: psa_crypto_opaque_key_examples.c mcux_mbedtls_psa_crypto_opaque_config.h mbedtls_user_config.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group xip
    ../../../../xip/: evkbmimxrt1170_flexspi_nor_config.c evkbmimxrt1170_flexspi_nor_config.h
    ../../../../: dcd.c dcd.h xmcd.c xmcd.h
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_anatop_ai.c fsl_anatop_ai.h fsl_memory.h fsl_dcdc.c fsl_dcdc.h fsl_gpc.c fsl_gpc.h fsl_pgmc.h fsl_pgmc.c fsl_pmu.h fsl_pmu.c fsl_soc_src.c fsl_soc_src.h fsl_caam.c fsl_caam.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_mu.h fsl_mu.c
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv7m_cachel1.h armv7m_mpu.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_COMMON.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group device/periph
    ../../../../../../devices/MIMXRT1176/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_ANADIG_LDO_SNVS.h PERI_ANADIG_LDO_SNVS_DIG.h PERI_ANADIG_MISC.h PERI_ANADIG_OSC.h PERI_ANADIG_PLL.h PERI_ANADIG_PMU.h PERI_ANADIG_TEMPSENSOR.h PERI_AOI.h PERI_ASRC.h PERI_AUDIO_PLL.h PERI_CAAM.h PERI_CAN.h PERI_CAN_WRAPPER.h PERI_CCM.h PERI_CCM_OBS.h PERI_CDOG.h PERI_CMP.h PERI_CSI.h PERI_DAC.h PERI_DCDC.h PERI_DCIC.h PERI_DMA.h PERI_DMAMUX.h PERI_DSI_HOST.h PERI_DSI_HOST_APB_PKT_IF.h PERI_DSI_HOST_DPI_INTFC.h PERI_DSI_HOST_NXP_FDSOI28_DPHY_INTFC.h PERI_EMVSIM.h PERI_ENC.h PERI_ENET.h PERI_ENET_QOS.h PERI_ETHERNET_PLL.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC_CPU_MODE_CTRL.h PERI_GPC_SET_POINT_CTRL.h PERI_GPC_STBY_CTRL.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IEE.h PERI_IEE_APC.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_LPSR.h PERI_IOMUXC_LPSR_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_IPS_DOMAIN.h PERI_KEY_MANAGER.h PERI_KPP.h PERI_LCDIF.h PERI_LCDIFV2.h PERI_LMEM.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_MCM.h PERI_MECC.h PERI_MIPI_CSI2RX.h PERI_MMCAU.h PERI_MU.h PERI_OCOTP.h PERI_OSC_RC_400M.h PERI_OTFAD.h PERI_PDM.h PERI_PGMC_BPC.h PERI_PGMC_CPC.h PERI_PGMC_MIF.h PERI_PGMC_PPC.h PERI_PHY_LDO.h PERI_PIT.h PERI_PUF.h PERI_PWM.h PERI_PXP.h PERI_RDC.h PERI_RDC_SEMAPHORE.h PERI_RTWDOG.h PERI_SEMA4.h PERI_SEMC.h PERI_SNVS.h PERI_SPDIF.h PERI_SRAM.h PERI_SRC.h PERI_SSARC_HP.h PERI_SSARC_LP.h PERI_TMPSNS.h PERI_TMR.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_VIDEO_MUX.h PERI_VIDEO_PLL.h PERI_VMBANDGAP.h PERI_WDOG.h PERI_XBARA.h PERI_XBARB.h PERI_XECC.h PERI_XRDC2.h
  group startup/arm
    ../../../../../../devices/MIMXRT1176/arm/: startup_MIMXRT1176_cm7.S
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
    ../../../../../../devices/MIMXRT1176/utilities/: fsl_memcpy.S
  group utilities/str
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/psa_crypto_driver/osal
    ../../../../../../components/psa_crypto_driver/osal/: osal_mutex.h
  group component/psa_crypto_driver/osal/baremetal
    ../../../../../../components/psa_crypto_driver/osal/baremetal/: osal_mutex.c osal_mutex_platform.h
  group component/psa_crypto_driver/caam
    ../../../../../../components/psa_crypto_driver/caam/: caam_crypto_primitives.h caam.h
  group component/psa_crypto_driver/caam/src
    ../../../../../../components/psa_crypto_driver/caam/src/: mcux_psa_caam_common_aead.c mcux_psa_caam_common_asymmetric_encryption.c mcux_psa_caam_common_asymmetric_signature.c mcux_psa_caam_common_cipher.c mcux_psa_caam_common_init.c mcux_psa_caam_common_key_generation.c mcux_psa_caam_common_mac.c mcux_psa_caam_entropy.c mcux_psa_caam_hash.c mcux_psa_caam_init.c mcux_psa_caam_utils.c
  group component/psa_crypto_driver/caam/include
    ../../../../../../components/psa_crypto_driver/caam/include/: mcux_psa_caam_common_aead.h mcux_psa_caam_common_asymmetric_encryption.h mcux_psa_caam_common_asymmetric_signature.h mcux_psa_caam_common_cipher.h mcux_psa_caam_common_init.h mcux_psa_caam_common_key_generation.h mcux_psa_caam_common_mac.h mcux_psa_caam_entropy.h mcux_psa_caam_hash.h mcux_psa_caam_init.h mcux_psa_caam_utils.h
  group component/psa_crypto_driver/caam/common/src
    ../../../../../../components/psa_crypto_driver/caam/common/src/: mcux_psa_common_key_management.c mcux_psa_mbedtls_origin.c
  group component/psa_crypto_driver/caam/common/include
    ../../../../../../components/psa_crypto_driver/caam/common/include/: mcux_psa_common_key_management.h mcux_psa_mbedtls_origin.h
  group mbedtls3x/include/mbedtls
    ../../../../../../middleware/mbedtls3x/include/mbedtls/: aes.h aria.h asn1.h asn1write.h base64.h bignum.h block_cipher.h build_info.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cipher.h cmac.h compat-2.x.h config_adjust_legacy_crypto.h config_adjust_legacy_from_psa.h config_adjust_psa_from_legacy.h config_adjust_psa_superset_legacy.h config_adjust_ssl.h config_adjust_x509.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h error.h gcm.h hkdf.h hmac_drbg.h lms.h mbedtls_config.h md.h md5.h memory_buffer_alloc.h nist_kw.h oid.h pem.h pk.h pkcs5.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h private_access.h psa_util.h ripemd160.h rsa.h sha1.h sha3.h sha256.h sha512.h threading.h timing.h version.h pkcs7.h x509.h x509_crl.h x509_crt.h x509_csr.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_ticket.h net_sockets.h
  group mbedtls3x/include/psa
    ../../../../../../middleware/mbedtls3x/include/psa/: build_info.h crypto.h crypto_adjust_auto_enabled.h crypto_adjust_config_dependencies.h crypto_adjust_config_key_pair_types.h crypto_adjust_config_synonyms.h crypto_builtin_composites.h crypto_builtin_key_derivation.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_key_derivation.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_legacy.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group mbedtls3x/library
    ../../../../../../middleware/mbedtls3x/library/: aes.c aesni.c aesni.h alignment.h aesce.c aesce.h aria.c asn1parse.c asn1write.c base64.c base64_internal.h bignum.c bignum_core.h bignum_core.c bignum_core_invasive.h bignum_internal.h bignum_mod.c bignum_mod.h bignum_mod_raw.c bignum_mod_raw.h bignum_mod_raw_invasive.h block_cipher.c block_cipher_internal.h bn_mul.h camellia.c ccm.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cipher_wrap.h cmac.c common.h constant_time.c constant_time_impl.h constant_time_internal.h ctr_drbg.c ctr.h des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_curves_new.c ecp_internal_alt.h ecp_invasive.h entropy.c entropy_poll.c entropy_poll.h error.c gcm.c hkdf.c hmac_drbg.c lmots.c lmots.h lms.c md.c md_psa.h md_wrap.h md5.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c padlock.h pem.c pk.c pk_ecc.c pk_internal.h pk_wrap.c pk_wrap.h pkcs5.c pkcs12.c pkparse.c pkwrite.c pkwrite.h platform.c platform_util.c poly1305.c psa_crypto_aead.h psa_crypto_cipher.h psa_crypto_core.h psa_crypto_core_common.h psa_crypto_driver_wrappers_no_static.h psa_crypto_driver_wrappers.h psa_crypto_ecp.h psa_crypto_ffdh.h psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.h psa_crypto_pake.h psa_crypto_random_impl.h psa_crypto_rsa.h psa_crypto_se.h psa_crypto_slot_management.h psa_crypto_storage.h psa_util_internal.h psa_util.c ripemd160.c rsa.c rsa_alt_helpers.c rsa_alt_helpers.h rsa_internal.h sha1.c sha3.c sha256.c sha512.c threading.c timing.c version.c version_features.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers_no_static.c psa_crypto_ecp.c psa_crypto_ffdh.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_pake.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write.c x509write_crt.c x509write_csr.c x509_internal.h pkcs7.c debug.c debug_internal.h mps_common.h mps_error.h mps_reader.c mps_reader.h mps_trace.c mps_trace.h net_sockets.c ssl_cache.c ssl_ciphersuites.c ssl_ciphersuites_internal.h ssl_client.c ssl_client.h ssl_cookie.c ssl_debug_helpers.h ssl_debug_helpers_generated.c ssl_misc.h ssl_msg.c ssl_ticket.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_invasive.h ssl_tls13_keys.c ssl_tls13_keys.h ssl_tls13_server.c psa_crypto_its.h
  group mbedtls3x/port
    ../../../../../../middleware/mbedtls3x/port/: mcux_mbedtls_config.h mcux_mbedtls_accelerator_config.h mcux_mbedtls_config.h mcux_mbedtls_accelerator_config.h mcux_psa_defines.h mcux_mbedtls_psa_crypto_config.h mcux_mbedtls_accelerator_config.h mcux_psa_defines.h
  group mbedtls3x/port/psa_its
    ../../../../../../middleware/mbedtls3x/port/psa_its/: psa_its_ram.c
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
target psa_crypto_opaque_key_examples_cm7 sdram_debug (ARM-ADS)
  device: MIMXRT1176DVMAB:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: psa_crypto_opaque_key_examples_cm7.out
  AfterMake: as above
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, USE_SDRAM=1, SKIP_SYSCLK_INIT=1, DATA_SECTION_IS_CACHEABLE=1, MULADDC_CANNOT_USE_R7, MBEDTLS_USER_CONFIG_FILE='\"mbedtls_user_config.h\"', MBEDTLS_CONFIG_FILE='\"mcux_mbedtls_psa_crypto_opaque_config.h\"', SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1176DVMAB_cm7, MIMXRT1176_cm7_SERIES, CRYPTO_USE_DRIVER_CAAM, CACHE_MODE_WRITE_THROUGH=1, PSA_CRYPTO_DRIVER_CAAM, MBEDTLS_PSA_ITS_RAM
  c misc: as above
  c include: as above
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_sdram.scf
  link misc: as above
target psa_crypto_opaque_key_examples_cm7 flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1176DVMAB:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: psa_crypto_opaque_key_examples_cm7.out
  AfterMake: as above
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, MULADDC_CANNOT_USE_R7, MBEDTLS_USER_CONFIG_FILE='\"mbedtls_user_config.h\"', MBEDTLS_CONFIG_FILE='\"mcux_mbedtls_psa_crypto_opaque_config.h\"', SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1176DVMAB_cm7, MIMXRT1176_cm7_SERIES, CRYPTO_USE_DRIVER_CAAM, CACHE_MODE_WRITE_THROUGH=1, PSA_CRYPTO_DRIVER_CAAM, MBEDTLS_PSA_ITS_RAM
  c misc: as above
  c include: as above
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor_ocram.scf
  link misc: --remove --predefine=\"-DXIP_BOOT_HEADER_ENABLE=1\" --predefine=\"-D__use_flash64MB__=1\" --predefine="-D__stack_size__=0x4000" --predefine="-D__heap_size__=0x1c000" --entry=Reset_Handler --info=sizes,totals,unused,veneers
target psa_crypto_opaque_key_examples_cm7 release (ARM-ADS)
  device: MIMXRT1176DVMAB:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: psa_crypto_opaque_key_examples_cm7.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, MULADDC_CANNOT_USE_R7, MBEDTLS_USER_CONFIG_FILE='\"mbedtls_user_config.h\"', MBEDTLS_CONFIG_FILE='\"mcux_mbedtls_psa_crypto_opaque_config.h\"', SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1176DVMAB_cm7, MIMXRT1176_cm7_SERIES, CRYPTO_USE_DRIVER_CAAM, CACHE_MODE_WRITE_THROUGH=1, PSA_CRYPTO_DRIVER_CAAM, MBEDTLS_PSA_ITS_RAM
  c misc: as above
  c include: as above
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_ram_ocram.scf
  link misc: as above
target psa_crypto_opaque_key_examples_cm7 sdram_release (ARM-ADS)
  device: MIMXRT1176DVMAB:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: psa_crypto_opaque_key_examples_cm7.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, USE_SDRAM=1, SKIP_SYSCLK_INIT=1, DATA_SECTION_IS_CACHEABLE=1, MULADDC_CANNOT_USE_R7, MBEDTLS_USER_CONFIG_FILE='\"mbedtls_user_config.h\"', MBEDTLS_CONFIG_FILE='\"mcux_mbedtls_psa_crypto_opaque_config.h\"', SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1176DVMAB_cm7, MIMXRT1176_cm7_SERIES, CRYPTO_USE_DRIVER_CAAM, CACHE_MODE_WRITE_THROUGH=1, PSA_CRYPTO_DRIVER_CAAM, MBEDTLS_PSA_ITS_RAM
  c misc: as above
  c include: as above
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_sdram.scf
  link misc: as above
target psa_crypto_opaque_key_examples_cm7 flexspi_nor_release (ARM-ADS)
  device: MIMXRT1176DVMAB:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: psa_crypto_opaque_key_examples_cm7.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, MULADDC_CANNOT_USE_R7, MBEDTLS_USER_CONFIG_FILE='\"mbedtls_user_config.h\"', MBEDTLS_CONFIG_FILE='\"mcux_mbedtls_psa_crypto_opaque_config.h\"', SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1176DVMAB_cm7, MIMXRT1176_cm7_SERIES, CRYPTO_USE_DRIVER_CAAM, CACHE_MODE_WRITE_THROUGH=1, PSA_CRYPTO_DRIVER_CAAM, MBEDTLS_PSA_ITS_RAM
  c misc: as above
  c include: as above
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor_ocram.scf
  link misc: as above
