# IAR project mbedtls_selftest_cm7.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; FREESCALE_KSDK_BM; MBEDTLS_CONFIG_FILE="ksdk_mbedtls_config.h"; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1176DVMAB_cm7; MIMXRT1176_cm7_SERIES; CRYPTO_USE_DRIVER_CAAM; CACHE_MODE_WRITE_THROUGH=1
  ICCARM.CCDiagSuppress: Pa167,Pe177,Pe191,Pe546
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../xip; ../../../../../../devices/MIMXRT1176/xip; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT1176; ../../../../../../devices/MIMXRT1176/periph; ../../../../../../devices/MIMXRT1176/drivers/cm7; ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite; ../../../../../../devices/MIMXRT1176/utilities/str; ../../../../../../components/uart; ../../../../../../middleware/mbedtls/include; ../../../../../../middleware/mbedtls/library; ../../../../../../middleware/mbedtls/port/ksdk
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT1176DVMAB_cm7; MIMXRT1176_cm7_SERIES
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mbedtls_selftest.bin
  ILINK.IlinkOutputFile: mbedtls_selftest_cm7.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x8000
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_ram_ocram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; USE_SDRAM=1; SKIP_SYSCLK_INIT=1; DATA_SECTION_IS_CACHEABLE=1; FREESCALE_KSDK_BM; MBEDTLS_CONFIG_FILE="ksdk_mbedtls_config.h"; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1176DVMAB_cm7; MIMXRT1176_cm7_SERIES; CRYPTO_USE_DRIVER_CAAM; CACHE_MODE_WRITE_THROUGH=1
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; FREESCALE_KSDK_BM; MBEDTLS_CONFIG_FILE="ksdk_mbedtls_config.h"; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1176DVMAB_cm7; MIMXRT1176_cm7_SERIES; CRYPTO_USE_DRIVER_CAAM; CACHE_MODE_WRITE_THROUGH=1
  ILINK.IlinkConfigDefines: __use_flash64MB__=1; __stack_size__=0x2000; __heap_size__=0x8000
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor_ocram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; FREESCALE_KSDK_BM; MBEDTLS_CONFIG_FILE="ksdk_mbedtls_config.h"; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1176DVMAB_cm7; MIMXRT1176_cm7_SERIES; CRYPTO_USE_DRIVER_CAAM; CACHE_MODE_WRITE_THROUGH=1
  ICCARM.CCOptLevel: 3
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_SDRAM=1; SKIP_SYSCLK_INIT=1; DATA_SECTION_IS_CACHEABLE=1; FREESCALE_KSDK_BM; MBEDTLS_CONFIG_FILE="ksdk_mbedtls_config.h"; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1176DVMAB_cm7; MIMXRT1176_cm7_SERIES; CRYPTO_USE_DRIVER_CAAM; CACHE_MODE_WRITE_THROUGH=1
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; FREESCALE_KSDK_BM; MBEDTLS_CONFIG_FILE="ksdk_mbedtls_config.h"; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1176DVMAB_cm7; MIMXRT1176_cm7_SERIES; CRYPTO_USE_DRIVER_CAAM; CACHE_MODE_WRITE_THROUGH=1
  ICCARM.CCOptLevel: 3
  ILINK.IlinkConfigDefines: as above
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor_ocram.icf
  group source
    ../: selftest.c mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group xip
    ../../../../xip/: evkbmimxrt1170_flexspi_nor_config.c evkbmimxrt1170_flexspi_nor_config.h
    ../../../../: dcd.c dcd.h xmcd.c xmcd.h
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_anatop_ai.c fsl_anatop_ai.h fsl_memory.h fsl_dcdc.c fsl_dcdc.h fsl_gpc.c fsl_gpc.h fsl_pgmc.h fsl_pgmc.c fsl_pmu.h fsl_pmu.c fsl_soc_src.c fsl_soc_src.h fsl_caam.c fsl_caam.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_mu.h fsl_mu.c
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv7m_cachel1.h armv7m_mpu.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_COMMON.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group device/periph
    ../../../../../../devices/MIMXRT1176/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_ANADIG_LDO_SNVS.h PERI_ANADIG_LDO_SNVS_DIG.h PERI_ANADIG_MISC.h PERI_ANADIG_OSC.h PERI_ANADIG_PLL.h PERI_ANADIG_PMU.h PERI_ANADIG_TEMPSENSOR.h PERI_AOI.h PERI_ASRC.h PERI_AUDIO_PLL.h PERI_CAAM.h PERI_CAN.h PERI_CAN_WRAPPER.h PERI_CCM.h PERI_CCM_OBS.h PERI_CDOG.h PERI_CMP.h PERI_CSI.h PERI_DAC.h PERI_DCDC.h PERI_DCIC.h PERI_DMA.h PERI_DMAMUX.h PERI_DSI_HOST.h PERI_DSI_HOST_APB_PKT_IF.h PERI_DSI_HOST_DPI_INTFC.h PERI_DSI_HOST_NXP_FDSOI28_DPHY_INTFC.h PERI_EMVSIM.h PERI_ENC.h PERI_ENET.h PERI_ENET_QOS.h PERI_ETHERNET_PLL.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC_CPU_MODE_CTRL.h PERI_GPC_SET_POINT_CTRL.h PERI_GPC_STBY_CTRL.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IEE.h PERI_IEE_APC.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_LPSR.h PERI_IOMUXC_LPSR_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_IPS_DOMAIN.h PERI_KEY_MANAGER.h PERI_KPP.h PERI_LCDIF.h PERI_LCDIFV2.h PERI_LMEM.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_MCM.h PERI_MECC.h PERI_MIPI_CSI2RX.h PERI_MMCAU.h PERI_MU.h PERI_OCOTP.h PERI_OSC_RC_400M.h PERI_OTFAD.h PERI_PDM.h PERI_PGMC_BPC.h PERI_PGMC_CPC.h PERI_PGMC_MIF.h PERI_PGMC_PPC.h PERI_PHY_LDO.h PERI_PIT.h PERI_PUF.h PERI_PWM.h PERI_PXP.h PERI_RDC.h PERI_RDC_SEMAPHORE.h PERI_RTWDOG.h PERI_SEMA4.h PERI_SEMC.h PERI_SNVS.h PERI_SPDIF.h PERI_SRAM.h PERI_SRC.h PERI_SSARC_HP.h PERI_SSARC_LP.h PERI_TMPSNS.h PERI_TMR.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_VIDEO_MUX.h PERI_VIDEO_PLL.h PERI_VMBANDGAP.h PERI_WDOG.h PERI_XBARA.h PERI_XBARB.h PERI_XECC.h PERI_XRDC2.h
  group startup/iar
    ../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group mbedtls/include/mbedtls
    ../../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h psa_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/include/psa
    ../../../../../../middleware/mbedtls/include/psa/: crypto.h crypto_builtin_composites.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group mbedtls/library
    ../../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum_internal.h bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cmac.c common.h constant_time.c constant_time_internal.h constant_time_invasive.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_invasive.h entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c mps_common.h mps_error.h mps_reader.c mps_reader.h mps_trace.c mps_trace.h net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c ssl_tls13_keys.h threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/port/ksdk
    ../../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c ccm_alt.h ecp_alt.h ecp_alt.c ecp_curves_alt.c ecp_alt_ksdk.c threading_alt.h
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
