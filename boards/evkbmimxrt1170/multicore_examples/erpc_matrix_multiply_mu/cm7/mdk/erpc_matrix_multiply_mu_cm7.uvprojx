# Keil uVision project erpc_matrix_multiply_mu_cm7.uvprojx, settings and files
target erpc_matrix_multiply_mu_cm7 flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: erpc_matrix_multiply_mu_cm7.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CORE1_IMAGE_COPY_TO_RAM, CPU_MIMXRT1176DVMAA_cm7, MCUXPRESSO_SDK, MULTICORE_APP=1, SDK_OS_BAREMETAL
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../..;../../../../../../devices/MIMXRT1176/utilities/debug_console_lite;../../../../../../devices/MIMXRT1176/drivers;../../../../../../middleware/multicore/erpc/erpc_c/infra;../../../../../../middleware/multicore/erpc/erpc_c/setup;../../../../../../middleware/multicore/erpc/erpc_c/transports;../../../../../../middleware/multicore/erpc/erpc_c/port;../../../../../../middleware/multicore/mcmgr/src;../../../../../../middleware/multicore/example/multicore_examples/erpc_common;../../../../../../middleware/multicore/example/multicore_examples/erpc_common/erpc_matrix_multiply/service;../../../../../../devices/MIMXRT1176;../../../../../../components/uart;../../../../../../components/lists;../../../../../../devices/MIMXRT1176/xip;../../../../xip;../../../../../../devices/MIMXRT1176/drivers/cm7;../../../../../../devices/MIMXRT1176/utilities/str;../../../../../../middleware/multicore/erpc/erpc_c;../../../../../../CMSIS/Core/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../../cm4/mdk/debug
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor.scf
  link misc: --remove --keep=*(*core1_code) --entry=Reset_Handler --diag_suppress 6314 --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-D__use_flash64MB__=1" --predefine="-D__stack_size__=0x400" --predefine="-D__heap_size__=0x2000"
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h dcd.c dcd.h
  group source
    ../: main_core0.c
    ../../: erpc_config.h
    ../../../../../../middleware/multicore/example/multicore_examples/erpc_common/: erpc_error_handler.h erpc_error_handler.cpp
  group doc
    ../: readme.md
  group evkbmimxrt1170
    ../: evkbmimxrt1170_connect_cm4_cm7side.jlinkscript
  group mcmgr
    ../../../../../../middleware/multicore/mcmgr/src/: mcmgr_internal_core_api_imxrt1170.c mcmgr_mu_internal.c mcmgr.h mcmgr_internal_core_api.h mcmgr.c
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c fsl_assert.h
    ../../../../../../devices/MIMXRT1176/utilities/incbin/: fsl_incbin.S
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_gpc.h fsl_gpc.c fsl_soc_src.h fsl_soc_src.c fsl_mu.h fsl_mu.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group erpc/infra
    ../../../../../../middleware/multicore/erpc/erpc_c/infra/: erpc_client_manager.h erpc_client_manager.cpp erpc_version.h erpc_codec.hpp erpc_basic_codec.hpp erpc_transport.hpp erpc_message_buffer.hpp erpc_message_loggers.hpp erpc_common.h erpc_manually_constructed.hpp erpc_crc16.hpp erpc_basic_codec.cpp erpc_message_buffer.cpp erpc_message_loggers.cpp erpc_crc16.cpp erpc_client_server_common.hpp erpc_pre_post_action.h erpc_pre_post_action.cpp erpc_utils.hpp erpc_utils.cpp
  group erpc/setup
    ../../../../../../middleware/multicore/erpc/erpc_c/setup/: erpc_client_setup.h erpc_client_setup.cpp erpc_setup_mu.cpp erpc_setup_mbf_dynamic.cpp erpc_transport_setup.h erpc_mbf_setup.h
  group erpc/transports
    ../../../../../../middleware/multicore/erpc/erpc_c/transports/: erpc_mu_transport.hpp erpc_mu_transport.cpp
  group erpc/port
    ../../../../../../middleware/multicore/erpc/erpc_c/port/: erpc_port.h erpc_port_stdlib.cpp erpc_config_internal.h erpc_setup_extensions.h erpc_endianness_agnostic_example.h erpc_endianness_undefined.h
  group erpc/service
    ../../../../../../middleware/multicore/example/multicore_examples/erpc_common/erpc_matrix_multiply/service/: erpc_matrix_multiply.erpc erpc_matrix_multiply_common.h erpc_matrix_multiply_common.hpp erpc_matrix_multiply_client.hpp erpc_matrix_multiply_client.cpp erpc_matrix_multiply_interface.hpp erpc_matrix_multiply_interface.cpp c_erpc_matrix_multiply_client.h c_erpc_matrix_multiply_client.cpp
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMXRT1176/arm/: startup_MIMXRT1176_cm7.S
  group xip
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkbmimxrt1170_flexspi_nor_config.c evkbmimxrt1170_flexspi_nor_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
target erpc_matrix_multiply_mu_cm7 flexspi_nor_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: erpc_matrix_multiply_mu_cm7.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CORE1_IMAGE_COPY_TO_RAM, CPU_MIMXRT1176DVMAA_cm7, MCUXPRESSO_SDK, MULTICORE_APP=1, SDK_OS_BAREMETAL
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../../cm4/mdk/release
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor.scf
  link misc: as above
