# Keil uVision project erpc_two_way_rpc_rpmsg_rtos_primary_core.uvprojx, settings and files
target erpc_two_way_rpc_rpmsg_rtos_primary_core flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1176DVMAB:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: erpc_two_way_rpc_rpmsg_rtos_primary_core.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, CORE1_IMAGE_COPY_TO_RAM, __USE_SHMEM, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1176DVMAB_cm7, MIMXRT1176_cm7_SERIES, MULTICORE_APP=1, SDK_OS_FREE_RTOS
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../xip;../../../../../../devices/MIMXRT1176/xip;../../../../../../devices/MIMXRT1176/drivers;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MIMXRT1176;../../../../../../devices/MIMXRT1176/periph;../../../../../../devices/MIMXRT1176/drivers/cm7;../../../../../../devices/MIMXRT1176/utilities/debug_console_lite;../../../../../../devices/MIMXRT1176/utilities/str;../../../../../../components/uart;../../../../../../middleware/multicore/rpmsg-lite/lib/include;../../../../../../middleware/multicore/rpmsg-lite/lib/include/environment/freertos;../../../../../../middleware/multicore/rpmsg-lite/lib/include/platform/imxrt1170;../../../../../../middleware/multicore/mcmgr/inc;../../../../../../middleware/multicore/mcmgr/inc/platform/imxrt1170;../../../../../../middleware/multicore/erpc/erpc_c/infra;../../../../../../middleware/multicore/erpc/erpc_c/setup;../../../../../../middleware/multicore/erpc/erpc_c/port;../../../../../../middleware/multicore/erpc/erpc_c/transports;../../../../../../middleware/multicore/erpc/erpc_c/config;../../../../../../middleware/multicore/erpc/examples/MCUXPRESSO_SDK;../../../../../../middleware/multicore/erpc/examples/MCUXPRESSO_SDK/erpc_two_way_rpc/service;../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F;../../../../../../rtos/freertos/freertos-kernel/template
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1176DVMAB_cm7, MIMXRT1176_cm7_SERIES
  asm include: ../../cm4/mdk/debug;..;../../../../xip;../../../../../../devices/MIMXRT1176/xip;../../../../../../devices/MIMXRT1176/drivers;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MIMXRT1176;../../../../../../devices/MIMXRT1176/periph;../../../../../../devices/MIMXRT1176/drivers/cm7;../../../../../../devices/MIMXRT1176/utilities/debug_console_lite;../../../../../../devices/MIMXRT1176/utilities/str;../../../../../../components/uart;../../../../../../middleware/multicore/rpmsg-lite/lib/include;../../../../../../middleware/multicore/rpmsg-lite/lib/include/environment/freertos;../../../../../../middleware/multicore/rpmsg-lite/lib/include/platform/imxrt1170;../../../../../../middleware/multicore/mcmgr/inc;../../../../../../middleware/multicore/mcmgr/inc/platform/imxrt1170;../../../../../../middleware/multicore/erpc/erpc_c/infra;../../../../../../middleware/multicore/erpc/erpc_c/setup;../../../../../../middleware/multicore/erpc/erpc_c/port;../../../../../../middleware/multicore/erpc/erpc_c/transports;../../../../../../middleware/multicore/erpc/erpc_c/config;../../../../../../middleware/multicore/erpc/examples/MCUXPRESSO_SDK;../../../../../../middleware/multicore/erpc/examples/MCUXPRESSO_SDK/erpc_two_way_rpc/service;../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F;../../../../../../rtos/freertos/freertos-kernel/template
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor.scf
  link misc: --remove --predefine=\"-DXIP_BOOT_HEADER_ENABLE=1\" --predefine=\"-D__use_flash64MB__=1\" --keep=*(*core1_code) --predefine="-D__stack_size__=0x400" --predefine="-D__use_shmem__=1" --predefine="-D__multicore__=1" --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: clock_config.c clock_config.h main.c FreeRTOSConfig_Gen.h erpc_config_gen.h mcux_config.h rpmsg_config.h
  group board
    ../: board.h board.c pin_mux.c pin_mux.h hardware_init.c app.h
  group xip
    ../../../../xip/: evkbmimxrt1170_flexspi_nor_config.c evkbmimxrt1170_flexspi_nor_config.h
    ../../../../: dcd.c dcd.h xmcd.c xmcd.h
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_anatop_ai.c fsl_anatop_ai.h fsl_memory.h fsl_dcdc.c fsl_dcdc.h fsl_gpc.c fsl_gpc.h fsl_pgmc.h fsl_pgmc.c fsl_pmu.h fsl_pmu.c fsl_soc_src.c fsl_soc_src.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_mu.h fsl_mu.c
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv7m_cachel1.h armv7m_mpu.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_COMMON.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group device/periph
    ../../../../../../devices/MIMXRT1176/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_ANADIG_LDO_SNVS.h PERI_ANADIG_LDO_SNVS_DIG.h PERI_ANADIG_MISC.h PERI_ANADIG_OSC.h PERI_ANADIG_PLL.h PERI_ANADIG_PMU.h PERI_ANADIG_TEMPSENSOR.h PERI_AOI.h PERI_ASRC.h PERI_AUDIO_PLL.h PERI_CAAM.h PERI_CAN.h PERI_CAN_WRAPPER.h PERI_CCM.h PERI_CCM_OBS.h PERI_CDOG.h PERI_CMP.h PERI_CSI.h PERI_DAC.h PERI_DCDC.h PERI_DCIC.h PERI_DMA.h PERI_DMAMUX.h PERI_DSI_HOST.h PERI_DSI_HOST_APB_PKT_IF.h PERI_DSI_HOST_DPI_INTFC.h PERI_DSI_HOST_NXP_FDSOI28_DPHY_INTFC.h PERI_EMVSIM.h PERI_ENC.h PERI_ENET.h PERI_ENET_QOS.h PERI_ETHERNET_PLL.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC_CPU_MODE_CTRL.h PERI_GPC_SET_POINT_CTRL.h PERI_GPC_STBY_CTRL.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IEE.h PERI_IEE_APC.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_LPSR.h PERI_IOMUXC_LPSR_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_IPS_DOMAIN.h PERI_KEY_MANAGER.h PERI_KPP.h PERI_LCDIF.h PERI_LCDIFV2.h PERI_LMEM.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_MCM.h PERI_MECC.h PERI_MIPI_CSI2RX.h PERI_MMCAU.h PERI_MU.h PERI_OCOTP.h PERI_OSC_RC_400M.h PERI_OTFAD.h PERI_PDM.h PERI_PGMC_BPC.h PERI_PGMC_CPC.h PERI_PGMC_MIF.h PERI_PGMC_PPC.h PERI_PHY_LDO.h PERI_PIT.h PERI_PUF.h PERI_PWM.h PERI_PXP.h PERI_RDC.h PERI_RDC_SEMAPHORE.h PERI_RTWDOG.h PERI_SEMA4.h PERI_SEMC.h PERI_SNVS.h PERI_SPDIF.h PERI_SRAM.h PERI_SRC.h PERI_SSARC_HP.h PERI_SSARC_LP.h PERI_TMPSNS.h PERI_TMR.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_VIDEO_MUX.h PERI_VIDEO_PLL.h PERI_VMBANDGAP.h PERI_WDOG.h PERI_XBARA.h PERI_XBARB.h PERI_XECC.h PERI_XRDC2.h
  group startup/arm
    ../../../../../../devices/MIMXRT1176/arm/: startup_MIMXRT1176_cm7.S
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
    ../../../../../../devices/MIMXRT1176/utilities/: fsl_memcpy.S
    ../../../../../../devices/MIMXRT1176/utilities/incbin/: fsl_incbin.S
  group utilities/str
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group rpmsg-lite/rpmsg-lite/lib/include
    ../../../../../../middleware/multicore/rpmsg-lite/lib/include/: llist.h rpmsg_compiler.h rpmsg_default_config.h rpmsg_env.h rpmsg_lite.h virtio_ring.h virtqueue.h rpmsg_queue.h rpmsg_ns.h
  group rpmsg-lite/rpmsg-lite/lib/common
    ../../../../../../middleware/multicore/rpmsg-lite/lib/common/: llist.c
  group rpmsg-lite/rpmsg-lite/lib/rpmsg_lite
    ../../../../../../middleware/multicore/rpmsg-lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_queue.c rpmsg_ns.c
  group rpmsg-lite/rpmsg-lite/lib/virtio
    ../../../../../../middleware/multicore/rpmsg-lite/lib/virtio/: virtqueue.c
  group rpmsg-lite/rpmsg-lite/lib/include/environment/freertos
    ../../../../../../middleware/multicore/rpmsg-lite/lib/include/environment/freertos/: rpmsg_env_specific.h
  group rpmsg-lite/rpmsg-lite/lib/rpmsg_lite/porting/environment
    ../../../../../../middleware/multicore/rpmsg-lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_freertos.c
  group rpmsg-lite/rpmsg-lite/lib/include/platform/imxrt1170
    ../../../../../../middleware/multicore/rpmsg-lite/lib/include/platform/imxrt1170/: rpmsg_platform.h
  group rpmsg-lite/rpmsg-lite/lib/rpmsg_lite/porting/platform/imxrt1170
    ../../../../../../middleware/multicore/rpmsg-lite/lib/rpmsg_lite/porting/platform/imxrt1170/: rpmsg_platform.c
  group mcmgr/mcmgr/inc
    ../../../../../../middleware/multicore/mcmgr/inc/: mcmgr.h mcmgr_internal_core_api.h
  group mcmgr/mcmgr/src
    ../../../../../../middleware/multicore/mcmgr/src/: mcmgr.c mcmgr_internal_core_api_imxrt1170.c mcmgr_mu_internal.c
  group mcmgr/mcmgr/inc/platform/imxrt1170
    ../../../../../../middleware/multicore/mcmgr/inc/platform/imxrt1170/: mcmgr_platform.h
  group erpc/erpc/erpc_c/infra
    ../../../../../../middleware/multicore/erpc/erpc_c/infra/: erpc_version.h erpc_codec.hpp erpc_basic_codec.hpp erpc_transport.hpp erpc_message_buffer.hpp erpc_message_loggers.hpp erpc_common.h erpc_manually_constructed.hpp erpc_crc16.hpp erpc_basic_codec.cpp erpc_message_buffer.cpp erpc_message_loggers.cpp erpc_crc16.cpp erpc_client_server_common.hpp erpc_pre_post_action.h erpc_pre_post_action.cpp erpc_utils.hpp erpc_utils.cpp erpc_arbitrated_client_manager.hpp erpc_arbitrated_client_manager.cpp erpc_client_manager.h erpc_client_manager.cpp erpc_simple_server.hpp erpc_simple_server.cpp erpc_server.hpp erpc_server.cpp erpc_transport_arbitrator.hpp erpc_transport_arbitrator.cpp
  group erpc/erpc/erpc_c/setup
    ../../../../../../middleware/multicore/erpc/erpc_c/setup/: erpc_transport_setup.h erpc_mbf_setup.h erpc_arbitrated_client_setup.h erpc_arbitrated_client_setup.cpp erpc_server_setup.h erpc_server_setup.cpp erpc_setup_mbf_rpmsg.cpp erpc_setup_rpmsg_lite_rtos_master.cpp
  group erpc/erpc/erpc_c/port
    ../../../../../../middleware/multicore/erpc/erpc_c/port/: erpc_setup_extensions.h erpc_endianness_agnostic_example.h erpc_endianness_undefined.h erpc_config_internal.h erpc_threading.h erpc_threading_freertos.cpp erpc_port.h erpc_port_freertos.cpp erpc_threading.h erpc_threading_freertos.cpp erpc_setup_extensions.h erpc_setup_extensions_freertos.cpp
  group erpc/erpc/erpc_c/config
    ../../../../../../middleware/multicore/erpc/erpc_c/config/: erpc_config.h
  group erpc/erpc/erpc_c/transports
    ../../../../../../middleware/multicore/erpc/erpc_c/transports/: erpc_rpmsg_lite_base.hpp erpc_rpmsg_lite_rtos_transport.hpp erpc_rpmsg_lite_rtos_transport.cpp
  group erpc/erpc/examples/MCUXPRESSO_SDK
    ../../../../../../middleware/multicore/erpc/examples/MCUXPRESSO_SDK/: erpc_error_handler.h erpc_error_handler.cpp
  group erpc/erpc/examples/MCUXPRESSO_SDK/erpc_two_way_rpc/service
    ../../../../../../middleware/multicore/erpc/examples/MCUXPRESSO_SDK/erpc_two_way_rpc/service/: erpc_two_way_rpc_Core0Interface_common.h erpc_two_way_rpc_Core0Interface_common.hpp erpc_two_way_rpc_Core0Interface_client.hpp erpc_two_way_rpc_Core0Interface_client.cpp c_erpc_two_way_rpc_Core0Interface_client.h c_erpc_two_way_rpc_Core0Interface_client.cpp erpc_two_way_rpc_Core0Interface_interface.hpp erpc_two_way_rpc_Core0Interface_interface.cpp erpc_two_way_rpc_Core1Interface_common.h erpc_two_way_rpc_Core1Interface_common.hpp erpc_two_way_rpc_Core1Interface_server.hpp erpc_two_way_rpc_Core1Interface_server.cpp c_erpc_two_way_rpc_Core1Interface_server.h c_erpc_two_way_rpc_Core1Interface_server.cpp erpc_two_way_rpc_Core1Interface_interface.hpp erpc_two_way_rpc_Core1Interface_interface.cpp
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/GCC/ARM_CM4F
    ../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos/freertos-kernel/template
    ../../../../../../rtos/freertos/freertos-kernel/template/: FreeRTOSConfig.h
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
target erpc_two_way_rpc_rpmsg_rtos_primary_core flexspi_nor_release (ARM-ADS)
  device: MIMXRT1176DVMAB:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: erpc_two_way_rpc_rpmsg_rtos_primary_core.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, CORE1_IMAGE_COPY_TO_RAM, __USE_SHMEM, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1176DVMAB_cm7, MIMXRT1176_cm7_SERIES, MULTICORE_APP=1, SDK_OS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: as above
  asm include: ../../cm4/mdk/release;..;../../../../xip;../../../../../../devices/MIMXRT1176/xip;../../../../../../devices/MIMXRT1176/drivers;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MIMXRT1176;../../../../../../devices/MIMXRT1176/periph;../../../../../../devices/MIMXRT1176/drivers/cm7;../../../../../../devices/MIMXRT1176/utilities/debug_console_lite;../../../../../../devices/MIMXRT1176/utilities/str;../../../../../../components/uart;../../../../../../middleware/multicore/rpmsg-lite/lib/include;../../../../../../middleware/multicore/rpmsg-lite/lib/include/environment/freertos;../../../../../../middleware/multicore/rpmsg-lite/lib/include/platform/imxrt1170;../../../../../../middleware/multicore/mcmgr/inc;../../../../../../middleware/multicore/mcmgr/inc/platform/imxrt1170;../../../../../../middleware/multicore/erpc/erpc_c/infra;../../../../../../middleware/multicore/erpc/erpc_c/setup;../../../../../../middleware/multicore/erpc/erpc_c/port;../../../../../../middleware/multicore/erpc/erpc_c/transports;../../../../../../middleware/multicore/erpc/erpc_c/config;../../../../../../middleware/multicore/erpc/examples/MCUXPRESSO_SDK;../../../../../../middleware/multicore/erpc/examples/MCUXPRESSO_SDK/erpc_two_way_rpc/service;../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F;../../../../../../rtos/freertos/freertos-kernel/template
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor.scf
  link misc: as above
