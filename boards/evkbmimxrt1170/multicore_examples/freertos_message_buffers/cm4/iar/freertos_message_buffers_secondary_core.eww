<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>freertos_message_buffers_secondary_core</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>freertos_message_buffers_secondary_core</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>freertos_message_buffers_secondary_core</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>freertos_message_buffers_secondary_core</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/freertos_message_buffers_secondary_core.ewp</path>
  </project>
</workspace>
