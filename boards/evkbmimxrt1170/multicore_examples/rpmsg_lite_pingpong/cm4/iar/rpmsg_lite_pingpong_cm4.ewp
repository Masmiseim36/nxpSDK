# IAR project rpmsg_lite_pingpong_cm4.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M4 NXP MIMXRT1176xxxA_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1176DVMAA_cm4; __USE_SHMEM; FLEXSPI_IN_USE; MULTICORE_APP=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imxrt1170; ../../../../../../middleware/multicore/rpmsg_lite/lib/include; ../../../../../../middleware/multicore/rpmsg_lite/lib/include/environment/bm; ../../../../../../devices/MIMXRT1176/utilities/str; ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../middleware/multicore/mcmgr/src; ../../../../../../devices/MIMXRT1176; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1176/xip; ../../../../xip; ../../../../../../devices/MIMXRT1176/drivers/cm4; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: rpmsg_lite_pingpong_cm4.out
  ILINK.IlinkConfigDefines: __use_shmem__=1; __stack_size__=0x400; __heap_size__=0x2000
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm4_ram.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1176DVMAA_cm4; __USE_SHMEM; FLEXSPI_IN_USE; MULTICORE_APP=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h dcd.c dcd.h
  group source
    ../: main_remote.c rpmsg_config.h
  group doc
    ../: readme.txt
  group evkbmimxrt1170
    ../: evkbmimxrt1170_connect_cm4_cm4side.jlinkscript
  group mcmgr
    ../../../../../../middleware/multicore/mcmgr/src/: mcmgr_internal_core_api_imxrt1170.c mcmgr_mu_internal.c mcmgr.h mcmgr_internal_core_api.h mcmgr.c
  group rpmsg_lite/include
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_lite.h rpmsg_ns.h llist.h rpmsg_default_config.h virtio_ring.h virtqueue.h rpmsg_compiler.h rpmsg_env.h
  group rpmsg_lite/include/platform/imxrt1170
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imxrt1170/: rpmsg_platform.h
  group rpmsg_lite/include/environment/bm
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/environment/bm/: rpmsg_env_specific.h
  group rpmsg_lite/rpmsg_lite
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c
  group rpmsg_lite/rpmsg_lite/porting/platform/imxrt1170
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/platform/imxrt1170/: rpmsg_platform.c
  group rpmsg_lite/rpmsg_lite/porting/environment
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_bm.c
  group rpmsg_lite/common
    ../../../../../../middleware/multicore/rpmsg_lite/lib/common/: llist.c
  group rpmsg_lite/virtio
    ../../../../../../middleware/multicore/rpmsg_lite/lib/virtio/: virtqueue.c
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_mu.h fsl_mu.c fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../devices/MIMXRT1176/drivers/cm4/: fsl_cache.c fsl_cache.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm4.h MIMXRT1176_cm4_features.h system_MIMXRT1176_cm4.c system_MIMXRT1176_cm4.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm4.s
  group xip
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkbmimxrt1170_flexspi_nor_config.c evkbmimxrt1170_flexspi_nor_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
