<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>rpmsg_lite_pingpong_rtos_cm4</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>rpmsg_lite_pingpong_rtos_cm4</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>rpmsg_lite_pingpong_rtos_cm4</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>rpmsg_lite_pingpong_rtos_cm4</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/rpmsg_lite_pingpong_rtos_cm4.ewp</path>
  </project>
</workspace>
