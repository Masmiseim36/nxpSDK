# IAR project erpc_server_matrix_multiply_uart.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1176DVMAA_cm7; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../devices/MIMXRT1176/cmsis_drivers; ../../../../../../middleware/multicore/erpc/erpc_c/infra; ../../../../../../middleware/multicore/erpc/erpc_c/setup; ../../../../../../middleware/multicore/erpc/erpc_c/transports; ../../../../../../middleware/multicore/erpc/erpc_c/port; ../../../../../../middleware/multicore/example/multiprocessor_examples/erpc_common; ../../../../../../middleware/multicore/example/multiprocessor_examples/erpc_common/erpc_matrix_multiply/service; ../../../../../../devices/MIMXRT1176; ../../../../../../devices/MIMXRT1176/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1176/utilities; ../../../../../../devices/MIMXRT1176/xip; ../../../../xip; ../../../../../../devices/MIMXRT1176/drivers/cm7; ../../../../../../CMSIS/Driver/Include; ../../../../../../devices/MIMXRT1176/template; ../../../../../../middleware/multicore/erpc/erpc_c; ../../../../../../CMSIS/Core/Include; ../../../../../../devices/MIMXRT1176/utilities/str
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: erpc_server_matrix_multiply_uart.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x2000
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_ram.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1176DVMAA_cm7; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; DEBUG; CPU_MIMXRT1176DVMAA_cm7; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1176DVMAA_cm7; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
  group source
    ../: main_server.c erpc_config.h
    ../../../../../../middleware/multicore/example/multiprocessor_examples/erpc_common/: erpc_error_handler.h erpc_error_handler.cpp
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.md
  group evkbmimxrt1170
    ../: evkbmimxrt1170_connect_cm4_cm7side.jlinkscript
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_lpuart_edma.h fsl_lpuart_edma.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_gpc.h fsl_gpc.c fsl_soc_src.h fsl_soc_src.c fsl_mu.h fsl_mu.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_memory.h fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../devices/MIMXRT1176/cmsis_drivers/: fsl_lpuart_cmsis.h fsl_lpuart_cmsis.c
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group erpc/infra
    ../../../../../../middleware/multicore/erpc/erpc_c/infra/: erpc_simple_server.hpp erpc_simple_server.cpp erpc_server.hpp erpc_server.cpp erpc_framed_transport.hpp erpc_framed_transport.cpp erpc_version.h erpc_codec.hpp erpc_basic_codec.hpp erpc_transport.hpp erpc_message_buffer.hpp erpc_message_loggers.hpp erpc_common.h erpc_manually_constructed.hpp erpc_crc16.hpp erpc_basic_codec.cpp erpc_message_buffer.cpp erpc_message_loggers.cpp erpc_crc16.cpp erpc_client_server_common.hpp erpc_pre_post_action.h erpc_pre_post_action.cpp erpc_utils.hpp erpc_utils.cpp
  group erpc/setup
    ../../../../../../middleware/multicore/erpc/erpc_c/setup/: erpc_server_setup.h erpc_server_setup.cpp erpc_setup_uart_cmsis.cpp erpc_setup_mbf_dynamic.cpp erpc_transport_setup.h erpc_mbf_setup.h
  group erpc/transports
    ../../../../../../middleware/multicore/erpc/erpc_c/transports/: erpc_uart_cmsis_transport.hpp erpc_uart_cmsis_transport.cpp
  group erpc/port
    ../../../../../../middleware/multicore/erpc/erpc_c/port/: erpc_port.h erpc_port_stdlib.cpp erpc_config_internal.h erpc_setup_extensions.h erpc_endianness_agnostic_example.h erpc_endianness_undefined.h
  group erpc/service
    ../../../../../../middleware/multicore/example/multiprocessor_examples/erpc_common/erpc_matrix_multiply/service/: erpc_matrix_multiply.erpc erpc_matrix_multiply_common.h erpc_matrix_multiply_common.hpp erpc_matrix_multiply_server.hpp erpc_matrix_multiply_server.cpp erpc_matrix_multiply_interface.hpp erpc_matrix_multiply_interface.cpp c_erpc_matrix_multiply_server.h c_erpc_matrix_multiply_server.cpp
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1176/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group xip
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkbmimxrt1170_flexspi_nor_config.c evkbmimxrt1170_flexspi_nor_config.h
  group CMSIS_driver/Include
    ../../../../../../CMSIS/Driver/Include/: Driver_USART.h Driver_Common.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
