# IAR project erpc_server_matrix_multiply_uart_cm7.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1176DVMAB_cm7; MIMXRT1176_cm7_SERIES
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050  --enable_restrict
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../xip; ../../../../../../devices/MIMXRT1176/xip; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../CMSIS/Driver/Include; ../../../../../../devices/MIMXRT1176; ../../../../../../devices/MIMXRT1176/periph; ../../../../../../devices/MIMXRT1176/drivers/cm7; ../../../../../../devices/MIMXRT1176/cmsis_drivers; ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite; ../../../../../../devices/MIMXRT1176/utilities/str; ../../../../../../components/uart; ../../../../../../middleware/multicore/erpc/erpc_c/infra; ../../../../../../middleware/multicore/erpc/erpc_c/setup; ../../../../../../middleware/multicore/erpc/erpc_c/port; ../../../../../../middleware/multicore/erpc/erpc_c/transports; ../../../../../../middleware/multicore/erpc/erpc_c/config; ../../../../../../middleware/multicore/erpc/examples/MCUXPRESSO_SDK; ../../../../../../middleware/multicore/erpc/examples/MCUXPRESSO_SDK/erpc_matrix_multiply/service
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT1176DVMAB_cm7; MIMXRT1176_cm7_SERIES
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: erpc_server_matrix_multiply_uart_cm7.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x2000
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; USE_SDRAM=1; SKIP_SYSCLK_INIT=1; DATA_SECTION_IS_CACHEABLE=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1176DVMAB_cm7; MIMXRT1176_cm7_SERIES
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1176DVMAB_cm7; MIMXRT1176_cm7_SERIES
  ILINK.IlinkConfigDefines: __use_flash64MB__=1; __stack_size__=0x400; __heap_size__=0x2000
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1176DVMAB_cm7; MIMXRT1176_cm7_SERIES
  ICCARM.CCOptLevel: 3
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_SDRAM=1; SKIP_SYSCLK_INIT=1; DATA_SECTION_IS_CACHEABLE=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1176DVMAB_cm7; MIMXRT1176_cm7_SERIES
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1176DVMAB_cm7; MIMXRT1176_cm7_SERIES
  ICCARM.CCOptLevel: 3
  ILINK.IlinkConfigDefines: as above
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
  group source
    ../: run_uart.py RTE_Device.h main_server.c erpc_config_gen.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group xip
    ../../../../xip/: evkbmimxrt1170_flexspi_nor_config.c evkbmimxrt1170_flexspi_nor_config.h
    ../../../../: dcd.c dcd.h xmcd.c xmcd.h
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_anatop_ai.c fsl_anatop_ai.h fsl_memory.h fsl_dcdc.c fsl_dcdc.h fsl_gpc.c fsl_gpc.h fsl_pgmc.h fsl_pgmc.c fsl_pmu.h fsl_pmu.c fsl_soc_src.c fsl_soc_src.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_gpio.h fsl_gpio.c fsl_lpuart_edma.h fsl_lpuart_edma.c fsl_lpuart.h fsl_lpuart.c fsl_mu.h fsl_mu.c
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
    ../../../../../../devices/MIMXRT1176/cmsis_drivers/: fsl_lpuart_cmsis.h fsl_lpuart_cmsis.c
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv7m_cachel1.h armv7m_mpu.h
  group CMSIS_driver/Include
    ../../../../../../CMSIS/Driver/Include/: Driver_USART.h Driver_Common.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_COMMON.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group device/periph
    ../../../../../../devices/MIMXRT1176/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_ANADIG_LDO_SNVS.h PERI_ANADIG_LDO_SNVS_DIG.h PERI_ANADIG_MISC.h PERI_ANADIG_OSC.h PERI_ANADIG_PLL.h PERI_ANADIG_PMU.h PERI_ANADIG_TEMPSENSOR.h PERI_AOI.h PERI_ASRC.h PERI_AUDIO_PLL.h PERI_CAAM.h PERI_CAN.h PERI_CAN_WRAPPER.h PERI_CCM.h PERI_CCM_OBS.h PERI_CDOG.h PERI_CMP.h PERI_CSI.h PERI_DAC.h PERI_DCDC.h PERI_DCIC.h PERI_DMA.h PERI_DMAMUX.h PERI_DSI_HOST.h PERI_DSI_HOST_APB_PKT_IF.h PERI_DSI_HOST_DPI_INTFC.h PERI_DSI_HOST_NXP_FDSOI28_DPHY_INTFC.h PERI_EMVSIM.h PERI_ENC.h PERI_ENET.h PERI_ENET_QOS.h PERI_ETHERNET_PLL.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC_CPU_MODE_CTRL.h PERI_GPC_SET_POINT_CTRL.h PERI_GPC_STBY_CTRL.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IEE.h PERI_IEE_APC.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_LPSR.h PERI_IOMUXC_LPSR_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_IPS_DOMAIN.h PERI_KEY_MANAGER.h PERI_KPP.h PERI_LCDIF.h PERI_LCDIFV2.h PERI_LMEM.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_MCM.h PERI_MECC.h PERI_MIPI_CSI2RX.h PERI_MMCAU.h PERI_MU.h PERI_OCOTP.h PERI_OSC_RC_400M.h PERI_OTFAD.h PERI_PDM.h PERI_PGMC_BPC.h PERI_PGMC_CPC.h PERI_PGMC_MIF.h PERI_PGMC_PPC.h PERI_PHY_LDO.h PERI_PIT.h PERI_PUF.h PERI_PWM.h PERI_PXP.h PERI_RDC.h PERI_RDC_SEMAPHORE.h PERI_RTWDOG.h PERI_SEMA4.h PERI_SEMC.h PERI_SNVS.h PERI_SPDIF.h PERI_SRAM.h PERI_SRC.h PERI_SSARC_HP.h PERI_SSARC_LP.h PERI_TMPSNS.h PERI_TMR.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_VIDEO_MUX.h PERI_VIDEO_PLL.h PERI_VMBANDGAP.h PERI_WDOG.h PERI_XBARA.h PERI_XBARB.h PERI_XECC.h PERI_XRDC2.h
  group startup/iar
    ../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group erpc/erpc/erpc_c/infra
    ../../../../../../middleware/multicore/erpc/erpc_c/infra/: erpc_version.h erpc_codec.hpp erpc_basic_codec.hpp erpc_transport.hpp erpc_message_buffer.hpp erpc_message_loggers.hpp erpc_common.h erpc_manually_constructed.hpp erpc_crc16.hpp erpc_basic_codec.cpp erpc_message_buffer.cpp erpc_message_loggers.cpp erpc_crc16.cpp erpc_client_server_common.hpp erpc_pre_post_action.h erpc_pre_post_action.cpp erpc_utils.hpp erpc_utils.cpp erpc_simple_server.hpp erpc_simple_server.cpp erpc_server.hpp erpc_server.cpp erpc_framed_transport.hpp erpc_framed_transport.cpp
  group erpc/erpc/erpc_c/setup
    ../../../../../../middleware/multicore/erpc/erpc_c/setup/: erpc_transport_setup.h erpc_mbf_setup.h erpc_server_setup.h erpc_server_setup.cpp erpc_setup_mbf_dynamic.cpp erpc_setup_uart_cmsis.cpp
  group erpc/erpc/erpc_c/port
    ../../../../../../middleware/multicore/erpc/erpc_c/port/: erpc_setup_extensions.h erpc_endianness_agnostic_example.h erpc_endianness_undefined.h erpc_config_internal.h erpc_port.h erpc_port_stdlib.cpp
  group erpc/erpc/erpc_c/config
    ../../../../../../middleware/multicore/erpc/erpc_c/config/: erpc_config.h
  group erpc/erpc/erpc_c/transports
    ../../../../../../middleware/multicore/erpc/erpc_c/transports/: erpc_uart_cmsis_transport.hpp erpc_uart_cmsis_transport.cpp
  group erpc/erpc/examples/MCUXPRESSO_SDK
    ../../../../../../middleware/multicore/erpc/examples/MCUXPRESSO_SDK/: erpc_error_handler.h erpc_error_handler.cpp
  group erpc/erpc/examples/MCUXPRESSO_SDK/erpc_matrix_multiply/service
    ../../../../../../middleware/multicore/erpc/examples/MCUXPRESSO_SDK/erpc_matrix_multiply/service/: erpc_matrix_multiply_common.h erpc_matrix_multiply_common.hpp erpc_matrix_multiply_server.hpp erpc_matrix_multiply_server.cpp erpc_matrix_multiply_interface.hpp erpc_matrix_multiply_interface.cpp c_erpc_matrix_multiply_server.h c_erpc_matrix_multiply_server.cpp
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
