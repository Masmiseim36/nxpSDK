# IAR project clock_freertos_cm7.ewp, settings and files
configuration flexspi_nor_sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; USE_SDRAM=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_XMCD_ENABLE=1; SKIP_SYSCLK_INIT=1; DATA_SECTION_IS_CACHEABLE=1; GCID_REV_CID=gc355/0x0_1216; CUSTOM_VGLITE_MEMORY_CONFIG=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; CPU_MIMXRT1176DVMAB_cm7; MIMXRT1176_cm7_SERIES; SDK_OS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pa092
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../xip; ../../../../../../devices/MIMXRT1176/xip; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT1176; ../../../../../../devices/MIMXRT1176/periph; ../../../../../../devices/MIMXRT1176/drivers/cm7; ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite; ../../../../../../devices/MIMXRT1176/utilities/str; ../../../../../../components/uart; ../../../../../../components/video; ../../../../../../components/video/display/dc; ../../../../../../components/video/display; ../../../../../../components/video/display/fbdev; ../../../../../../components/video/display/dc/elcdif; ../../../../../../components/video/display/dc/lcdifv2; ../../../../../../components/video/display/mipi_dsi_cmd; ../../../../../../components/video/display/hx8394; ../../../../../../components/video/display/rm68191; ../../../../../../components/video/display/rm68200; ../../../../../../components/video/display/rpi; ../../../../../../middleware/vglite/driver/inc; ../../../../../../middleware/vglite/driver/VGLite; ../../../../../../middleware/vglite/driver/VGLite/rtos; ../../../../../../middleware/vglite/driver/VGLite/Series/gc555/0x423_ECO; ../../../../../../middleware/vglite/driver/VGLite/Series/gc355/0x0_1216; ../../../../../../middleware/vglite/driver/VGLite/Series/gc255/0x40A; ../../../../../../middleware/vglite/driver/VGLiteKernel; ../../../../../../middleware/vglite/driver/VGLiteKernel/rtos; ../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F; ../../../../../../rtos/freertos/freertos-kernel/template
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT1176DVMAB_cm7; MIMXRT1176_cm7_SERIES
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: clock_freertos.bin
  ILINK.IlinkOutputFile: clock_freertos_cm7.out
  ILINK.IlinkConfigDefines: __use_flash64MB__=1
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
  ILINK.IlinkExtraOptions: --redirect  __iar_sh_stdout=__iar_sh_stdout_swo
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; USE_SDRAM=1; SKIP_SYSCLK_INIT=1; DATA_SECTION_IS_CACHEABLE=1; GCID_REV_CID=gc355/0x0_1216; CUSTOM_VGLITE_MEMORY_CONFIG=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; CPU_MIMXRT1176DVMAB_cm7; MIMXRT1176_cm7_SERIES; SDK_OS_FREE_RTOS
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; XIP_EXTERNAL_FLASH=1; USE_SDRAM=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_XMCD_ENABLE=1; SKIP_SYSCLK_INIT=1; DATA_SECTION_IS_CACHEABLE=1; GCID_REV_CID=gc355/0x0_1216; CUSTOM_VGLITE_MEMORY_CONFIG=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; CPU_MIMXRT1176DVMAB_cm7; MIMXRT1176_cm7_SERIES; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 3
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_SDRAM=1; SKIP_SYSCLK_INIT=1; DATA_SECTION_IS_CACHEABLE=1; GCID_REV_CID=gc355/0x0_1216; CUSTOM_VGLITE_MEMORY_CONFIG=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; CPU_MIMXRT1176DVMAB_cm7; MIMXRT1176_cm7_SERIES; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
  group source
    ../: clock_freertos.c clock_analog.h hour_needle.h minute_needle.h layer.h layer.c vglite_window.h vglite_window.c pin_mux.c pin_mux.h ClockAnalogOrange.svg HourNeedle.svg MinuteNeedle.svg FreeRTOSConfigBoard.h display_support.h display_support.c vglite_support.h vglite_support.c FreeRTOSConfig_Gen.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c hardware_init.c app.h
  group xip
    ../../../../xip/: evkbmimxrt1170_flexspi_nor_config.c evkbmimxrt1170_flexspi_nor_config.h
    ../../../../: dcd.c dcd.h xmcd.c xmcd.h
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_soc_mipi_csi2rx.c fsl_soc_mipi_csi2rx.h fsl_soc_mipi_dsi.h fsl_anatop_ai.c fsl_anatop_ai.h fsl_memory.h fsl_dcdc.c fsl_dcdc.h fsl_gpc.c fsl_gpc.h fsl_pgmc.h fsl_pgmc.c fsl_pmu.h fsl_pmu.c fsl_soc_src.c fsl_soc_src.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_elcdif.c fsl_elcdif.h fsl_gpio.h fsl_gpio.c fsl_lcdifv2.c fsl_lcdifv2.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.h fsl_lpuart.c fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_mu.h fsl_mu.c
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv7m_cachel1.h armv7m_mpu.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_COMMON.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group device/periph
    ../../../../../../devices/MIMXRT1176/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_ANADIG_LDO_SNVS.h PERI_ANADIG_LDO_SNVS_DIG.h PERI_ANADIG_MISC.h PERI_ANADIG_OSC.h PERI_ANADIG_PLL.h PERI_ANADIG_PMU.h PERI_ANADIG_TEMPSENSOR.h PERI_AOI.h PERI_ASRC.h PERI_AUDIO_PLL.h PERI_CAAM.h PERI_CAN.h PERI_CAN_WRAPPER.h PERI_CCM.h PERI_CCM_OBS.h PERI_CDOG.h PERI_CMP.h PERI_CSI.h PERI_DAC.h PERI_DCDC.h PERI_DCIC.h PERI_DMA.h PERI_DMAMUX.h PERI_DSI_HOST.h PERI_DSI_HOST_APB_PKT_IF.h PERI_DSI_HOST_DPI_INTFC.h PERI_DSI_HOST_NXP_FDSOI28_DPHY_INTFC.h PERI_EMVSIM.h PERI_ENC.h PERI_ENET.h PERI_ENET_QOS.h PERI_ETHERNET_PLL.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC_CPU_MODE_CTRL.h PERI_GPC_SET_POINT_CTRL.h PERI_GPC_STBY_CTRL.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IEE.h PERI_IEE_APC.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_LPSR.h PERI_IOMUXC_LPSR_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_IPS_DOMAIN.h PERI_KEY_MANAGER.h PERI_KPP.h PERI_LCDIF.h PERI_LCDIFV2.h PERI_LMEM.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_MCM.h PERI_MECC.h PERI_MIPI_CSI2RX.h PERI_MMCAU.h PERI_MU.h PERI_OCOTP.h PERI_OSC_RC_400M.h PERI_OTFAD.h PERI_PDM.h PERI_PGMC_BPC.h PERI_PGMC_CPC.h PERI_PGMC_MIF.h PERI_PGMC_PPC.h PERI_PHY_LDO.h PERI_PIT.h PERI_PUF.h PERI_PWM.h PERI_PXP.h PERI_RDC.h PERI_RDC_SEMAPHORE.h PERI_RTWDOG.h PERI_SEMA4.h PERI_SEMC.h PERI_SNVS.h PERI_SPDIF.h PERI_SRAM.h PERI_SRC.h PERI_SSARC_HP.h PERI_SSARC_LP.h PERI_TMPSNS.h PERI_TMR.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_VIDEO_MUX.h PERI_VIDEO_PLL.h PERI_VMBANDGAP.h PERI_WDOG.h PERI_XBARA.h PERI_XBARB.h PERI_XECC.h PERI_XRDC2.h
  group startup/iar
    ../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group video
    ../../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../../components/video/display/dc/: fsl_dc_fb.h
    ../../../../../../components/video/display/: fsl_display.h
    ../../../../../../components/video/display/fbdev/: fsl_fbdev.h fsl_fbdev.c
    ../../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.h fsl_dc_fb_elcdif.c
    ../../../../../../components/video/display/dc/lcdifv2/: fsl_dc_fb_lcdifv2.h fsl_dc_fb_lcdifv2.c
    ../../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
    ../../../../../../components/video/display/hx8394/: fsl_hx8394.h fsl_hx8394.c
    ../../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../../components/video/display/rpi/: fsl_rpi.h fsl_rpi.c
  group vglite
    ../../../../../../middleware/vglite/driver/: RELEASE_NOTES.txt LICENSE.txt
  group vglite/inc
    ../../../../../../middleware/vglite/driver/inc/: vg_lite.h
  group vglite/VGLite
    ../../../../../../middleware/vglite/driver/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_stroke.c vg_lite_options.h vg_lite_context.h
  group vglite/VGLite/rtos
    ../../../../../../middleware/vglite/driver/VGLite/rtos/: vg_lite_os.c
  group vglite/VGLite/Series/gc555/0x423_ECO
    ../../../../../../middleware/vglite/driver/VGLite/Series/gc555/0x423_ECO/: vg_lite_options.h
  group vglite/VGLite/Series/gc355/0x0_1216
    ../../../../../../middleware/vglite/driver/VGLite/Series/gc355/0x0_1216/: vg_lite_options.h
  group vglite/VGLite/Series/gc255/0x40A
    ../../../../../../middleware/vglite/driver/VGLite/Series/gc255/0x40A/: vg_lite_options.h
  group vglite/VGLiteKernel
    ../../../../../../middleware/vglite/driver/VGLiteKernel/: vg_lite_hal.h vg_lite_hw.h vg_lite_kernel.c vg_lite_kernel.h vg_lite_option.h vg_lite_type.h vg_lite_debug.h
  group vglite/VGLiteKernel/rtos
    ../../../../../../middleware/vglite/driver/VGLiteKernel/rtos/: vg_lite_hal.c vg_lite_platform.h
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable/IAR/ARM_CM4F
    ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos-kernel/template
    ../../../../../../rtos/freertos/freertos-kernel/template/: FreeRTOSConfig.h
  group doc
    ../: readme.md examples_shared_readme.md
