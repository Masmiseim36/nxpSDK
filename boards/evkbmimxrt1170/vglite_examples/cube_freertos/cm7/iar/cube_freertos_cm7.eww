<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>cube_freertos_cm7</project>
        <configuration>sdram_debug</configuration>
      </member>
      <member>
        <project>cube_freertos_cm7</project>
        <configuration>sdram_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdram_debug</name>
      <member>
        <project>cube_freertos_cm7</project>
        <configuration>sdram_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdram_release</name>
      <member>
        <project>cube_freertos_cm7</project>
        <configuration>sdram_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/cube_freertos_cm7.ewp</path>
  </project>
</workspace>
