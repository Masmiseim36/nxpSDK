# IAR project maestro_usb_speaker.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6B NXP MIMXRT1062xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_BOOT_HEADER_ENABLE=1; XIP_EXTERNAL_FLASH=1; USB_STACK_FREERTOS; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; OSA_USED; SHELL_TASK_STACK_SIZE=4000; SAI_XFER_QUEUE_SIZE=2; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1062DVL6B; MIMXRT1062_SERIES; SERIAL_PORT_TYPE_UART=1; SDK_I2C_BASED_COMPONENT_USED=1; CODEC_MULTI_ADAPTERS=1; CODEC_CS42448_ENABLE; CODEC_WM8962_ENABLE; USE_RTOS=1; STREAMER_ENABLE_AUDIO_SINK; STREAMER_ENABLE_AUDIO_SRC; SDK_OS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa050,Pa082,Pe188
  ICCARM.IExtraOptions: --align_sp_on_irq  --macro_positions_in_diagnostics  --header_context  --no_unaligned_access  --diag_suppress=Pa082,Pa050 --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../xip; ../../../../../devices/MIMXRT1062/drivers; ../../../../../CMSIS/Core/Include; ../../../../../CMSIS/Core/Include/m-profile; ../../../../../devices/MIMXRT1062; ../../../../../devices/MIMXRT1062/periph; ../../../../../devices/MIMXRT1062/xip; ../../../../../devices/MIMXRT1062/utilities/debug_console; ../../../../../components/lists; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../devices/MIMXRT1062/utilities/shell; ../../../../../components/serial_manager; ../../../../../components/codec/i2c; ../../../../../components/codec; ../../../../../components/codec/port; ../../../../../components/codec/port/wm8962; ../../../../../components/codec/port/cs42448; ../../../../../components/codec/cs42448; ../../../../../components/codec/wm8962; ../../../../../components/i2c; ../../../../../components/uart; ../../../../../components/osa; ../../../../../middleware/usb/include; ../../../../../middleware/usb/device; ../../../../../middleware/usb/config/device/ehci; ../../../../../middleware/usb/device/class; ../../../../../middleware/usb/phy; ../../../../../middleware/audio_voice/maestro/src/inc; ../../../../../middleware/audio_voice/maestro/src/core/inc; ../../../../../middleware/audio_voice/maestro/src/utils/inc; ../../../../../middleware/audio_voice/maestro/src/elements; ../../../../../middleware/audio_voice/maestro/src/devices; ../../../../../rtos/freertos/freertos-kernel/include; ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F; ../../../../../rtos/freertos/freertos-kernel/template
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT1062DVL6B; MIMXRT1062_SERIES; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; OSA_USED
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: maestro_usb_speaker.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x3000
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; XIP_BOOT_HEADER_ENABLE=1; XIP_EXTERNAL_FLASH=1; USB_STACK_FREERTOS; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; OSA_USED; SHELL_TASK_STACK_SIZE=4000; SAI_XFER_QUEUE_SIZE=2; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1062DVL6B; MIMXRT1062_SERIES; SERIAL_PORT_TYPE_UART=1; SDK_I2C_BASED_COMPONENT_USED=1; CODEC_MULTI_ADAPTERS=1; CODEC_CS42448_ENABLE; CODEC_WM8962_ENABLE; USE_RTOS=1; STREAMER_ENABLE_AUDIO_SINK; STREAMER_ENABLE_AUDIO_SRC; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  group source
    ../: FreeRTOSConfigBoard.h app_definitions.h app_streamer.c audio_speaker.c cmd.c main.c usb_device_descriptor.c app_streamer.h audio_speaker.h cmd.h main.h usb_device_descriptor.h streamer_pcm.c streamer_pcm.h FreeRTOSConfig_Gen.h fsl_debug_console_conf.h fsl_os_abstraction_config.h mcux_config.h usb_device_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group xip
    ../../../xip/: evkcmimxrt1060_flexspi_nor_config.c evkcmimxrt1060_flexspi_nor_config.h
    ../../../: dcd.c dcd.h
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_gpc.c fsl_gpc.h fsl_gpio.h fsl_gpio.c fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.h fsl_lpuart.c fsl_pmu.h fsl_pmu.c fsl_sai_edma.h fsl_sai_edma.c fsl_sai.h fsl_sai.c fsl_src.c fsl_src.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv7m_cachel1.h armv7m_mpu.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h MIMXRT1062_COMMON.h system_MIMXRT1062.c system_MIMXRT1062.h
  group device/periph
    ../../../../../devices/MIMXRT1062/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_AIPSTZ.h PERI_AOI.h PERI_BEE.h PERI_CAN.h PERI_CCM.h PERI_CCM_ANALOG.h PERI_CM7_MCM.h PERI_CMP.h PERI_CSI.h PERI_CSU.h PERI_DCDC.h PERI_DCP.h PERI_DMA.h PERI_DMAMUX.h PERI_ENC.h PERI_ENET.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_KPP.h PERI_LCDIF.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_OCOTP.h PERI_PGC.h PERI_PIT.h PERI_PMU.h PERI_PWM.h PERI_PXP.h PERI_ROMC.h PERI_RTWDOG.h PERI_SEMC.h PERI_SNVS.h PERI_SPDIF.h PERI_SRC.h PERI_TEMPMON.h PERI_TMR.h PERI_TRNG.h PERI_TSC.h PERI_USB.h PERI_USBNC.h PERI_USBPHY.h PERI_USB_ANALOG.h PERI_USDHC.h PERI_WDOG.h PERI_XBARA.h PERI_XBARB.h PERI_XTALOSC24M.h
  group startup/iar
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_assert.h fsl_assert.c
    ../../../../../devices/MIMXRT1062/utilities/shell/: fsl_shell.h fsl_shell.c
  group utilities/str
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.h fsl_debug_console.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/i2c
    ../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h
  group codec
    ../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
    ../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../components/codec/cs42448/: fsl_cs42448.h fsl_cs42448.c
    ../../../../../components/codec/wm8962/: fsl_wm8962.h fsl_wm8962.c
  group codec/port
    ../../../../../components/codec/port/: fsl_codec_adapter.c fsl_codec_adapter.h fsl_codec_adapter.h
  group codec/port/wm8962
    ../../../../../components/codec/port/wm8962/: fsl_codec_wm8962_adapter.h fsl_codec_wm8962_adapter.c
  group codec/port/cs42448
    ../../../../../components/codec/port/cs42448/: fsl_codec_cs42448_adapter.h fsl_codec_cs42448_adapter.c
  group usb/include
    ../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group usb/device
    ../../../../../middleware/usb/device/: usb_device.h usb_device_ehci.c usb_device_ehci.h usb_device_dci.c usb_device_dci.h usb_device_ch9.c usb_device_ch9.h
  group usb/device/class
    ../../../../../middleware/usb/device/class/: usb_device_class.c usb_device_class.h usb_device_audio.c usb_device_audio.h
  group usb/phy
    ../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group maestro/src/inc
    ../../../../../middleware/audio_voice/maestro/src/inc/: audio_cfg.h error.h streamer_api.h streamer_element_properties.h streamer_message.h types.h
  group maestro/src/core/inc
    ../../../../../middleware/audio_voice/maestro/src/core/inc/: pad.h pipeline.h streamer.h streamer_element.h
  group maestro/src/core/src
    ../../../../../middleware/audio_voice/maestro/src/core/src/: pad.c pipeline.c streamer.c streamer_element.c streamer_msg.c
  group maestro/src/utils/inc
    ../../../../../middleware/audio_voice/maestro/src/utils/inc/: general_utils.h maestro_logging.h
  group maestro/src/utils/src
    ../../../../../middleware/audio_voice/maestro/src/utils/src/: general_utils.c maestro_logging.c
  group maestro/src/elements
    ../../../../../middleware/audio_voice/maestro/src/elements/: audio_sink.c audio_sink.h audio_src.c audio_src.h
  group maestro/src/devices
    ../../../../../middleware/audio_voice/maestro/src/devices/: audio_sink_default.c audio_sink_default.h audio_src_default.c audio_src_default.h
  group freertos/freertos-kernel
    ../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable
    ../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable/IAR/ARM_CM4F
    ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos-kernel/template
    ../../../../../rtos/freertos/freertos-kernel/template/: FreeRTOSConfig.h
  group doc
    ../: example_board_readme.md examples_shared_readme.md
