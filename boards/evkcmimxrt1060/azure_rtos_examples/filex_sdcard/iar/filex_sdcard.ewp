# IAR project filex_sdcard.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6B NXP MIMXRT1062xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1062DVL6B; FSL_RTOS_THREADX; SDMMC_OSA_POLLING_EVENT_BY_SEMPHORE=0; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; DATA_SECTION_IS_CACHEABLE=1; MCUXPRESSO_SDK; SD_ENABLED; FX_INCLUDE_USER_DEFINE_FILE; TX_INCLUDE_USER_DEFINE_FILE
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../devices/MIMXRT1062/drivers; ../../../../../middleware/sdmmc/host/usdhc; ../../../../../middleware/sdmmc/sd; ../../../../../components/gpio; ../../../../../devices/MIMXRT1062; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../devices/MIMXRT1062/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../devices/MIMXRT1062/utilities; ../../../../../devices/MIMXRT1062/xip; ../../../xip; ../../../../../rtos/azure-rtos/filex/common/inc; ../../../../../rtos/azure-rtos/filex/ports/generic/inc; ../../../../../rtos/azure-rtos/threadx/common/inc; ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/iar/inc; ../../../../../middleware/sdmmc/common; ../../../../../middleware/sdmmc/osa; ../../../../../components/osa; ../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: filex_sdcard.out
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_ram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../rtos/azure-rtos/binary/filex/cortex_m7/iar/libfilex.a; ../../../../../rtos/azure-rtos/binary/threadx/cortex_m7/iar/libthreadx.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1062DVL6B; FSL_RTOS_THREADX; SDMMC_OSA_POLLING_EVENT_BY_SEMPHORE=0; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; DATA_SECTION_IS_CACHEABLE=1; MCUXPRESSO_SDK; SD_ENABLED; FX_INCLUDE_USER_DEFINE_FILE; TX_INCLUDE_USER_DEFINE_FILE
  ILINK.IlinkConfigDefines: __use_flash16MB__=1
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1062DVL6B; FSL_RTOS_THREADX; SDMMC_OSA_POLLING_EVENT_BY_SEMPHORE=0; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; DATA_SECTION_IS_CACHEABLE=1; MCUXPRESSO_SDK; SD_ENABLED; FX_INCLUDE_USER_DEFINE_FILE; TX_INCLUDE_USER_DEFINE_FILE
  ICCARM.CCOptLevel: 1
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1062DVL6B; FSL_RTOS_THREADX; SDMMC_OSA_POLLING_EVENT_BY_SEMPHORE=0; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; DATA_SECTION_IS_CACHEABLE=1; MCUXPRESSO_SDK; SD_ENABLED; FX_INCLUDE_USER_DEFINE_FILE; TX_INCLUDE_USER_DEFINE_FILE
  ICCARM.CCOptLevel: 1
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkConfigDefines: __use_flash16MB__=1
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
  group board
    ../: sdmmc_config.c sdmmc_config.h pin_mux.c pin_mux.h board_setup.c board_setup.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group source
    ../: filex_sdcard.c fx_sdcard_driver.c
  group azure-rtos/config
    ../: tx_user.h fx_user.h
  group azure-rtos/filex/common/inc
    ../../../../../rtos/azure-rtos/filex/common/inc/: fx_api.h fx_directory.h fx_directory_exFAT.h fx_fault_tolerant.h fx_file.h fx_media.h fx_system.h fx_unicode.h fx_user_sample.h fx_utility.h
  group azure-rtos/filex/ports/generic/inc
    ../../../../../rtos/azure-rtos/filex/ports/generic/inc/: fx_port.h
  group azure-rtos/threadx/common/inc
    ../../../../../rtos/azure-rtos/threadx/common/inc/: tx_api.h tx_block_pool.h tx_byte_pool.h tx_event_flags.h tx_initialize.h tx_mutex.h tx_queue.h tx_semaphore.h tx_thread.h tx_timer.h tx_trace.h tx_user_sample.h
  group azure-rtos/threadx/ports/cortex_m7/iar/inc
    ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/iar/inc/: tx_port.h
  group azure-rtos/threadx/ports/cortex_m7/iar/src
    ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/iar/src/: tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_schedule.s tx_thread_stack_build.s tx_thread_system_return.s tx_timer_interrupt.s
  group azure-rtos/threadx/ports/common
    ../../../../../rtos/azure-rtos/threadx/ports/common/: tx_initialize_low_level.c
  group doc
    ../: readme.md
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_cache.c fsl_cache.h fsl_usdhc.c fsl_usdhc.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group sdmmc/host
    ../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt
    ../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group sdmmc/src
    ../../../../../middleware/sdmmc/sd/: fsl_sd.c
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc/sd/: fsl_sd.h
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sd
    ../../../../../middleware/sdmmc/sd/: ChangeLogKSDK.txt
  group sdmmc/osa
    ../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group component/gpio
    ../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction_threadx.c fsl_os_abstraction_threadx.h fsl_os_abstraction.h fsl_os_abstraction_config.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c fsl_assert.h
  group startup
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkcmimxrt1060_flexspi_nor_config.c evkcmimxrt1060_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
