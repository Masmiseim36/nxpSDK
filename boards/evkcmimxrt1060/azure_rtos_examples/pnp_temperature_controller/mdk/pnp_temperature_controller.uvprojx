# Keil uVision project pnp_temperature_controller.uvprojx, settings and files
target pnp_temperature_controller sdram_debug (ARM-ADS)
  device: MIMXRT1062DVL6B NXP
  pack: NXP.MIMXRT1062_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: pnp_temperature_controller.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, DEBUG, __CLANG_ARM, CPU_MIMXRT1062DVL6B, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, NXD_MQTT_OVER_WEBSOCKET, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK, AZ_NO_PRECONDITION_CHECKING, NX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE, FSL_RTOS_THREADX
  c misc: -Wno-tautological-pointer-compare  -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../../rtos/azure-rtos/netxduo/addons/azure_iot;../../../../../rtos/azure-rtos/netxduo/addons/azure_iot/azure-sdk-for-c/sdk/inc;../../../../../devices/MIMXRT1062/drivers;../../../../../components/phy/device/phyksz8081;../../../../../devices/MIMXRT1062;../../../../../devices/MIMXRT1062/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../devices/MIMXRT1062/utilities;../../../../../devices/MIMXRT1062/xip;../../../xip;../../../../../rtos/azure-rtos/netxduo/addons/auto_ip;../../../../../rtos/azure-rtos/netxduo/addons/cloud;../../../../../rtos/azure-rtos/netxduo/addons/BSD;../../../../../rtos/azure-rtos/netxduo/addons/dhcp;../../../../../rtos/azure-rtos/netxduo/addons/dns;../../../../../rtos/azure-rtos/netxduo/addons/ftp;../../../../../rtos/azure-rtos/netxduo/addons/http;../../../../../rtos/azure-rtos/netxduo/addons/mdns;../../../../../rtos/azure-rtos/netxduo/addons/mqtt;../../../../../rtos/azure-rtos/netxduo/addons/nat;../../../../../rtos/azure-rtos/netxduo/addons/pop3;../../../../../rtos/azure-rtos/netxduo/addons/ppp;../../../../../rtos/azure-rtos/netxduo/addons/pppoe;../../../../../rtos/azure-rtos/netxduo/addons/ptp;../../../../../rtos/azure-rtos/netxduo/addons/smtp;../../../../../rtos/azure-rtos/netxduo/addons/snmp;../../../../../rtos/azure-rtos/netxduo/addons/sntp;../../../../../rtos/azure-rtos/netxduo/addons/telnet;../../../../../rtos/azure-rtos/netxduo/addons/tftp;../../../../../rtos/azure-rtos/netxduo/addons/web;../../../../../rtos/azure-rtos/netxduo/addons/websocket;../../../../../rtos/azure-rtos/netxduo/addons/rtp;../../../../../rtos/azure-rtos/netxduo/addons/rtsp;../../../../../rtos/azure-rtos/netxduo/common/inc;../../../../../rtos/azure-rtos/netxduo/crypto_libraries/inc;../../../../../rtos/azure-rtos/netxduo/nx_secure/inc;../../../../../rtos/azure-rtos/netxduo/nx_secure/ports;../../../../../rtos/azure-rtos/netxduo/ports/cortex_m7/ac6/inc;../../../../../rtos/azure-rtos/filex/common/inc;../../../../../rtos/azure-rtos/filex/ports/generic/inc;../../../../../rtos/azure-rtos/threadx/common/inc;../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc;../../../../../components/phy;../../../../../CMSIS/Core/Include;../../../../../devices/MIMXRT1062/utilities/str
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_sdram.scf
  link misc: ../../../../../rtos/azure-rtos/binary/netxduo/cortex_m7/mdk/libnetxduo.lib ../../../../../rtos/azure-rtos/binary/filex/cortex_m7/mdk/libfilex.lib ../../../../../rtos/azure-rtos/binary/threadx/cortex_m7/mdk/libthreadx.lib --remove --entry=Reset_Handler --diag_suppress 6314
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group source
    ../: main.c pnp_temperature_controller.c pnp_deviceinfo_component.c pnp_deviceinfo_component.h pnp_thermostat_component.c pnp_thermostat_component.h nx_azure_iot_pnp_helpers.c nx_azure_iot_pnp_helpers.h get_seed.c sample_config.h nx_azure_iot_cert.c nx_azure_iot_cert.h nx_azure_iot_ciphersuites.c nx_azure_iot_ciphersuites.h sample_device_identity.c
  group azure-rtos/config
    ../: tx_user.h nx_user.h fx_user.h
  group doc
    ../: readme.md
  group azure-rtos/netxduo/addons/azure_iot
    ../../../../../rtos/azure-rtos/netxduo/addons/azure_iot/: nx_azure_iot.h nx_azure_iot_adu_agent.h nx_azure_iot_hub_client.h nx_azure_iot_hub_client_properties.h nx_azure_iot_json_reader.h nx_azure_iot_json_writer.h nx_azure_iot_provisioning_client.h nx_azure_iot.c nx_azure_iot_adu_agent.c nx_azure_iot_adu_root_key.c nx_azure_iot_hub_client.c nx_azure_iot_hub_client_properties.c nx_azure_iot_json_reader.c nx_azure_iot_json_writer.c nx_azure_iot_provisioning_client.c
  group azure-rtos/netxduo/addons/azure_iot/azure-sdk-for-c/sdk/inc/azure
    ../../../../../rtos/azure-rtos/netxduo/addons/azure_iot/azure-sdk-for-c/sdk/inc/azure/: az_core.h az_iot.h
  group azure-rtos/netxduo/addons/azure_iot/azure-sdk-for-c/sdk/inc/azure/core
    ../../../../../rtos/azure-rtos/netxduo/addons/azure_iot/azure-sdk-for-c/sdk/inc/azure/core/: _az_cfg.h _az_cfg_prefix.h _az_cfg_suffix.h az_base64.h az_config.h az_context.h az_credentials.h az_http.h az_http_transport.h az_json.h az_log.h az_platform.h az_precondition.h az_result.h az_span.h az_version.h
  group azure-rtos/netxduo/addons/azure_iot/azure-sdk-for-c/sdk/inc/azure/core/internal
    ../../../../../rtos/azure-rtos/netxduo/addons/azure_iot/azure-sdk-for-c/sdk/inc/azure/core/internal/: az_config_internal.h az_credentials_internal.h az_http_internal.h az_log_internal.h az_precondition_internal.h az_result_internal.h az_retry_internal.h az_span_internal.h
  group azure-rtos/netxduo/addons/azure_iot/azure-sdk-for-c/sdk/inc/azure/iot
    ../../../../../rtos/azure-rtos/netxduo/addons/azure_iot/azure-sdk-for-c/sdk/inc/azure/iot/: az_iot_common.h az_iot_hub_client.h az_iot_hub_client_properties.h az_iot_provisioning_client.h
  group azure-rtos/netxduo/addons/azure_iot/azure-sdk-for-c/sdk/inc/azure/iot/internal
    ../../../../../rtos/azure-rtos/netxduo/addons/azure_iot/azure-sdk-for-c/sdk/inc/azure/iot/internal/: az_iot_common_internal.h
  group azure-rtos/netxduo/addons/azure_iot/azure-sdk-for-c/sdk/src/azure/core
    ../../../../../rtos/azure-rtos/netxduo/addons/azure_iot/azure-sdk-for-c/sdk/src/azure/core/: CMakeLists.txt az_base64.c az_context.c az_hex_private.h az_http_header_validation_private.h az_http_pipeline.c az_http_policy.c az_http_policy_logging.c az_http_policy_logging_private.h az_http_policy_retry.c az_http_private.h az_http_request.c az_http_response.c az_json_private.h az_json_reader.c az_json_token.c az_json_writer.c az_log.c az_precondition.c az_span.c az_span_private.h
  group azure-rtos/netxduo/addons/azure_iot/azure-sdk-for-c/sdk/src/azure/iot
    ../../../../../rtos/azure-rtos/netxduo/addons/azure_iot/azure-sdk-for-c/sdk/src/azure/iot/: CMakeLists.txt az_iot_common.c az_iot_hub_client.c az_iot_hub_client_c2d.c az_iot_hub_client_commands.c az_iot_hub_client_methods.c az_iot_hub_client_properties.c az_iot_hub_client_sas.c az_iot_hub_client_telemetry.c az_iot_hub_client_twin.c az_iot_provisioning_client.c az_iot_provisioning_client_sas.c
  group azure-rtos/netxduo/addons/azure_iot/azure-sdk-for-c/sdk/src/azure/platform
    ../../../../../rtos/azure-rtos/netxduo/addons/azure_iot/azure-sdk-for-c/sdk/src/azure/platform/: az_nohttp.c az_noplatform.c
  group azure-rtos/ports
    ../../../../../rtos/azure-rtos/ports/netxduo/: nx_driver_imxrt_irq.c nx_driver_imxrt.c nx_driver_imxrt.h
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_enet.h fsl_enet.c fsl_trng.c fsl_trng.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group component/phy
    ../../../../../components/phy/device/phyksz8081/: fsl_phyksz8081.h fsl_phyksz8081.c
    ../../../../../components/phy/: fsl_phy.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1062/arm/: startup_MIMXRT1062.S
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkcmimxrt1060_flexspi_nor_config.c evkcmimxrt1060_flexspi_nor_config.h
  group azure-rtos/netxduo/addons/auto_ip
    ../../../../../rtos/azure-rtos/netxduo/addons/auto_ip/: nx_auto_ip.c nx_auto_ip.h
  group azure-rtos/netxduo/addons/cloud
    ../../../../../rtos/azure-rtos/netxduo/addons/cloud/: nx_cloud.c nx_cloud.h
  group azure-rtos/netxduo/addons/dhcp
    ../../../../../rtos/azure-rtos/netxduo/addons/dhcp/: nxd_dhcp_client.c nxd_dhcp_client.h nxd_dhcp_server.c nxd_dhcp_server.h nxd_dhcpv6_client.c nxd_dhcpv6_client.h nxd_dhcpv6_server.c nxd_dhcpv6_server.h
  group azure-rtos/netxduo/addons/dns
    ../../../../../rtos/azure-rtos/netxduo/addons/dns/: nxd_dns.c nxd_dns.h
  group azure-rtos/netxduo/addons/ftp
    ../../../../../rtos/azure-rtos/netxduo/addons/ftp/: nxd_ftp_client.c nxd_ftp_client.h nxd_ftp_server.c nxd_ftp_server.h
  group azure-rtos/netxduo/addons/http
    ../../../../../rtos/azure-rtos/netxduo/addons/http/: nxd_http_client.c nxd_http_client.h nxd_http_server.c nxd_http_server.h
  group azure-rtos/netxduo/addons/mdns
    ../../../../../rtos/azure-rtos/netxduo/addons/mdns/: nxd_mdns.c nxd_mdns.h
  group azure-rtos/netxduo/addons/mqtt
    ../../../../../rtos/azure-rtos/netxduo/addons/mqtt/: nxd_mqtt_client.c nxd_mqtt_client.h
  group azure-rtos/netxduo/addons/nat
    ../../../../../rtos/azure-rtos/netxduo/addons/nat/: nx_nat.c nx_nat.h
  group azure-rtos/netxduo/addons/pop3
    ../../../../../rtos/azure-rtos/netxduo/addons/pop3/: nxd_pop3_client.c nxd_pop3_client.h
  group azure-rtos/netxduo/addons/ppp
    ../../../../../rtos/azure-rtos/netxduo/addons/ppp/: nx_ppp.c nx_ppp.h
  group azure-rtos/netxduo/addons/pppoe
    ../../../../../rtos/azure-rtos/netxduo/addons/pppoe/: nx_pppoe_client.c nx_pppoe_client.h nx_pppoe_server.c nx_pppoe_server.h
  group azure-rtos/netxduo/addons/ptp
    ../../../../../rtos/azure-rtos/netxduo/addons/ptp/: nxd_ptp_client.c nxd_ptp_client.h
  group azure-rtos/netxduo/addons/smtp
    ../../../../../rtos/azure-rtos/netxduo/addons/smtp/: nxd_smtp_client.c nxd_smtp_client.h
  group azure-rtos/netxduo/addons/snmp
    ../../../../../rtos/azure-rtos/netxduo/addons/snmp/: nx_des.c nx_des.h nx_sha1.c nx_sha1.h nxd_snmp.c nxd_snmp.h
  group azure-rtos/netxduo/addons/sntp
    ../../../../../rtos/azure-rtos/netxduo/addons/sntp/: nxd_sntp_client.c nxd_sntp_client.h
  group azure-rtos/netxduo/addons/telnet
    ../../../../../rtos/azure-rtos/netxduo/addons/telnet/: nxd_telnet_client.c nxd_telnet_client.h nxd_telnet_server.c nxd_telnet_server.h
  group azure-rtos/netxduo/addons/tftp
    ../../../../../rtos/azure-rtos/netxduo/addons/tftp/: nxd_tftp_client.c nxd_tftp_client.h nxd_tftp_server.c nxd_tftp_server.h
  group azure-rtos/netxduo/addons/web
    ../../../../../rtos/azure-rtos/netxduo/addons/web/: nx_tcpserver.c nx_tcpserver.h nx_web_http_client.c nx_web_http_client.h nx_web_http_common.h nx_web_http_server.c nx_web_http_server.h
  group azure-rtos/netxduo/addons/websocket
    ../../../../../rtos/azure-rtos/netxduo/addons/websocket/: nx_websocket_client.c nx_websocket_client.h
  group azure-rtos/netxduo/addons/rtp
    ../../../../../rtos/azure-rtos/netxduo/addons/rtp/: nx_rtp_sender.c nx_rtp_sender.h
  group azure-rtos/netxduo/addons/rtsp
    ../../../../../rtos/azure-rtos/netxduo/addons/rtsp/: nx_rtsp_server.c nx_rtsp_server.h
  group azure-rtos/netxduo/common/inc
    ../../../../../rtos/azure-rtos/netxduo/common/inc/: nx_api.h nx_arp.h nx_http_proxy_client.h nx_icmp.h nx_icmpv4.h nx_icmpv6.h nx_igmp.h nx_ip.h nx_ipv4.h nx_ipv6.h nx_link.h nx_md5.h nx_mld.h nx_nd_cache.h nx_packet.h nx_rarp.h nx_system.h nx_tcp.h nx_udp.h nx_user_sample.h
  group azure-rtos/netxduo/crypto_libraries/inc
    ../../../../../rtos/azure-rtos/netxduo/crypto_libraries/inc/: nx_crypto.h nx_crypto_3des.h nx_crypto_aes.h nx_crypto_cbc.h nx_crypto_ccm.h nx_crypto_const.h nx_crypto_ctr.h nx_crypto_des.h nx_crypto_dh.h nx_crypto_drbg.h nx_crypto_ec.h nx_crypto_ecdh.h nx_crypto_ecdsa.h nx_crypto_ecjpake.h nx_crypto_gcm.h nx_crypto_hkdf.h nx_crypto_hmac.h nx_crypto_hmac_md5.h nx_crypto_hmac_sha1.h nx_crypto_hmac_sha2.h nx_crypto_hmac_sha5.h nx_crypto_huge_number.h nx_crypto_md5.h nx_crypto_method_self_test.h nx_crypto_null.h nx_crypto_phash.h nx_crypto_pkcs1_v1.5.h nx_crypto_rsa.h nx_crypto_sha1.h nx_crypto_sha2.h nx_crypto_sha5.h nx_crypto_tls_prf_1.h nx_crypto_tls_prf_sha256.h nx_crypto_tls_prf_sha384.h nx_crypto_tls_prf_sha512.h nx_crypto_xcbc_mac.h
  group azure-rtos/netxduo/nx_secure/inc
    ../../../../../rtos/azure-rtos/netxduo/nx_secure/inc/: nx_secure_crypto_table_self_test.h nx_secure_dtls.h nx_secure_dtls_api.h nx_secure_tls.h nx_secure_tls_api.h nx_secure_user_sample.h nx_secure_x509.h
  group azure-rtos/netxduo/nx_secure/ports
    ../../../../../rtos/azure-rtos/netxduo/nx_secure/ports/: nx_secure_port.h
  group azure-rtos/netxduo/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/netxduo/ports/cortex_m7/ac6/inc/: nx_port.h
  group azure-rtos/filex/common/inc
    ../../../../../rtos/azure-rtos/filex/common/inc/: fx_api.h fx_directory.h fx_fault_tolerant.h fx_file.h fx_media.h fx_system.h fx_unicode.h fx_user_sample.h fx_utility.h
  group azure-rtos/filex/ports/generic/inc
    ../../../../../rtos/azure-rtos/filex/ports/generic/inc/: fx_port.h
  group azure-rtos/threadx/common/inc
    ../../../../../rtos/azure-rtos/threadx/common/inc/: tx_api.h tx_block_pool.h tx_byte_pool.h tx_event_flags.h tx_initialize.h tx_mutex.h tx_queue.h tx_semaphore.h tx_thread.h tx_timer.h tx_trace.h tx_user_sample.h
  group azure-rtos/threadx/ports/common
    ../../../../../rtos/azure-rtos/threadx/ports/common/: tx_initialize_low_level.c
  group azure-rtos/threadx/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc/: tx_port.h
  group azure-rtos/threadx/ports/cortex_m7/ac6/src
    ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/src/: tx_thread_context_restore.S tx_thread_context_save.S tx_thread_interrupt_control.S tx_thread_interrupt_disable.S tx_thread_interrupt_restore.S tx_thread_schedule.S tx_thread_stack_build.S tx_thread_system_return.S tx_timer_interrupt.S
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
target pnp_temperature_controller flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1062DVL6B NXP
  pack: NXP.MIMXRT1062_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: pnp_temperature_controller.out
  AfterMake: fromelf.exe --output "$Lpnp_temperature_controller.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, __CLANG_ARM, CPU_MIMXRT1062DVL6B, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, NXD_MQTT_OVER_WEBSOCKET, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, DATA_SECTION_IS_CACHEABLE=1, MCUXPRESSO_SDK, AZ_NO_PRECONDITION_CHECKING, NX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE, FSL_RTOS_THREADX
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: ../../../../../rtos/azure-rtos/binary/netxduo/cortex_m7/mdk/libnetxduo.lib ../../../../../rtos/azure-rtos/binary/filex/cortex_m7/mdk/libfilex.lib ../../../../../rtos/azure-rtos/binary/threadx/cortex_m7/mdk/libthreadx.lib --remove --entry=Reset_Handler --diag_suppress 6314 --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-D__use_flash16MB__=1"
target pnp_temperature_controller sdram_release (ARM-ADS)
  device: MIMXRT1062DVL6B NXP
  pack: NXP.MIMXRT1062_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: pnp_temperature_controller.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, __CLANG_ARM, CPU_MIMXRT1062DVL6B, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, NXD_MQTT_OVER_WEBSOCKET, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK, AZ_NO_PRECONDITION_CHECKING, NX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE, FSL_RTOS_THREADX
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_sdram.scf
  link misc: as above
target pnp_temperature_controller flexspi_nor_release (ARM-ADS)
  device: MIMXRT1062DVL6B NXP
  pack: NXP.MIMXRT1062_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: pnp_temperature_controller.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, __CLANG_ARM, CPU_MIMXRT1062DVL6B, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, NXD_MQTT_OVER_WEBSOCKET, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, DATA_SECTION_IS_CACHEABLE=1, MCUXPRESSO_SDK, AZ_NO_PRECONDITION_CHECKING, NX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE, FSL_RTOS_THREADX
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: as above
