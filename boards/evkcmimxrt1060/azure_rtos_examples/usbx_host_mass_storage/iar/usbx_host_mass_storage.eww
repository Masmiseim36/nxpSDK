<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>usbx_host_mass_storage</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
      <member>
        <project>usbx_host_mass_storage</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
      <member>
        <project>usbx_host_mass_storage</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>usbx_host_mass_storage</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_debug</name>
      <member>
        <project>usbx_host_mass_storage</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_release</name>
      <member>
        <project>usbx_host_mass_storage</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>usbx_host_mass_storage</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>usbx_host_mass_storage</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/usbx_host_mass_storage.ewp</path>
  </project>
</workspace>
