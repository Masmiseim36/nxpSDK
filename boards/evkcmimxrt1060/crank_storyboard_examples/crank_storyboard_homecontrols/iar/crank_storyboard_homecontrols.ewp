# IAR project crank_storyboard_homecontrols.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6B NXP MIMXRT1062xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1062DVL6B; SKIP_SYSCLK_INIT; XIP_BOOT_HEADER_DCD_ENABLE=1; FLEXRAM_CFG_ENABLE=1; GRE_TARGET_OS_freertos; GRE_TARGET_CPU_cortexm7; GRE_FEATURE_VFS_RESOURCES; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; CPU_MIMXRT1062DVL6B_cm7; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../..; ../../../../../devices/MIMXRT1062/drivers; ../../../../../components/ft5406_rt; ../../../../../components/gt911; ../../../../../components/video; ../../../../../middleware/Crank_Software/cortexM7/include/freertos; ../../../../../middleware/Crank_Software/cortexM7/include; ../../../../../devices/MIMXRT1062; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../devices/MIMXRT1062/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../devices/MIMXRT1062/utilities; ../../../../../devices/MIMXRT1062/xip; ../../../xip; ../../../../../rtos/freertos/freertos-kernel/include; ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F; ../../template; ../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_CLEAR_BSS; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../../..
  ILINK.IlinkOutputFile: crank_storyboard_homecontrols.out
  ILINK.IlinkConfigDefines: __use_flash16MB__=1
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/Crank_Software/cortexM7/lib/iar/libgre.a; ../../../../../middleware/Crank_Software/cortexM7/lib/iar/libgreal.a; ../../../../../middleware/Crank_Software/cortexM7/lib/iar/libsbimage.a; ../../../../../middleware/Crank_Software/cortexM7/lib/iar/libsbvfs.a; ../../../../../middleware/Crank_Software/cortexM7/plugins/iar/libgre-plugin-animation.a; ../../../../../middleware/Crank_Software/cortexM7/plugins/iar/libgre-plugin-canvas.a; ../../../../../middleware/Crank_Software/cortexM7/plugins/iar/libgre-plugin-capture-playback.a; ../../../../../middleware/Crank_Software/cortexM7/plugins/iar/libgre-plugin-ccallback.a; ../../../../../middleware/Crank_Software/cortexM7/plugins/iar/libgre-plugin-circle.a; ../../../../../middleware/Crank_Software/cortexM7/plugins/iar/libgre-plugin-greio.a; ../../../../../middleware/Crank_Software/cortexM7/plugins/iar/libgre-plugin-logger.a; ../../../../../middleware/Crank_Software/cortexM7/plugins/iar/libgre-plugin-lua.a; ../../../../../middleware/Crank_Software/cortexM7/plugins/iar/libgre-plugin-luagredom.a; ../../../../../middleware/Crank_Software/cortexM7/plugins/iar/libgre-plugin-metrics.a; ../../../../../middleware/Crank_Software/cortexM7/plugins/iar/libgre-plugin-poly.a; ../../../../../middleware/Crank_Software/cortexM7/plugins/iar/libgre-plugin-rtext.a; ../../../../../middleware/Crank_Software/cortexM7/plugins/iar/libgre-plugin-screen-fade.a; ../../../../../middleware/Crank_Software/cortexM7/plugins/iar/libgre-plugin-screen-path.a; ../../../../../middleware/Crank_Software/cortexM7/plugins/iar/libgre-plugin-timer.a; ../../../../../middleware/Crank_Software/cortexM7/plugins/iar/libgre-plugin-sbimage-soil.a; ../../../../../middleware/Crank_Software/cortexM7/plugins/iar/librender-plugin-swrender.a; ../../../../../middleware/Crank_Software/cortexM7/lib/iar/liblogging-util.a; ../../../../../middleware/Crank_Software/cortexM7/lib/iar/libgreio.a; ../../../../../middleware/Crank_Software/cortexM7/lib/iar/libswrender.a; ../../../../../middleware/Crank_Software/cortexM7/lib/iar/libsblua.a; ../../../../../middleware/Crank_Software/cortexM7/lib/iar/libsoil.a; ../../../../../middleware/Crank_Software/cortexM7/plugins/iar/libfont-plugin-freetype.a; ../../../../../middleware/Crank_Software/cortexM7/lib/iar/libsbfreetype.a; ../../../../../middleware/Crank_Software/cortexM7/lib/iar/libpng.a; ../../../../../middleware/Crank_Software/cortexM7/lib/iar/libsbz.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1062DVL6B; SKIP_SYSCLK_INIT; XIP_BOOT_HEADER_DCD_ENABLE=1; FLEXRAM_CFG_ENABLE=1; GRE_TARGET_OS_freertos; GRE_TARGET_CPU_cortexm7; GRE_FEATURE_VFS_RESOURCES; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; CPU_MIMXRT1062DVL6B_cm7; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS
  AARM.ADefines: NDEBUG; __STARTUP_CLEAR_BSS; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: HomeControls.h freertos_sbengine_pxp.c sbengine_plugins.h sbengine_task_pxp.c FreeRTOSConfig.h
  group board
    ../: lcd.c lcd.h pin_mux.c pin_mux.h peripherals.c peripherals.h touch.c touch.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.md
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_cache.c fsl_cache.h fsl_elcdif.c fsl_elcdif.h fsl_pxp.c fsl_pxp.h fsl_lpi2c.c fsl_lpi2c.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group touchpanel
    ../../../../../components/ft5406_rt/: fsl_ft5406_rt.h fsl_ft5406_rt.c
    ../../../../../components/gt911/: fsl_gt911.h fsl_gt911.c
  group video
    ../../../../../components/video/: fsl_video_common.h fsl_video_common.c
  group freertos/freertos-kernel
    ../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/portable
    ../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: heap_3.c ReadMe.url
  group freertos/freertos-kernel/portable/IAR/ARM_CM4F
    ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos-kernel/include
    ../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c fsl_assert.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkcmimxrt1060_flexspi_nor_config.c evkcmimxrt1060_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
