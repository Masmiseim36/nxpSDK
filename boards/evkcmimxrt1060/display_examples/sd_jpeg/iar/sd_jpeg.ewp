# IAR project sd_jpeg.ewp, settings and files
configuration sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6B NXP MIMXRT1062xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; USE_SDRAM=1; SKIP_SYSCLK_INIT=1; DATA_SECTION_IS_CACHEABLE=1; SDK_DEBUGCONSOLE_UART; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1062DVL6B; MIMXRT1062_SERIES; OSA_USED; USE_RTOS=0; SD_ENABLED=1
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../xip; ../../../../../devices/MIMXRT1062/drivers; ../../../../../CMSIS/Core/Include; ../../../../../CMSIS/Core/Include/m-profile; ../../../../../devices/MIMXRT1062; ../../../../../devices/MIMXRT1062/periph; ../../../../../devices/MIMXRT1062/xip; ../../../../../devices/MIMXRT1062/utilities/debug_console_lite; ../../../../../components/lists; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../components/gpio; ../../../../../components/uart; ../../../../../components/osa; ../../../../../components/video; ../../../../../components/video/display/dc; ../../../../../components/video/display; ../../../../../components/video/display/dc/elcdif; ../../../../../middleware/fatfs/source; ../../../../../middleware/fatfs/template; ../../../../../middleware/fatfs/source/fsl_sd_disk; ../../../../../middleware/sdmmc/common; ../../../../../middleware/sdmmc/osa; ../../../../../middleware/sdmmc/sd; ../../../../../middleware/sdmmc/host/usdhc; ../../../../../middleware/libjpeg/inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT1062DVL6B; MIMXRT1062_SERIES; OSA_USED
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: sd_jpeg.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x20000
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_sdram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; XIP_EXTERNAL_FLASH=1; USE_SDRAM=1; SKIP_SYSCLK_INIT=1; DATA_SECTION_IS_CACHEABLE=1; SDK_DEBUGCONSOLE_UART; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1062DVL6B; MIMXRT1062_SERIES; OSA_USED; USE_RTOS=0; SD_ENABLED=1
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor_sdram.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_SDRAM=1; SKIP_SYSCLK_INIT=1; DATA_SECTION_IS_CACHEABLE=1; SDK_DEBUGCONSOLE_UART; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1062DVL6B; MIMXRT1062_SERIES; OSA_USED; USE_RTOS=0; SD_ENABLED=1
  ICCARM.CCOptLevel: 3
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; XIP_EXTERNAL_FLASH=1; USE_SDRAM=1; SKIP_SYSCLK_INIT=1; DATA_SECTION_IS_CACHEABLE=1; SDK_DEBUGCONSOLE_UART; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1062DVL6B; MIMXRT1062_SERIES; OSA_USED; USE_RTOS=0; SD_ENABLED=1
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor_sdram.icf
  group source
    ../: pics.zip sd_jpeg.c jconfig.h sdmmc_config.h sdmmc_config.c display_support.h display_support.c ffconf_gen.h fsl_os_abstraction_config.h mcux_config.h
  group source/template
    ../../../../../middleware/fatfs/template/: ffconf.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group xip
    ../../../xip/: evkcmimxrt1060_flexspi_nor_config.c evkcmimxrt1060_flexspi_nor_config.h
    ../../../: dcd.c dcd.h
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_elcdif.c fsl_elcdif.h fsl_gpc.c fsl_gpc.h fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_pmu.h fsl_pmu.c fsl_src.c fsl_src.h fsl_usdhc.c fsl_usdhc.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv7m_cachel1.h armv7m_mpu.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h MIMXRT1062_COMMON.h system_MIMXRT1062.c system_MIMXRT1062.h
  group device/periph
    ../../../../../devices/MIMXRT1062/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_AIPSTZ.h PERI_AOI.h PERI_BEE.h PERI_CAN.h PERI_CCM.h PERI_CCM_ANALOG.h PERI_CM7_MCM.h PERI_CMP.h PERI_CSI.h PERI_CSU.h PERI_DCDC.h PERI_DCP.h PERI_DMA.h PERI_DMAMUX.h PERI_ENC.h PERI_ENET.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_KPP.h PERI_LCDIF.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_OCOTP.h PERI_PGC.h PERI_PIT.h PERI_PMU.h PERI_PWM.h PERI_PXP.h PERI_ROMC.h PERI_RTWDOG.h PERI_SEMC.h PERI_SNVS.h PERI_SPDIF.h PERI_SRC.h PERI_TEMPMON.h PERI_TMR.h PERI_TRNG.h PERI_TSC.h PERI_USB.h PERI_USBNC.h PERI_USBPHY.h PERI_USB_ANALOG.h PERI_USDHC.h PERI_WDOG.h PERI_XBARA.h PERI_XBARB.h PERI_XTALOSC24M.h
  group startup/iar
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/gpio
    ../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c fsl_os_abstraction.h
  group video
    ../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../components/video/display/dc/: fsl_dc_fb.h
    ../../../../../components/video/display/: fsl_display.h
    ../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.h fsl_dc_fb_elcdif.c
  group fatfs/source
    ../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_sd_disk
    ../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group sdmmc/common
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h fsl_sdmmc_common.c
  group sdmmc/osa
    ../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group sdmmc/sd
    ../../../../../middleware/sdmmc/sd/: fsl_sd.c fsl_sd.h
  group sdmmc/host/usdhc
    ../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h fsl_sdmmc_host.h
  group sdmmc/host/usdhc/non_blocking
    ../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group libjpeg/inc
    ../../../../../middleware/libjpeg/inc/: cderror.h cdjpeg.h jdct.h jerror.h jinclude.h jmemsys.h jmorecfg.h jpegint.h jpeglib.h jversion.h transupp.h
  group libjpeg/src
    ../../../../../middleware/libjpeg/src/: jaricom.c jcapimin.c jcapistd.c jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcprepct.c jcsample.c jctrans.c jdapimin.c jdapistd.c jdarith.c jdatadst.c jdatasrc.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jdtrans.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jmemmgr.c jmemnobs.c jquant1.c jquant2.c jutils.c
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
