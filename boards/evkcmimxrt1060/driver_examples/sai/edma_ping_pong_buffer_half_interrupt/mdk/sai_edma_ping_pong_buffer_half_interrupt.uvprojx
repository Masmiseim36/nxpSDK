# Keil uVision project sai_edma_ping_pong_buffer_half_interrupt.uvprojx, settings and files
target sai_edma_ping_pong_buffer_half_interrupt flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1062DVL6B NXP
  pack: NXP.MIMXRT1062_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: sai_edma_ping_pong_buffer_half_interrupt.out
  AfterMake: fromelf.exe --output "$Lsai_edma_ping_pong_buffer_half_interrupt.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, XIP_BOOT_HEADER_ENABLE=1, XIP_EXTERNAL_FLASH=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1062DVL6B, MIMXRT1062_SERIES, SDK_I2C_BASED_COMPONENT_USED=1, CODEC_MULTI_ADAPTERS=1, CODEC_CS42448_ENABLE, CODEC_WM8962_ENABLE
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../xip;../../../../../../devices/MIMXRT1062/drivers;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MIMXRT1062;../../../../../../devices/MIMXRT1062/periph;../../../../../../devices/MIMXRT1062/xip;../../../../../../devices/MIMXRT1062/utilities/debug_console_lite;../../../../../../devices/MIMXRT1062/utilities/str;../../../../../../components/codec/i2c;../../../../../../components/codec;../../../../../../components/codec/port;../../../../../../components/codec/port/wm8962;../../../../../../components/codec/port/cs42448;../../../../../../components/codec/cs42448;../../../../../../components/codec/wm8962;../../../../../../components/i2c;../../../../../../components/uart
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1062DVL6B, MIMXRT1062_SERIES
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: --remove --predefine=\"-DXIP_BOOT_HEADER_ENABLE=1\" --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: sai_edma_ping_pong_buffer_half_interrupt.c music.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group xip
    ../../../../xip/: evkcmimxrt1060_flexspi_nor_config.c evkcmimxrt1060_flexspi_nor_config.h
    ../../../../: dcd.c dcd.h
    ../../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group drivers
    ../../../../../../devices/MIMXRT1062/drivers/: fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_gpc.c fsl_gpc.h fsl_gpio.h fsl_gpio.c fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.h fsl_lpuart.c fsl_pmu.h fsl_pmu.c fsl_sai_edma.h fsl_sai_edma.c fsl_sai.h fsl_sai.c fsl_src.c fsl_src.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv7m_cachel1.h armv7m_mpu.h
  group device
    ../../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h MIMXRT1062_COMMON.h system_MIMXRT1062.c system_MIMXRT1062.h
  group device/periph
    ../../../../../../devices/MIMXRT1062/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_AIPSTZ.h PERI_AOI.h PERI_BEE.h PERI_CAN.h PERI_CCM.h PERI_CCM_ANALOG.h PERI_CM7_MCM.h PERI_CMP.h PERI_CSI.h PERI_CSU.h PERI_DCDC.h PERI_DCP.h PERI_DMA.h PERI_DMAMUX.h PERI_ENC.h PERI_ENET.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_KPP.h PERI_LCDIF.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_OCOTP.h PERI_PGC.h PERI_PIT.h PERI_PMU.h PERI_PWM.h PERI_PXP.h PERI_ROMC.h PERI_RTWDOG.h PERI_SEMC.h PERI_SNVS.h PERI_SPDIF.h PERI_SRC.h PERI_TEMPMON.h PERI_TMR.h PERI_TRNG.h PERI_TSC.h PERI_USB.h PERI_USBNC.h PERI_USBPHY.h PERI_USB_ANALOG.h PERI_USDHC.h PERI_WDOG.h PERI_XBARA.h PERI_XBARB.h PERI_XTALOSC24M.h
  group startup/arm
    ../../../../../../devices/MIMXRT1062/arm/: startup_MIMXRT1062.S
  group utilities
    ../../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
    ../../../../../../devices/MIMXRT1062/utilities/: fsl_memcpy.S
  group utilities/str
    ../../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group codec
    ../../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
    ../../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../../components/codec/cs42448/: fsl_cs42448.h fsl_cs42448.c
    ../../../../../../components/codec/wm8962/: fsl_wm8962.h fsl_wm8962.c
  group codec/port
    ../../../../../../components/codec/port/: fsl_codec_adapter.c fsl_codec_adapter.h fsl_codec_adapter.h
  group codec/port/wm8962
    ../../../../../../components/codec/port/wm8962/: fsl_codec_wm8962_adapter.h fsl_codec_wm8962_adapter.c
  group codec/port/cs42448
    ../../../../../../components/codec/port/cs42448/: fsl_codec_cs42448_adapter.h fsl_codec_cs42448_adapter.c
  group component/i2c
    ../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
target sai_edma_ping_pong_buffer_half_interrupt flexspi_nor_release (ARM-ADS)
  device: MIMXRT1062DVL6B NXP
  pack: NXP.MIMXRT1062_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: sai_edma_ping_pong_buffer_half_interrupt.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, XIP_BOOT_HEADER_ENABLE=1, XIP_EXTERNAL_FLASH=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1062DVL6B, MIMXRT1062_SERIES, SDK_I2C_BASED_COMPONENT_USED=1, CODEC_MULTI_ADAPTERS=1, CODEC_CS42448_ENABLE, CODEC_WM8962_ENABLE
  c misc: as above
  c include: as above
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1062DVL6B, MIMXRT1062_SERIES
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: as above
