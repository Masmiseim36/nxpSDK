<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>snvs_sw_zmk</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>snvs_sw_zmk</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>snvs_sw_zmk</project>
        <configuration>sdram_debug</configuration>
      </member>
      <member>
        <project>snvs_sw_zmk</project>
        <configuration>sdram_release</configuration>
      </member>
      <member>
        <project>snvs_sw_zmk</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
      <member>
        <project>snvs_sw_zmk</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>snvs_sw_zmk</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>snvs_sw_zmk</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdram_debug</name>
      <member>
        <project>snvs_sw_zmk</project>
        <configuration>sdram_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdram_release</name>
      <member>
        <project>snvs_sw_zmk</project>
        <configuration>sdram_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_debug</name>
      <member>
        <project>snvs_sw_zmk</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_release</name>
      <member>
        <project>snvs_sw_zmk</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/snvs_sw_zmk.ewp</path>
  </project>
</workspace>
