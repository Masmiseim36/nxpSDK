# Keil uVision project ew_gui_graphics_accelerator.uvprojx, settings and files
target ew_gui_graphics_accelerator flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1062DVL6B NXP
  pack: NXP.MIMXRT1062_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ew_gui_graphics_accelerator.out
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1062DVL6B, SKIP_SYSCLK_INIT, XIP_BOOT_HEADER_DCD_ENABLE=1, EW_USE_DOUBLE_BUFFER=1, EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565, EW_SURFACE_ROTATION=0, EW_USE_FREE_RTOS=0, CPU_MIMXRT1062DVL6B_cm7, MCUXPRESSO_SDK, SDK_I2C_BASED_COMPONENT_USED=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../GeneratedCode;../../../../../devices/MIMXRT1062/drivers;../../../../../components/ft5406_rt;../../../../../components/gt911;../../../../../components/video;../../../../../devices/MIMXRT1062/utilities/str;../../../../../devices/MIMXRT1062/utilities/debug_console_lite;../../../../../middleware/EmbeddedWizard/TargetSpecific/evkcmimxrt1060;../../../../../middleware/EmbeddedWizard/PlatformPackage/evkcmimxrt1060/RGB565;../../../../../middleware/EmbeddedWizard/PlatformPackage/evkcmimxrt1060/RTE;../../../../../devices/MIMXRT1062;../../../../../components/uart;../../../../../components/lists;../../../../../devices/MIMXRT1062/xip;../../../xip;../../../../../CMSIS/Core/Include
  asm define: DEBUG, __STARTUP_CLEAR_BSS, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1010/RTE/libewrte-m7-keil.lib ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1010/RGB565/libewgfx-m7-keil.lib --remove --entry=Reset_Handler --diag_suppress 6314 --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-D__use_flash16MB__=1"
  group board
    ../: board.c board.h clock_config.c clock_config.h dcd.c dcd.h ewconfig.h ewdef.h pin_mux.c pin_mux.h
  group source
    ../: main.c ewmain.c ewmain.h DeviceDriver.c DeviceDriver.h
  group doc
    ../: readme.md
  group EmbeddedWizard/GeneratedCode
    ../GeneratedCode/: Accelerator.c Application.c Core.c Effects.c Graphics.c GraphicsSystem.c Resources.c Templates.c Views.c WidgetSet.c Accelerator.h Application.h Core.h Effects.h Graphics.h GraphicsSystem.h Resources.h Templates.h Views.h WidgetSet.h _AcceleratorAccelerator.h _AcceleratorFontLarge.h _AcceleratorFontMedium.h _AcceleratorFontSmall.h _AcceleratorGraphicsFactory.h _AcceleratorImgBlend1.h _AcceleratorImgBlend2.h _AcceleratorImgBlend3.h _AcceleratorImgBlend4.h _AcceleratorImgBlend5.h _AcceleratorImgBlend6.h _AcceleratorImgBlend7.h _AcceleratorImgCopy1.h _AcceleratorImgCopy2.h _AcceleratorImgCopy3.h _AcceleratorImgCopy4.h _AcceleratorImgCopy5.h _AcceleratorLogo.h _ApplicationApplication.h _CoreCursorEvent.h _CoreCursorGrabEvent.h _CoreCursorHit.h _CoreDialogContext.h _CoreDragEvent.h _CoreEvent.h _CoreGroup.h _CoreKeyEvent.h _CoreKeyPressHandler.h _CoreLayoutContext.h _CoreLayoutQuadContext.h _CoreModalContext.h _CoreOutline.h _CoreQuadView.h _CoreRectView.h _CoreResource.h _CoreRoot.h _CoreSimpleTouchHandler.h _CoreTask.h _CoreTaskQueue.h _CoreTimer.h _CoreView.h _EffectsEffectTimerClass.h _GraphicsCanvas.h _GraphicsSystemDeviceClass.h _ResourcesBitmap.h _ResourcesFont.h _ResourcesFontMedium.h _TemplatesDeviceClass.h _ViewsFrame.h _ViewsImage.h _ViewsRectangle.h _ViewsText.h _WidgetSetPushButton.h _WidgetSetPushButtonConfig.h _WidgetSetPushButtonMedium.h _WidgetSetSwitchMedium.h _WidgetSetToggleButton.h _WidgetSetToggleButtonConfig.h _WidgetSetWidgetConfig.h ewlocale.h
  group EmbeddedWizard/Project
    ../EmbeddedWizard/: Accelerator.ewu Application.ewu GraphicsAccelerator.ewp GraphicsAccelerator.ews GraphicsSystem.ewu
  group EmbeddedWizard/Project/Res
    ../EmbeddedWizard/Res/: Citron.png EmWiLogo.png Flower.png Img_01.jpg Img_02.jpg Img_03.jpg Img_04.jpg Img_05.jpg Kiwi.png Orange.png Pretzel.png Tomato.png Trefoil.png
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_cache.c fsl_cache.h fsl_elcdif.c fsl_elcdif.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_pxp.c fsl_pxp.h fsl_lpi2c.c fsl_lpi2c.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group touchpanel
    ../../../../../components/ft5406_rt/: fsl_ft5406_rt.h fsl_ft5406_rt.c
    ../../../../../components/gt911/: fsl_gt911.h fsl_gt911.c
  group video
    ../../../../../components/video/: fsl_video_common.h fsl_video_common.c
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c fsl_assert.h
  group EmbeddedWizard/TargetSpecific/evkcmimxrt1060
    ../../../../../middleware/EmbeddedWizard/TargetSpecific/evkcmimxrt1060/: ew_bsp_clock.c ew_bsp_console.c ew_bsp_display.c ew_bsp_event.c ew_bsp_graphics.c ew_bsp_inout.c ew_bsp_system.c ew_bsp_touch.c ew_bsp_clock.h ew_bsp_console.h ew_bsp_display.h ew_bsp_event.h ew_bsp_graphics.h ew_bsp_inout.h ew_bsp_system.h ew_bsp_touch.h
  group EmbeddedWizard/PlatformPackage/evkcmimxrt1060/RGB565
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkcmimxrt1060/RGB565/: ewextgfx.c ewextbmp.h ewextfnt.h ewextgfx.h ewextpxl_RGB565.h ewgfx.h ewgfxcore.h ewgfxdefs.h ewgfxdriver.h ewgfxlinks.h ewgfxres.h ewgfxtasks.h
  group EmbeddedWizard/PlatformPackage/evkcmimxrt1060/RTE
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkcmimxrt1060/RTE/: ewextrte.c ewextrte.h ewrte.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1062/arm/: startup_MIMXRT1062.S
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkcmimxrt1060_flexspi_nor_config.c evkcmimxrt1060_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
target ew_gui_graphics_accelerator flexspi_nor_release (ARM-ADS)
  device: MIMXRT1062DVL6B NXP
  pack: NXP.MIMXRT1062_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ew_gui_graphics_accelerator.out
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1062DVL6B, SKIP_SYSCLK_INIT, XIP_BOOT_HEADER_DCD_ENABLE=1, EW_USE_DOUBLE_BUFFER=1, EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565, EW_SURFACE_ROTATION=0, EW_USE_FREE_RTOS=0, CPU_MIMXRT1062DVL6B_cm7, MCUXPRESSO_SDK, SDK_I2C_BASED_COMPONENT_USED=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_CLEAR_BSS, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: as above
