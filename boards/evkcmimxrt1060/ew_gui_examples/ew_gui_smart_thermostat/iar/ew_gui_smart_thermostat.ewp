# IAR project ew_gui_smart_thermostat.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6B NXP MIMXRT1062xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1062DVL6B; SKIP_SYSCLK_INIT; XIP_BOOT_HEADER_DCD_ENABLE=1; EW_USE_DOUBLE_BUFFER=1; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565; EW_SURFACE_ROTATION=0; EW_USE_FREE_RTOS=0; CPU_MIMXRT1062DVL6B_cm7; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../GeneratedCode; ../../../../../devices/MIMXRT1062/drivers; ../../../../../components/ft5406_rt; ../../../../../components/gt911; ../../../../../components/video; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../devices/MIMXRT1062/utilities/debug_console_lite; ../../../../../middleware/EmbeddedWizard/TargetSpecific/evkcmimxrt1060; ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkcmimxrt1060/RGB565; ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkcmimxrt1060/RTE; ../../../../../devices/MIMXRT1062; ../../../../../components/uart; ../../../../../components/lists; ../../../../../devices/MIMXRT1062/xip; ../../../xip; ../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_CLEAR_BSS; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: ew_gui_smart_thermostat.out
  ILINK.IlinkConfigDefines: __use_flash16MB__=1
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1010/RTE/libewrte-m7-iar.a; ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1010/RGB565/libewgfx-m7-iar.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1062DVL6B; SKIP_SYSCLK_INIT; XIP_BOOT_HEADER_DCD_ENABLE=1; EW_USE_DOUBLE_BUFFER=1; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565; EW_SURFACE_ROTATION=0; EW_USE_FREE_RTOS=0; CPU_MIMXRT1062DVL6B_cm7; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1
  AARM.ADefines: NDEBUG; __STARTUP_CLEAR_BSS; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../: board.c board.h clock_config.c clock_config.h dcd.c dcd.h ewconfig.h ewdef.h pin_mux.c pin_mux.h
  group source
    ../: main.c ewmain.c ewmain.h DeviceDriver.c DeviceDriver.h
  group doc
    ../: readme.md
  group EmbeddedWizard/GeneratedCode
    ../GeneratedCode/: Application.c Core.c Effects.c Graphics.c Resources.c Templates.c Thermostat.c Views.c WidgetSet.c Application.h Core.h Effects.h Graphics.h Resources.h Templates.h Thermostat.h Views.h WidgetSet.h _ApplicationApplication.h _CoreCursorEvent.h _CoreCursorGrabEvent.h _CoreCursorHit.h _CoreDialogContext.h _CoreDragEvent.h _CoreEvent.h _CoreGroup.h _CoreKeyEvent.h _CoreKeyPressHandler.h _CoreLayoutContext.h _CoreLayoutQuadContext.h _CoreModalContext.h _CoreOutline.h _CorePropertyObserver.h _CoreQuadView.h _CoreRectView.h _CoreResource.h _CoreRoot.h _CoreRotateTouchHandler.h _CoreSimpleTouchHandler.h _CoreTask.h _CoreTaskQueue.h _CoreTimer.h _CoreView.h _EffectsEffect.h _EffectsEffectTimerClass.h _EffectsInt32Effect.h _EffectsTimingList.h _GraphicsCanvas.h _GraphicsPath.h _GraphicsWarpMatrix.h _ResourcesBitmap.h _ResourcesFont.h _TemplatesDeviceClass.h _ThermostatBackgroundDay.h _ThermostatBackgroundDefault.h _ThermostatBackgroundNight.h _ThermostatButtonDay.h _ThermostatButtonNight.h _ThermostatButtonVacation.h _ThermostatController.h _ThermostatDeviceClass.h _ThermostatErgosign.h _ThermostatFontL.h _ThermostatFontM.h _ThermostatFontXXL.h _ThermostatNeedle.h _ThermostatSwingSwitch.h _ThermostatSymbolFan.h _ThermostatSymbolHeadCool.h _ThermostatTemperatureController.h _ThermostatThermostat.h _ThermostatVertBar.h _ThermostatWheels.h _ViewsFrame.h _ViewsImage.h _ViewsStrokePath.h _ViewsText.h _ViewsWallpaper.h _ViewsWarpImage.h _ViewsWarpView.h _WidgetSetRadioButton.h _WidgetSetRadioButtonConfig.h _WidgetSetToggleButton.h _WidgetSetToggleButtonConfig.h _WidgetSetVerticalSlider.h _WidgetSetVerticalSliderConfig.h _WidgetSetWidgetConfig.h ewlocale.h
  group EmbeddedWizard/Project
    ../EmbeddedWizard/: Application.ewu SmartThermostat.ewp SmartThermostat.ews Thermostat.ewu
  group EmbeddedWizard/Project/Res
    ../EmbeddedWizard/Res/: BackgroundDay.png BackgroundDefault.png BackgroundNight.png ButtonDay.png ButtonNight.png ButtonVacation.png Controller.png Ergosign.png Needle.png SwingSwitch.png SymbolFan.png SymbolHeadCool.png VertBar.png Wheels.png
  group EmbeddedWizard/TargetSpecific/evkcmimxrt1060
    ../../../../../middleware/EmbeddedWizard/TargetSpecific/evkcmimxrt1060/: ew_bsp_clock.c ew_bsp_console.c ew_bsp_display.c ew_bsp_event.c ew_bsp_graphics.c ew_bsp_inout.c ew_bsp_system.c ew_bsp_touch.c ew_bsp_clock.h ew_bsp_console.h ew_bsp_display.h ew_bsp_event.h ew_bsp_graphics.h ew_bsp_inout.h ew_bsp_system.h ew_bsp_touch.h
  group EmbeddedWizard/PlatformPackage/evkcmimxrt1060/RGB565
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkcmimxrt1060/RGB565/: ewextgfx.c ewextbmp.h ewextfnt.h ewextgfx.h ewextpxl_RGB565.h ewgfx.h ewgfxcore.h ewgfxdefs.h ewgfxdriver.h ewgfxlinks.h ewgfxres.h ewgfxtasks.h
  group EmbeddedWizard/PlatformPackage/evkcmimxrt1060/RTE
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkcmimxrt1060/RTE/: ewextrte.c ewextrte.h ewrte.h
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_cache.c fsl_cache.h fsl_elcdif.c fsl_elcdif.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_pxp.c fsl_pxp.h fsl_lpi2c.c fsl_lpi2c.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group touchpanel
    ../../../../../components/ft5406_rt/: fsl_ft5406_rt.h fsl_ft5406_rt.c
    ../../../../../components/gt911/: fsl_gt911.h fsl_gt911.c
  group video
    ../../../../../components/video/: fsl_video_common.h fsl_video_common.c
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c fsl_assert.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkcmimxrt1060_flexspi_nor_config.c evkcmimxrt1060_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
