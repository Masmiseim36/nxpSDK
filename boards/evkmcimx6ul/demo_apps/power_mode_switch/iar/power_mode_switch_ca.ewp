# IAR project power_mode_switch_ca.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX6G3 NXP MCIMX6G3
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: DEBUG; CPU_MCIMX6G3DVM05; FSL_RTOS_FREE_RTOS; EVK_MCIMX6UL
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CA9; ../../../../../rtos/freertos_9.0.0/Source/include; ..; ../../../../../CORTEXA/Include; ../../../../../devices; ../../../../../rtos/freertos_9.0.0/Source; ../../..; ../../../../../devices/MCIMX6G3/drivers; ../../../../../platform/utilities/debug_console; ../../../../../platform/utilities/debug_console/io; ../../../../../platform/utilities/debug_console/str; ../../../../../devices/MCIMX6G3/utilities; ../../../../../devices/MCIMX6G3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; NO_CRP; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: power_mode_switch_ca.out
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_lpm_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCIMX6G3DVM05; FSL_RTOS_FREE_RTOS; EVK_MCIMX6UL
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NO_CRP; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ./: lpm_ocram_asm.s
    ../: power_mode_switch.c power_mode_switch.h FreeRTOSConfig.h lpm.c lpm.h lpm_ocram.c
  group freertos
    ../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
    ../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h
    ../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group freertos/portable
    ../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CA9/: port.c portASM.s portASM.h portmacro.h
  group startup
    ../../../../../devices/MCIMX6G3/iar/: startup_MCIMX6G3.s
    ../../../../../devices/MCIMX6G3/: system_MCIMX6G3.c system_MCIMX6G3.h
  group doc
    ../: readme.txt
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config_ocram.c clock_config.c clock_config.h
  group drivers
    ../../../../../devices/MCIMX6G3/drivers/: fsl_gpc.c fsl_gpc.h fsl_gpt.c fsl_gpt.h fsl_epit.c fsl_epit.h fsl_gpio.h fsl_gpio.c fsl_uart.h fsl_uart.c fsl_common.h fsl_common.c fsl_iomuxc.h fsl_clock.h fsl_clock.c
  group utilities
    ../../../../../devices/MCIMX6G3/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_io.c fsl_io.h fsl_log.c fsl_log.h fsl_str.c fsl_str.h
