<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>ii2c_polling_b2b_transfer_master</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>ii2c_polling_b2b_transfer_master</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>ii2c_polling_b2b_transfer_master</project>
        <configuration>DDR_Debug</configuration>
      </member>
      <member>
        <project>ii2c_polling_b2b_transfer_master</project>
        <configuration>DDR_Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>ii2c_polling_b2b_transfer_master</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>ii2c_polling_b2b_transfer_master</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>DDR_Debug</name>
      <member>
        <project>ii2c_polling_b2b_transfer_master</project>
        <configuration>DDR_Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>DDR_Release</name>
      <member>
        <project>ii2c_polling_b2b_transfer_master</project>
        <configuration>DDR_Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/ii2c_polling_b2b_transfer_master.ewp</path>
  </project>
</workspace>
