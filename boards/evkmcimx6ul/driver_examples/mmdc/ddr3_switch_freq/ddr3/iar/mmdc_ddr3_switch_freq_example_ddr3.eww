<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>mmdc_ddr3_switch_freq_example_ddr3</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>mmdc_ddr3_switch_freq_example_ddr3</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mmdc_ddr3_switch_freq_example_ddr3</project>
        <configuration>DDR_Debug</configuration>
      </member>
      <member>
        <project>mmdc_ddr3_switch_freq_example_ddr3</project>
        <configuration>DDR_Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>mmdc_ddr3_switch_freq_example_ddr3</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>mmdc_ddr3_switch_freq_example_ddr3</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>DDR_Debug</name>
      <member>
        <project>mmdc_ddr3_switch_freq_example_ddr3</project>
        <configuration>DDR_Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>DDR_Release</name>
      <member>
        <project>mmdc_ddr3_switch_freq_example_ddr3</project>
        <configuration>DDR_Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/mmdc_ddr3_switch_freq_example_ddr3.ewp</path>
  </project>
</workspace>
