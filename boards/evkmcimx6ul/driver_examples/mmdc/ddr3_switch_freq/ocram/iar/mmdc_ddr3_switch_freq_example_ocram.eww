<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>mmdc_ddr3_switch_freq_example_ocram</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>mmdc_ddr3_switch_freq_example_ocram</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>mmdc_ddr3_switch_freq_example_ocram</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>mmdc_ddr3_switch_freq_example_ocram</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/mmdc_ddr3_switch_freq_example_ocram.ewp</path>
  </project>
</workspace>
