<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>snvs_hp_rtc</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>snvs_hp_rtc</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>snvs_hp_rtc</project>
        <configuration>DDR_Debug</configuration>
      </member>
      <member>
        <project>snvs_hp_rtc</project>
        <configuration>DDR_Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>snvs_hp_rtc</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>snvs_hp_rtc</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>DDR_Debug</name>
      <member>
        <project>snvs_hp_rtc</project>
        <configuration>DDR_Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>DDR_Release</name>
      <member>
        <project>snvs_hp_rtc</project>
        <configuration>DDR_Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/snvs_hp_rtc.ewp</path>
  </project>
</workspace>
