<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>src_reset_source</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>src_reset_source</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>src_reset_source</project>
        <configuration>DDR_Debug</configuration>
      </member>
      <member>
        <project>src_reset_source</project>
        <configuration>DDR_Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>src_reset_source</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>src_reset_source</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>DDR_Debug</name>
      <member>
        <project>src_reset_source</project>
        <configuration>DDR_Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>DDR_Release</name>
      <member>
        <project>src_reset_source</project>
        <configuration>DDR_Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/src_reset_source.ewp</path>
  </project>
</workspace>
