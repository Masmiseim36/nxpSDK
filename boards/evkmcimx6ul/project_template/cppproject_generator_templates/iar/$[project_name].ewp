# IAR project $[project_name].ewp, settings and files
configuration ddr_debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX6G3 NXP MCIMX6G3
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: DEBUG
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../CORTEXA/Include; ../../../../../devices; ../../../../../devices/MCIMX6G3/drivers; ../../../../../devices/MCIMX6G3/utilities; ../../../../../devices/MCIMX6G3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: cppproject_templates.out
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_flash.icf
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_flash.icf
  group startup
    ../../../../../devices/MCIMX6G3/iar/: startup_MCIMX6G3.s
    ../../../../../devices/MCIMX6G3/: system_MCIMX6G3.c system_MCIMX6G3.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MCIMX6G3/drivers/: fsl_uart.h fsl_uart.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c
  group utilities
    ../../../../../devices/MCIMX6G3/utilities/: fsl_debug_console.c fsl_debug_console.h
