<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>dev_phdc_weighscale_bm</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>dev_phdc_weighscale_bm</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>dev_phdc_weighscale_bm</project>
        <configuration>DDR_Debug</configuration>
      </member>
      <member>
        <project>dev_phdc_weighscale_bm</project>
        <configuration>DDR_Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>dev_phdc_weighscale_bm</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>dev_phdc_weighscale_bm</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>DDR_Debug</name>
      <member>
        <project>dev_phdc_weighscale_bm</project>
        <configuration>DDR_Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>DDR_Release</name>
      <member>
        <project>dev_phdc_weighscale_bm</project>
        <configuration>DDR_Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/dev_phdc_weighscale_bm.ewp</path>
  </project>
</workspace>
