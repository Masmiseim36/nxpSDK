<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>host_suspend_resume_hid_mouse_freertos_ca</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>host_suspend_resume_hid_mouse_freertos_ca</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>host_suspend_resume_hid_mouse_freertos_ca</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>host_suspend_resume_hid_mouse_freertos_ca</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/host_suspend_resume_hid_mouse_freertos_ca.ewp</path>
  </project>
</workspace>
