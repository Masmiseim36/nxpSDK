# IAR project cmsis_lpi2c_edma_b2b_transfer_master.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX7U5_M4 NXP MCIMX7U5_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MCIMX7U5CVP05; CPU_MCIMX7U5CVP05_cm4; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../../CMSIS/Driver/Include; ../../../../..; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../devices/MCIMX7U5/drivers; ../../../../../../../devices/MCIMX7U5/cmsis_drivers; ../../../../../../../devices/MCIMX7U5; ../../../../../../../devices/MCIMX7U5/utilities/str; ../../../../../../../devices/MCIMX7U5/utilities/debug_console; ../../../../../../../components/uart; ../../../../../../../components/serial_manager; ../../../../../../../components/lists; ../../../../../../../devices/MCIMX7U5/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: cmsis_lpi2c_edma_b2b_transfer_master.out
  ILINK.IlinkIcfFile: MCIMX7U5xxxxx_cm4_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; ENABLE_RAM_VECTOR_TABLE; CPU_MCIMX7U5CVP05; CPU_MCIMX7U5CVP05_cm4; SERIAL_PORT_TYPE_UART=1
  AARM.ADefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; ENABLE_RAM_VECTOR_TABLE
  ILINK.IlinkConfigDefines: __ram_vector_table__=1
  ILINK.IlinkIcfFile: MCIMX7U5xxxxx_cm4_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCIMX7U5CVP05; CPU_MCIMX7U5CVP05_cm4; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; ENABLE_RAM_VECTOR_TABLE; CPU_MCIMX7U5CVP05; CPU_MCIMX7U5CVP05_cm4; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; ENABLE_RAM_VECTOR_TABLE
  ILINK.IlinkConfigDefines: __ram_vector_table__=1
  ILINK.IlinkIcfFile: MCIMX7U5xxxxx_cm4_flash.icf
  group source
    ../: cmsis_lpi2c_edma_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h fsl_iomuxc.h
  group doc
    ../: readme.txt
  group remoteproc
    ../: empty_rsc_table.c
  group drivers
    ../../../../../../../devices/MCIMX7U5/drivers/: fsl_port.h fsl_clock.c fsl_clock.h fsl_edma.c fsl_edma.h fsl_dmamux.c fsl_dmamux.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_gpio.c fsl_gpio.h fsl_msmc.c fsl_msmc.h
    ../../../../../../../devices/MCIMX7U5/cmsis_drivers/: fsl_lpi2c_cmsis.c fsl_lpi2c_cmsis.h
  group device
    ../../../../../../../devices/MCIMX7U5/: MCIMX7U5_cm4.h MCIMX7U5_cm4_features.h fsl_device_registers.h system_MCIMX7U5_cm4.c system_MCIMX7U5_cm4.h
  group utilities
    ../../../../../../../devices/MCIMX7U5/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/MCIMX7U5/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MCIMX7U5/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../../components/uart/: lpuart_adapter.c uart.h
  group component/serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../../../devices/MCIMX7U5/iar/: startup_MCIMX7U5_cm4.s
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_I2C.h Driver_Common.h
