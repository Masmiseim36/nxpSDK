# IAR project wireless_uart_bridge.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX7U5_M4 NXP MCIMX7U5_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MCIMX7U5DVP07; CPU_MCIMX7U5DVP07_cm4; ENABLE_RAM_VECTOR_TABLE; SDK_I2C_BASED_COMPONENT_USED=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../ble; ../ble/framework/Common; ../ble/framework/FSCI/Interface; ../ble/framework/FSCI/Source; ../ble/framework/FunctionLib; ../ble/framework/Lists; ../ble/framework/MemManager/Interface; ../ble/framework/Messaging/Interface; ../ble/framework/OSAbstraction/Interface; ../ble/framework/Panic/Interface; ../ble/framework/SerialManager/Interface; ../ble/framework/SerialManager/Source; ../ble/gatt_db; ../ble/fsci_host/fsci; ../ble/fsci_host/host; ../ble/fsci_host/host/config; ../ble/fsci_host/host/interface; ../ble/profiles/device_info; ../ble/profiles/wireless_uart; ../ble/profiles/battery; ../srtm/channels; ../srtm/services; ../../../../../components/codec/i2c; ../../../../../devices/MCIMX7U5/drivers; ../../../../../components/i2c; ../../../../../components/codec; ../../../../../components/codec/port/wm8960; ../../../../../devices/MCIMX7U5; ../../../../../devices/MCIMX7U5/utilities/str; ../../../../../devices/MCIMX7U5/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../CMSIS/Include; ../../../../../rtos/freertos/freertos_kernel/include; ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F; ../../../../../components/pf1550; ../../../../../components/codec/wm8960; ../../../../../components/srtm/include; ../../../../../components/srtm/srtm; ../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imx7ulp_m4; ../../../../../middleware/multicore/rpmsg_lite/lib/include; ../../../../../middleware/issdk/sensors; ../../../../../CMSIS/Driver/Include; ../../../../../middleware/issdk/algorithms/pedometer/include; ../../../../../middleware/issdk/algorithms/pedometer/include/libinclude
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; NO_CRP
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: wireless_uart_bridge.out
  ILINK.IlinkIcfFile: MCIMX7U5xxxxx_cm4_ram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/issdk/algorithms/pedometer/lib/libpedometerm4.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCIMX7U5DVP07; CPU_MCIMX7U5DVP07_cm4; ENABLE_RAM_VECTOR_TABLE; SDK_I2C_BASED_COMPONENT_USED=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; NO_CRP
  group source
    ../: app_config.c app_config.h FreeRTOSConfig.h rpmsg_config.h wireless_uart_bridge.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h fsl_iomuxc.h
  group ble
    ../ble/: ApplMain.c ApplMain.h ble_conn_manager.c ble_conn_manager.h ble_service_discovery.c ble_service_discovery.h ble_init.h
  group ble/framework/Common
    ../ble/framework/Common/: EmbeddedTypes.h
  group ble/framework/fsci
    ../ble/framework/FSCI/Interface/: FsciInterface.h
    ../ble/framework/FSCI/Source/: FsciCommands.c FsciCommands.h FsciCommunication.c FsciCommunication.h FsciLogging.c FsciMain.c
  group ble/framework/FunctionLib
    ../ble/framework/FunctionLib/: FunctionLib.c FunctionLib.h
  group ble/framework/Lists
    ../ble/framework/Lists/: GenericList.h GenericList.c
  group ble/framework/MemManager
    ../ble/framework/MemManager/Interface/: MemManager.h
    ../ble/framework/MemManager/Source/: MemManager.c
  group ble/framework/Messaging
    ../ble/framework/Messaging/Source/: Messaging.c
    ../ble/framework/Messaging/Interface/: Messaging.h
  group ble/framework/OSA
    ../ble/framework/OSAbstraction/Source/: fsl_os_abstraction_free_rtos.c
    ../ble/framework/OSAbstraction/Interface/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h
  group ble/framework/Panic
    ../ble/framework/Panic/Source/: Panic.c
    ../ble/framework/Panic/Interface/: Panic.h
  group ble/framework/SerialManager
    ../ble/framework/SerialManager/Interface/: SerialManager.h
    ../ble/framework/SerialManager/Source/: SerialManager.c UART_Adapter.c UART_Adapter.h
  group ble/gatt_db
    ../ble/gatt_db/: gatt_database.c gatt_database_dynamic.c gatt_database_dynamic.h
  group ble/fsci_host/fsci
    ../ble/fsci_host/fsci/: fsci_ble.c fsci_ble.h fsci_ble_types.c fsci_ble_types.h fsci_ble_gap.c fsci_ble_gap.h fsci_ble_gap_types.c fsci_ble_gap_types.h fsci_ble_gatt.c fsci_ble_gatt.h fsci_ble_gatt_types.c fsci_ble_gatt_types.h fsci_ble_gatt_db_app.c fsci_ble_gatt_db_app.h fsci_ble_gatt_db_app_types.c fsci_ble_gatt_db_app_types.h fsci_ble_l2cap.c fsci_ble_l2cap.h fsci_ble_l2cap_types.c fsci_ble_l2cap_types.h
  group ble/fsci_host/host
    ../ble/fsci_host/host/: host_ble.c host_ble.h host_gap.c host_gatt.c host_gatt_db.c host_l2cap.c
    ../ble/fsci_host/host/config/: ble_config.h ble_globals.c
    ../ble/fsci_host/host/interface/: att_callbacks.h att_errors.h att_interface.h att_params.h att_types.h ble_constants.h ble_general.h ble_host_tasks.h ble_sig_defines.h ble_utils.h fsci_ble_interface.h gap_interface.h gap_types.h gatt_client_interface.h gatt_database.h gatt_db_app_interface.h gatt_db_att_interface.h gatt_db_dynamic.h gatt_interface.h gatt_server_interface.h gatt_types.h hci_interface.h hci_types.h l2ca_cb_interface.h l2ca_interface.h l2ca_types.h vendor_debug_commands.h
  group ble/profiles
    ../ble/profiles/device_info/: device_info_interface.h device_info_service.c
    ../ble/profiles/wireless_uart/: wireless_uart_interface.h wireless_uart_service.c
    ../ble/profiles/battery/: battery_interface.h battery_service.c
  group remoteproc
    ../: rsc_table.c rsc_table.h remoteproc.h
  group doc
    ../: readme.txt
  group evkmcimx7ulp
    ../: app_srtm.c app_srtm.h
  group srtm/channels
    ../srtm/channels/: srtm_rpmsg_endpoint.h srtm_rpmsg_endpoint.c
  group srtm/services
    ../srtm/services/: srtm_lfcl_service.h srtm_lfcl_service.c srtm_pmic_service.h srtm_pmic_service.c srtm_pf1550_adapter.h srtm_pf1550_adapter.c srtm_audio_service.h srtm_audio_service.c srtm_sai_edma_adapter.h srtm_sai_edma_adapter.c srtm_i2c_codec_adapter.h srtm_i2c_codec_adapter.c srtm_io_service.h srtm_io_service.c srtm_keypad_service.h srtm_keypad_service.c srtm_rtc_service.h srtm_rtc_service.c srtm_snvs_lp_rtc_adapter.h srtm_snvs_lp_rtc_adapter.c srtm_sensor_service.h srtm_sensor_service.c
  group srtm/port
    ../../../../../components/srtm/port/: srtm_heap_freertos.c srtm_mutex_freertos.c srtm_sem_freertos.c srtm_message_pool.c
  group srtm/include
    ../../../../../components/srtm/include/: srtm_channel.h srtm_defs.h srtm_dispatcher.h srtm_message.h srtm_peercore.h srtm_service.h
  group srtm/srtm
    ../../../../../components/srtm/srtm/: srtm_channel.c srtm_channel_struct.h srtm_dispatcher.c srtm_dispatcher_struct.h srtm_message.c srtm_message_struct.h srtm_peercore.c srtm_peercore_struct.h srtm_service.c srtm_service_struct.h srtm_heap.h srtm_message_pool.h srtm_list.h srtm_mutex.h srtm_sem.h
  group codec
    ../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
    ../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../components/codec/port/wm8960/: fsl_codec_adapter.c fsl_codec_adapter.h
    ../../../../../components/codec/wm8960/: fsl_wm8960.h fsl_wm8960.c
  group drivers
    ../../../../../devices/MCIMX7U5/drivers/: fsl_common.h fsl_common.c fsl_lptmr.c fsl_lptmr.h fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_msmc.h fsl_msmc.c fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_lpi2c.c fsl_lpi2c.h fsl_pmc0.h fsl_port.h fsl_llwu.h fsl_llwu.c fsl_snvs_lp.c fsl_snvs_lp.h fsl_mu.h fsl_mu.c fsl_sai.h fsl_sai.c fsl_sai_edma.h fsl_sai_edma.c
  group drivers/freertos
    ../../../../../devices/MCIMX7U5/drivers/: fsl_lpi2c_freertos.h fsl_lpi2c_freertos.c
  group component/i2c
    ../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group device
    ../../../../../devices/MCIMX7U5/: fsl_device_registers.h MCIMX7U5_cm4.h MCIMX7U5_cm4_features.h system_MCIMX7U5_cm4.c system_MCIMX7U5_cm4.h
  group utilities
    ../../../../../devices/MCIMX7U5/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MCIMX7U5/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MCIMX7U5/utilities/: fsl_assert.c
  group startup
    ../../../../../devices/MCIMX7U5/iar/: startup_MCIMX7U5_cm4.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group freertos/freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    ../../../../../rtos/freertos/freertos_kernel/include/: croutine.h StackMacros.h atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos_kernel/portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: ReadMe.url heap_4.c
  group pmic_driver
    ../../../../../components/pf1550/: fsl_pf1550.h fsl_pf1550.c fsl_pf1550_charger.h fsl_pf1550_charger.c
  group rpmsg_lite
    ../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_lite.h rpmsg_ns.h llist.h rpmsg_default_config.h virtio_ring.h virtqueue.h rpmsg_compiler.h rpmsg_env.h rpmsg_queue.h
    ../../../../../middleware/multicore/rpmsg_lite/lib/common/: llist.c
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c
    ../../../../../middleware/multicore/rpmsg_lite/lib/virtio/: virtqueue.c
  group rpmsg_lite/porting
    ../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imx7ulp_m4/: rpmsg_platform.h
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/platform/imx7ulp_m4/: rpmsg_platform.c
  group rpmsg_lite/env/freertos
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_freertos.c
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_queue.c
  group sensors
    ../../../../../middleware/issdk/sensors/: fxas21002.h fxos8700.h mpl3115.h fxlc95000.h fxls8471q.h fxls8962.h fxpq3115.h mag3110.h mma845x.h mma865x.h mma8491q.h mma9553.h diff_p.h
  group CMSIS_driver
    ../../../../../CMSIS/Driver/Include/: Driver_I2C.h Driver_Common.h Driver_SPI.h
  group pedometer
    ../../../../../middleware/issdk/algorithms/pedometer/source/: pedometer.c
    ../../../../../middleware/issdk/algorithms/pedometer/include/: pedometer.h
    ../../../../../middleware/issdk/algorithms/pedometer/include/libinclude/: KeynetikPedometer.h
