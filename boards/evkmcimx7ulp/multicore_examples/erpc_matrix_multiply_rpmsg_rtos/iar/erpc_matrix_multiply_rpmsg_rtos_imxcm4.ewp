# IAR project erpc_matrix_multiply_rpmsg_rtos_imxcm4.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX7U5_M4 NXP MCIMX7U5_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MCIMX7U5DVP08; FSL_RTOS_FREE_RTOS; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.CCIncludePath2: ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM4F; ..; ../../erpc_common/erpc_matrix_multiply/service; ../../..; ../../erpc_common; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../rtos/amazon-freertos/lib/include; ../../../../../rtos/amazon-freertos/lib/include/private; ../srtm/channels; ../srtm/services; ../../../../../devices/MCIMX7U5/drivers; ../../../../../devices/MCIMX7U5/drivers; ../../../../../devices/MCIMX7U5/drivers; ../../../../../devices/MCIMX7U5/drivers; ../../../../../devices/MCIMX7U5/drivers; ../../../../../devices/MCIMX7U5; ../../../../../devices/MCIMX7U5/utilities/str; ../../../../../devices/MCIMX7U5/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/serial_manager; ../../../../../devices/MCIMX7U5/drivers; ../../../../../components/lists; ../../../../../devices/MCIMX7U5/drivers; ../../../../../devices/MCIMX7U5/drivers; ../../../../../devices/MCIMX7U5/drivers; ../../../../../devices/MCIMX7U5/drivers; ../../../../../devices/MCIMX7U5/drivers; ../../../../../devices/MCIMX7U5/drivers; ../../../../../devices/MCIMX7U5/drivers; ../../../../../devices/MCIMX7U5/drivers; ../../../../../components/pf1550; ../../../../../devices/MCIMX7U5/drivers; ../../../../../devices/MCIMX7U5/drivers; ../../../../../components/codec/wm8960; ../../../../../components/codec/i2c; ../../../../../components/codec/i2c; ../../../../../components/srtm/include; ../../../../../components/srtm/srtm; ../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imx7ulp_m4; ../../../../../middleware/multicore/rpmsg_lite/lib/include; ../../../../../middleware/multicore/rpmsg_lite/lib/include; ../../../../../middleware/issdk/sensors; ../../../../../CMSIS/Driver/Include; ../../../../../CMSIS/Driver/Include; ../../../../../CMSIS/Driver/Include; ../../../../../middleware/issdk/algorithms/pedometer/source; ../../../../../middleware/issdk/algorithms/pedometer/include; ../../../../../middleware/issdk/algorithms/pedometer/include/libinclude; ../../../../../components/codec; ../../../../../components/codec/port; ../../../../../components/codec/wm8960; ../../../../../components/codec; ../../../../../components/i2c; ../../../../../middleware/multicore/erpc/erpc_c/infra; ../../../../../middleware/multicore/erpc/erpc_c/port; ../../../../../middleware/multicore/erpc/erpc_c/setup; ../../../../../middleware/multicore/erpc/erpc_c/transports; ../../../../../middleware/multicore/erpc/erpc_c
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; NO_CRP
  AARM.AUserIncludes: ..; ../../..
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: erpc_matrix_multiply_rpmsg_rtos_imxcm4.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x400
  ILINK.IlinkIcfFile: MCIMX7U5xxxxx_cm4_ram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/issdk/algorithms/pedometer/lib/libpedometerm4.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; ENABLE_RAM_VECTOR_TABLE; CPU_MCIMX7U5DVP08; FSL_RTOS_FREE_RTOS; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE
  AARM.ADefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; ENABLE_RAM_VECTOR_TABLE; NO_CRP
  ILINK.IlinkConfigDefines: __ram_vector_table__=1; __stack_size__=0x400; __heap_size__=0x400
  ILINK.IlinkIcfFile: MCIMX7U5xxxxx_cm4_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCIMX7U5DVP08; FSL_RTOS_FREE_RTOS; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; NO_CRP
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; ENABLE_RAM_VECTOR_TABLE; CPU_MCIMX7U5DVP08; FSL_RTOS_FREE_RTOS; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; ENABLE_RAM_VECTOR_TABLE; NO_CRP
  ILINK.IlinkConfigDefines: as above
  ILINK.IlinkIcfFile: MCIMX7U5xxxxx_cm4_flash.icf
  group source
    ../: main_core1.c rpmsg_config.h erpc_config.h FreeRTOSConfig.h app_srtm.c app_srtm.h
    ../../erpc_common/: erpc_error_handler.h erpc_error_handler.cpp
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h fsl_iomuxc.h
  group src
    ../python/: erpc_matrix_multiply_python.md example.py
    ../python/service/: __init__.py erpc_matrix_multiply.erpc
    ../python/service/erpc_matrix_multiply/: __init__.py client.py common.py interface.py server.py
  group erpc/service
    ../../erpc_common/erpc_matrix_multiply/service/: erpc_matrix_multiply.erpc erpc_matrix_multiply.h erpc_matrix_multiply_server.h erpc_matrix_multiply_server.cpp
  group erpc/infra
    ../../../../../middleware/multicore/erpc/erpc_c/infra/: erpc_server.cpp erpc_server.h erpc_simple_server.cpp erpc_simple_server.h erpc_basic_codec.cpp erpc_basic_codec.h erpc_codec.h erpc_common.h erpc_crc16.cpp erpc_crc16.h erpc_manually_constructed.h erpc_message_buffer.cpp erpc_message_buffer.h erpc_message_loggers.cpp erpc_message_loggers.h erpc_transport.h erpc_version.h
  group erpc/setup
    ../../../../../middleware/multicore/erpc/erpc_c/setup/: erpc_server_setup.cpp erpc_server_setup.h erpc_setup_rpmsg_tty_rtos_remote.cpp erpc_setup_mbf_rpmsg_tty.cpp erpc_mbf_setup.h erpc_transport_setup.h
  group erpc/port
    ../../../../../middleware/multicore/erpc/erpc_c/port/: erpc_threading.h erpc_threading_freertos.cpp erpc_config_internal.h erpc_port.h erpc_port_freertos.cpp
  group erpc/transports
    ../../../../../middleware/multicore/erpc/erpc_c/transports/: erpc_rpmsg_lite_base_transport.h erpc_rpmsg_tty_rtos_transport.cpp erpc_rpmsg_tty_rtos_transport.h
  group doc
    ../: readme.txt
  group srtm/channels
    ../srtm/channels/: srtm_rpmsg_endpoint.c srtm_rpmsg_endpoint.h
  group srtm/services
    ../srtm/services/: srtm_audio_service.c srtm_audio_service.h srtm_i2c_codec_adapter.c srtm_i2c_codec_adapter.h srtm_io_service.c srtm_io_service.h srtm_keypad_service.c srtm_keypad_service.h srtm_lfcl_service.c srtm_lfcl_service.h srtm_pf1550_adapter.c srtm_pf1550_adapter.h srtm_pmic_service.c srtm_pmic_service.h srtm_rtc_service.c srtm_rtc_service.h srtm_sai_edma_adapter.c srtm_sai_edma_adapter.h srtm_sensor_service.c srtm_sensor_service.h srtm_snvs_lp_rtc_adapter.c srtm_snvs_lp_rtc_adapter.h
  group srtm/port
    ../../../../../components/srtm/port/: srtm_heap_freertos.c srtm_mutex_freertos.c srtm_sem_freertos.c srtm_message_pool.c
  group srtm/include
    ../../../../../components/srtm/include/: srtm_channel.h srtm_defs.h srtm_dispatcher.h srtm_message.h srtm_peercore.h srtm_service.h
  group srtm/srtm
    ../../../../../components/srtm/srtm/: srtm_channel.c srtm_channel_struct.h srtm_dispatcher.c srtm_dispatcher_struct.h srtm_heap.h srtm_list.h srtm_message.c srtm_message_pool.h srtm_message_struct.h srtm_mutex.h srtm_peercore.c srtm_peercore_struct.h srtm_sem.h srtm_service.c srtm_service_struct.h
  group drivers
    ../../../../../devices/MCIMX7U5/drivers/: fsl_gpio.c fsl_gpio.h fsl_port.h fsl_clock.c fsl_clock.h fsl_mu.c fsl_mu.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_msmc.c fsl_msmc.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_lpi2c.c fsl_lpi2c.h fsl_pmc0.h fsl_llwu.c fsl_llwu.h fsl_snvs_lp.c fsl_snvs_lp.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h
  group drivers/freertos
    ../../../../../devices/MCIMX7U5/drivers/: fsl_lpi2c_freertos.c fsl_lpi2c_freertos.h
  group amazon-freertos/freertos
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos/freertos/portable
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
  group amazon-freertos/include
    ../../../../../rtos/amazon-freertos/lib/include/: FreeRTOS.h event_groups.h freertos_tasks_c_additions.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
    ../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h stack_macros.h threading_alt.h
  group device
    ../../../../../devices/MCIMX7U5/: MCIMX7U5_cm4.h MCIMX7U5_cm4_features.h fsl_device_registers.h system_MCIMX7U5_cm4.c system_MCIMX7U5_cm4.h
  group utilities
    ../../../../../devices/MCIMX7U5/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MCIMX7U5/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MCIMX7U5/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group component/i2c
    ../../../../../components/i2c/: i2c.h lpi2c_adapter.c
  group startup
    ../../../../../devices/MCIMX7U5/iar/: startup_MCIMX7U5_cm4.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h
  group pmic_driver
    ../../../../../components/pf1550/: fsl_pf1550.c fsl_pf1550.h fsl_pf1550_charger.c fsl_pf1550_charger.h
  group codec
    ../../../../../components/codec/wm8960/: fsl_wm8960.c fsl_wm8960.h
    ../../../../../components/codec/i2c/: fsl_codec_i2c.c fsl_codec_i2c.h
    ../../../../../components/codec/: fsl_codec_common.c fsl_codec_common.h
    ../../../../../components/codec/port/: fsl_codec_adapter.h
    ../../../../../components/codec/port/wm8960/: fsl_codec_adapter.c
  group rpmsg_lite
    ../../../../../middleware/multicore/rpmsg_lite/lib/common/: llist.c
    ../../../../../middleware/multicore/rpmsg_lite/lib/include/: llist.h rpmsg_compiler.h rpmsg_default_config.h rpmsg_lite.h rpmsg_ns.h virtio_ring.h virtqueue.h
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c
    ../../../../../middleware/multicore/rpmsg_lite/lib/virtio/: virtqueue.c
  group rpmsg_lite/porting
    ../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imx7ulp_m4/: rpmsg_platform.h
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/platform/imx7ulp_m4/: rpmsg_platform.c
  group rpmsg_lite/env/freertos
    ../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_env.h rpmsg_queue.h
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_freertos.c
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_queue.c
  group sensors
    ../../../../../middleware/issdk/sensors/: diff_p.h fxas21002.h fxlc95000.h fxls8471q.h fxls8962.h fxos8700.h fxpq3115.h mag3110.h mma845x.h mma8491q.h mma865x.h mma9553.h mpl3115.h
  group CMSIS_driver
    ../../../../../CMSIS/Driver/Include/: Driver_I2C.h Driver_Common.h Driver_SPI.h
  group pedometer
    ../../../../../middleware/issdk/algorithms/pedometer/include/libinclude/: KeynetikPedometer.h
    ../../../../../middleware/issdk/algorithms/pedometer/include/: pedometer.h
    ../../../../../middleware/issdk/algorithms/pedometer/source/: pedometer.c
