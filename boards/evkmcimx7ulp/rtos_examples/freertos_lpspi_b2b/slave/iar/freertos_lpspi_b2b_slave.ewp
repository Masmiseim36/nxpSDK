# IAR project freertos_lpspi_b2b_slave.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX7U5_M4 NXP MCIMX7U5_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MCIMX7U5DVP07; CPU_MCIMX7U5DVP07_cm4; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MCIMX7U5/drivers; ../../../../../../devices/MCIMX7U5; ../../../../../../devices/MCIMX7U5/utilities/str; ../../../../../../devices/MCIMX7U5/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../CMSIS/Include; ../../../../../../rtos/freertos/freertos_kernel/include; ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: freertos_lpspi_b2b_slave.out
  ILINK.IlinkIcfFile: MCIMX7U5xxxxx_cm4_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; ENABLE_RAM_VECTOR_TABLE; CPU_MCIMX7U5DVP07; CPU_MCIMX7U5DVP07_cm4; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  AARM.ADefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; ENABLE_RAM_VECTOR_TABLE
  ILINK.IlinkConfigDefines: __ram_vector_table__=1
  ILINK.IlinkIcfFile: MCIMX7U5xxxxx_cm4_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCIMX7U5DVP07; CPU_MCIMX7U5DVP07_cm4; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; ENABLE_RAM_VECTOR_TABLE; CPU_MCIMX7U5DVP07; CPU_MCIMX7U5DVP07_cm4; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; ENABLE_RAM_VECTOR_TABLE
  ILINK.IlinkConfigDefines: __ram_vector_table__=1
  ILINK.IlinkIcfFile: MCIMX7U5xxxxx_cm4_flash.icf
  group source
    ../: freertos_lpspi_b2b_slave.c FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h fsl_iomuxc.h
  group doc
    ../: readme.txt
  group remoteproc
    ../: empty_rsc_table.c
  group drivers
    ../../../../../../devices/MCIMX7U5/drivers/: fsl_port.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_lpspi.c fsl_lpspi.h fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_msmc.h fsl_msmc.c
  group freertos/freertos_kernel
    ../../../../../../rtos/freertos/freertos_kernel/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/include
    ../../../../../../rtos/freertos/freertos_kernel/include/: croutine.h StackMacros.h atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group device
    ../../../../../../devices/MCIMX7U5/: fsl_device_registers.h MCIMX7U5_cm4.h MCIMX7U5_cm4_features.h system_MCIMX7U5_cm4.c system_MCIMX7U5_cm4.h
  group utilities
    ../../../../../../devices/MCIMX7U5/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MCIMX7U5/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MCIMX7U5/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MCIMX7U5/iar/: startup_MCIMX7U5_cm4.s
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
