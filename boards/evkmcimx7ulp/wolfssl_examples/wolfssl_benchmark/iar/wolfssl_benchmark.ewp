# IAR project wolfssl_benchmark.ewp, settings and files
configuration flash_debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX7U5_M4 NXP MCIMX7U5_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; ENABLE_RAM_VECTOR_TABLE; CPU_MCIMX7U5DVP08; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; FREESCALE_KSDK_BM; WOLFSSL_USER_SETTINGS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../middleware/mmcau; ../../../../../middleware/wolfssl; ../../../../../middleware/wolfssl/wolfssl/wolfcrypt/port; ../../../../../devices/MCIMX7U5/drivers; ../../../../../devices/MCIMX7U5/drivers; ../../../../../devices/MCIMX7U5/drivers; ../../../../../devices/MCIMX7U5/drivers; ../../../../../devices/MCIMX7U5/drivers; ../../../../../devices/MCIMX7U5; ../../../../../devices/MCIMX7U5/utilities/str; ../../../../../devices/MCIMX7U5/utilities; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/serial_manager; ../../../../../devices/MCIMX7U5/drivers; ../../../../../components/lists; ../../../../../devices/MCIMX7U5/drivers; ../../../../../devices/MCIMX7U5/drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; ENABLE_RAM_VECTOR_TABLE
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: wolfssl_benchmark.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1; __stack_size__=25000; __heap_size__=40000
  ILINK.IlinkIcfFile: MCIMX7U5xxxxx_cm4_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/mmcau/asm-cm4-cm7/lib_mmcau.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; ENABLE_RAM_VECTOR_TABLE; CPU_MCIMX7U5DVP08; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; FREESCALE_KSDK_BM; WOLFSSL_USER_SETTINGS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; ENABLE_RAM_VECTOR_TABLE
  group source
    ../: wolfssl_benchmark.c user_settings.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h fsl_iomuxc.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MCIMX7U5/drivers/: fsl_ltc.h fsl_ltc.c fsl_trng.c fsl_trng.h fsl_port.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_msmc.h fsl_msmc.c
  group mmcau/mmcau_include
    ../../../../../middleware/mmcau/: cau_api.h fsl_mmcau.h
  group mmcau/mmcau_source
    ../../../../../middleware/mmcau/: fsl_mmcau.c
  group wolfssl/wolfssl_include
    ../../../../../middleware/wolfssl/wolfssl/: callbacks.h certs_test.h crl.h error-ssl.h internal.h ocsp.h options.h sniffer.h sniffer_error.h ssl.h test.h version.h
    ../../../../../middleware/wolfssl/wolfssl/openssl/: ec.h ssl.h bn.h
    ../../../../../middleware/wolfssl/wolfssl/wolfcrypt/: aes.h arc4.h asn.h asn_public.h blake2.h blake2-impl.h blake2-int.h camellia.h cmac.h chacha.h chacha20_poly1305.h coding.h compress.h curve25519.h des3.h dh.h dsa.h ecc.h ed25519.h error-crypt.h fe_operations.h fips_test.h ge_operations.h hash.h hc128.h hmac.h integer.h idea.h logging.h md2.h md4.h md5.h mem_track.h memory.h misc.h mpi_class.h mpi_superclass.h pkcs7.h poly1305.h pwdbased.h rabbit.h random.h ripemd.h rsa.h settings.h sha.h sha256.h sha512.h signature.h srp.h tfm.h types.h visibility.h wc_encrypt.h wc_port.h
  group wolfssl/wolfssl_source
    ../../../../../middleware/wolfssl/wolfcrypt/src/: aes.c arc4.c asm.c asn.c blake2b.c camellia.c cmac.c chacha.c chacha20_poly1305.c coding.c compress.c curve25519.c des3.c dh.c dsa.c ecc.c ecc_fp.c ed25519.c error.c fe_low_mem.c fe_operations.c ge_low_mem.c ge_operations.c hash.c hc128.c hmac.c integer.c idea.c logging.c md2.c md4.c md5.c memory.c misc.c pkcs7.c poly1305.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha512.c signature.c srp.c tfm.c wc_encrypt.c wc_port.c
    ../../../../../middleware/wolfssl/src/: async.c crl.c internal.c io.c keys.c ocsp.c sniffer.c ssl.c tls.c
  group wolfssl/wolfssl_port
    ../../../../../middleware/wolfssl/wolfcrypt/src/port/nxp/: ksdk_port.c
    ../../../../../middleware/wolfssl/wolfssl/wolfcrypt/port/nxp/: ksdk_port.h
  group device
    ../../../../../devices/MCIMX7U5/: fsl_device_registers.h MCIMX7U5_cm4.h MCIMX7U5_cm4_features.h system_MCIMX7U5_cm4.c system_MCIMX7U5_cm4.h
  group utilities
    ../../../../../devices/MCIMX7U5/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MCIMX7U5/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group component/uart
    ../../../../../components/uart/: uart.h lpuart_adapter.c
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: generic_list.h generic_list.c
  group startup
    ../../../../../devices/MCIMX7U5/iar/: startup_MCIMX7U5_cm4.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
