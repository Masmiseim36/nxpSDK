# IAR project cmsis_ecspi_sdma_loopback_transfer.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8MM6_M4 NXP MIMX8MM6_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MIMX8MM6DVTLZ
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MIMX8MM6/drivers; ../../../../../../devices/MIMX8MM6/utilities/debug_console_lite; ../../../../../../devices/MIMX8MM6/cmsis_drivers; ../../../../../../devices/MIMX8MM6; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../../../CMSIS/Include; ../../../../../../CMSIS/Driver/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: cmsis_ecspi_sdma_loopback_transfer.out
  ILINK.IlinkIcfFile: MIMX8MM6xxxxx_cm4_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: FLASH_TARGET; CPU_MIMX8MM6DVTLZ
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8MM6xxxxx_cm4_flash.icf
configuration ddr_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MIMX8MM6DVTLZ
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8MM6xxxxx_cm4_ddr_ram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMX8MM6DVTLZ
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FLASH_TARGET; CPU_MIMX8MM6DVTLZ
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8MM6xxxxx_cm4_flash.icf
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MIMX8MM6DVTLZ
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8MM6xxxxx_cm4_ddr_ram.icf
  group source
    ../: cmsis_ecspi_sdma_loopback_transfer.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h fsl_iomuxc.h
  group doc
    ../: readme.txt
  group remoteproc
    ../: empty_rsc_table.c
  group drivers
    ../../../../../../devices/MIMX8MM6/drivers/: fsl_ecspi_sdma.h fsl_ecspi_sdma.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_rdc.h fsl_rdc.c fsl_uart.h fsl_uart.c fsl_ecspi.h fsl_ecspi.c fsl_sdma.h fsl_sdma_script.h fsl_sdma.c fsl_memory.h
    ../../../../../../devices/MIMX8MM6/cmsis_drivers/: fsl_ecspi_cmsis.h fsl_ecspi_cmsis.c
  group utilities
    ../../../../../../devices/MIMX8MM6/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group device
    ../../../../../../devices/MIMX8MM6/: fsl_device_registers.h MIMX8MM6_cm4.h MIMX8MM6_cm4_features.h system_MIMX8MM6_cm4.c system_MIMX8MM6_cm4.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_iuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMX8MM6/iar/: startup_MIMX8MM6_cm4.s
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group CMSIS_driver
    ../../../../../../CMSIS/Driver/Include/: Driver_SPI.h Driver_Common.h
