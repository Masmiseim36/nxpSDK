# IAR project safety_iec60730b.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8MN6_M7 NXP MIMX8MN6_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMX8MN6DVTJZ; SDK_DELAY_USE_DWT; FLASH_TARGET; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../middleware/safety_iec60730b/boards/common/cm4_cm7/startup/cm7; ..; ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/register; ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/ram; ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/flash; ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/stack; ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/programCounter; ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7; ../../../../../middleware/safety_iec60730b/safety/v4_1; ../../../../../middleware/safety_iec60730b/safety/v4_1/compiler; ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/wdog; ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/tsi; ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/dio; ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/clock; ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/aio; ../../../../../devices/MIMX8MN6; ../../../../../devices/MIMX8MN6/drivers; ../../../../../devices/MIMX8MN6/utilities/str; ../../../../../devices/MIMX8MN6/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ../../../../../middleware/safety_iec60730b/boards/common/cm4_cm7/startup/cm7; ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/register; ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/ram; ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/flash; ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/stack; ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/programCounter; ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7; ../../../../../middleware/safety_iec60730b/safety/v4_1; ../../../../../middleware/safety_iec60730b/safety/v4_1/compiler; ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/wdog; ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/tsi; ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/dio; ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/clock; ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/aio; ../../../../../devices/MIMX8MN6
  postbuild: ../../../../../middleware/safety_iec60730b/boards/evkmimx8mn/linker/iar/crc_iar.bat "$TARGET_BPATH$"
  ILINK.IlinkOutputFile: safety_iec60730b.out
  ILINK.IlinkIcfFile: linker/evkmimx8mn_safety.icf
  ILINK.IlinkExtraOptions: --place_holder __checksum,4,.checksum,4; --keep=__checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group source
    ../: freemaster_cfg.h safety_test_items.h safety_test_items.c isr.h safety_config.h project_setup_evkmimx8mn.h project_setup_evkmimx8mn.c safety_cm4_cm7_imx8m.c safety_cm4_cm7_imx8m.h main_imx8m.c
  group doc
    ../: readme.txt
  group board
    ../: pin_mux.c pin_mux.h clock_config.c clock_config.h board.c board.h
  group tools/srecord
    ../../../../../tools/srecord/: srecord-1.64.zip
  group startup
    ../../../../../middleware/safety_iec60730b/boards/common/cm4_cm7/startup/cm7/: start.c startup_iar.c vectors_iar.h vectors_iar.c
  group linker
    linker/: evkmimx8mn_safety.icf
    ../../../../../middleware/safety_iec60730b/boards/evkmimx8mn/linker/iar/: crc_iar.bat
  group GUI
    ../GUI/: safety.pmp
  group safety/v4_1
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/: iec60730b_core.h
    ../../../../../middleware/safety_iec60730b/safety/v4_1/: iec60730b.h iec60730b_types.h IEC60730B_M4_M7_IAR_v4_1.a IEC60730B_M4_M7_COM_IAR_v4_1.a
  group safety/v4_1/register
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/register/: iec60730b_cm4_cm7_reg.h
  group safety/v4_1/ram
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/ram/: iec60730b_cm4_cm7_ram.h
  group safety/v4_1/flash
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/flash/: iec60730b_cm4_cm7_flash.h
  group safety/v4_1/stack
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/stack/: iec60730b_cm4_cm7_stack.h
  group safety/v4_1/programCounter
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/programCounter/: iec60730b_cm4_cm7_pc.h iec60730b_cm4_cm7_pc_object.S
  group safety/v4_1/compiler
    ../../../../../middleware/safety_iec60730b/safety/v4_1/compiler/: asm_mac_common.h
  group safety/v4_1/wdog
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/wdog/: iec60730b_wdog.c iec60730b_wdog.h
  group safety/v4_1/tsi
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/tsi/: iec60730b_tsi.h
  group safety/v4_1/dio
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/dio/: iec60730b_dio_ext.h iec60730b_dio.h
  group safety/v4_1/clock
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/clock/: iec60730b_clock.h
  group safety/v4_1/aio
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/aio/: iec60730b_aio.h
  group MIMX8MN6
    ../../../../../devices/MIMX8MN6/: system_MIMX8MN6_cm7.c system_MIMX8MN6_cm7.h
  group drivers
    ../../../../../devices/MIMX8MN6/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_rdc.h fsl_rdc.c fsl_uart.h fsl_uart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group device
    ../../../../../devices/MIMX8MN6/: fsl_device_registers.h MIMX8MN6_cm7.h MIMX8MN6_cm7_features.h
  group utilities
    ../../../../../devices/MIMX8MN6/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMX8MN6/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMX8MN6/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_iuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
