# IAR project sai_low_power_audio.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8MN6_M7 NXP MIMX8MN6_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMX8MN6DVTJZ; SDK_DELAY_USE_DWT; SRTM_DEBUG_MESSAGE_FUNC=DbgConsole_Printf; SRTM_DEBUG_VERBOSE_LEVEL=SRTM_DEBUG_VERBOSE_WARN; NOT_CONFIG_CLK_ROOT=1; SDK_I2C_BASED_COMPONENT_USED=1; SERIAL_PORT_TYPE_UART=1; BOARD_USE_CODEC=1; CODEC_WM8524_ENABLE; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../..; ..; ../../../../../devices/MIMX8MN6/drivers; ../../../../../components/srtm/channels; ../../../../../components/srtm/services; ../../../../../components/codec; ../../../../../components/codec/port; ../../../../../devices/MIMX8MN6; ../../../../../devices/MIMX8MN6/utilities/str; ../../../../../devices/MIMX8MN6/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../CMSIS/Include; ../../../../../components/codec/wm8524; ../../../../../components/srtm/include; ../../../../../components/srtm/srtm; ../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imx8mn_m7; ../../../../../middleware/multicore/rpmsg_lite/lib/include; ../../../../../rtos/freertos/freertos_kernel/include; ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; NO_CRP; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../../..
  ILINK.IlinkOutputFile: sai_low_power_audio.out
  ILINK.IlinkIcfFile: MIMX8MN6xxxxx_cm7_lpa_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMX8MN6DVTJZ; SDK_DELAY_USE_DWT; SRTM_DEBUG_MESSAGE_FUNC=DbgConsole_Printf; SRTM_DEBUG_VERBOSE_LEVEL=SRTM_DEBUG_VERBOSE_WARN; NOT_CONFIG_CLK_ROOT=1; SDK_I2C_BASED_COMPONENT_USED=1; SERIAL_PORT_TYPE_UART=1; BOARD_USE_CODEC=1; CODEC_WM8524_ENABLE; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; NO_CRP; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: FreeRTOSConfig.h rpmsg_config.h lpm.c lpm.h sai_low_power_audio.c sai_low_power_audio.h app_srtm.c app_srtm.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h fsl_iomuxc.h
  group remoteproc
    ../: rsc_table.c rsc_table.h remoteproc.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMX8MN6/drivers/: fsl_gpio.h fsl_gpio.c fsl_uart.h fsl_uart.c fsl_gpc.c fsl_gpc.h fsl_gpt.c fsl_gpt.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_sai.h fsl_sai.c fsl_sai_sdma.h fsl_sai_sdma.c fsl_rdc.h fsl_rdc.c fsl_sdma.h fsl_sdma_script.h fsl_sdma.c fsl_memory.h fsl_mu.h fsl_mu.c
  group srtm/channels
    ../../../../../components/srtm/channels/: srtm_rpmsg_endpoint.h srtm_rpmsg_endpoint.c
  group srtm/services
    ../../../../../components/srtm/services/: srtm_audio_service.h srtm_audio_service.c srtm_sai_sdma_adapter.h srtm_sai_sdma_adapter.c srtm_wm8524_adapter.h srtm_wm8524_adapter.c
  group srtm/port
    ../../../../../components/srtm/port/: srtm_heap_freertos.c srtm_mutex_freertos.c srtm_sem_freertos.c srtm_message_pool.c
  group srtm/include
    ../../../../../components/srtm/include/: srtm_channel.h srtm_defs.h srtm_dispatcher.h srtm_message.h srtm_peercore.h srtm_service.h
  group srtm/srtm
    ../../../../../components/srtm/srtm/: srtm_channel.c srtm_channel_struct.h srtm_dispatcher.c srtm_dispatcher_struct.h srtm_message.c srtm_message_struct.h srtm_peercore.c srtm_peercore_struct.h srtm_service.c srtm_service_struct.h srtm_heap.h srtm_message_pool.h srtm_list.h srtm_mutex.h srtm_sem.h
  group codec
    ../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../components/codec/port/: fsl_wm8524_adapter.c fsl_wm8524_adapter.h fsl_codec_adapter.c fsl_codec_adapter.h
    ../../../../../components/codec/wm8524/: fsl_wm8524.h fsl_wm8524.c
  group device
    ../../../../../devices/MIMX8MN6/: fsl_device_registers.h MIMX8MN6_cm7.h MIMX8MN6_cm7_features.h system_MIMX8MN6_cm7.c system_MIMX8MN6_cm7.h
  group utilities
    ../../../../../devices/MIMX8MN6/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMX8MN6/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMX8MN6/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_iuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMX8MN6/iar/: startup_MIMX8MN6_cm7.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group rpmsg_lite
    ../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_lite.h rpmsg_ns.h llist.h rpmsg_default_config.h virtio_ring.h virtqueue.h rpmsg_compiler.h rpmsg_env.h rpmsg_queue.h
    ../../../../../middleware/multicore/rpmsg_lite/lib/common/: llist.c
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c
    ../../../../../middleware/multicore/rpmsg_lite/lib/virtio/: virtqueue.c
  group rpmsg_lite/porting
    ../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imx8mn_m7/: rpmsg_platform.h
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/platform/imx8mn_m7/: rpmsg_platform.c
  group rpmsg_lite/env/freertos
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_freertos.c
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_queue.c
  group freertos/freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    ../../../../../rtos/freertos/freertos_kernel/include/: croutine.h StackMacros.h atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos_kernel/portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: ReadMe.url heap_4.c
