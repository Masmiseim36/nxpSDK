# IAR project tmu_1_temperature_polling.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8MN6_M7 NXP MIMX8MN6_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMX8MN6DVTJZ
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MIMX8MN6/drivers; ../../../../../../devices/MIMX8MN6/drivers; ../../../../../../devices/MIMX8MN6/drivers; ../../../../../../devices/MIMX8MN6/drivers; ../../../../../../devices/MIMX8MN6; ../../../../../../devices/MIMX8MN6/utilities/str; ../../../../../../devices/MIMX8MN6/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/serial_manager; ../../../../../../devices/MIMX8MN6/drivers; ../../../../../../components/lists
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: tmu_1_temperature_polling.out
  ILINK.IlinkIcfFile: MIMX8MN6xxxxx_cm7_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: FLASH_TARGET; CPU_MIMX8MN6DVTJZ
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8MN6xxxxx_cm7_flash.icf
configuration ddr_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MIMX8MN6DVTJZ
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8MN6xxxxx_cm7_ddr_ram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMX8MN6DVTJZ
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FLASH_TARGET; CPU_MIMX8MN6DVTJZ
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8MN6xxxxx_cm7_flash.icf
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MIMX8MN6DVTJZ
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8MN6xxxxx_cm7_ddr_ram.icf
  group source
    ../: tmu_1_temperature_polling.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h fsl_iomuxc.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MIMX8MN6/drivers/: fsl_tmu.c fsl_tmu.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_rdc.c fsl_rdc.h fsl_uart.c fsl_uart.h
  group device
    ../../../../../../devices/MIMX8MN6/: MIMX8MN6_cm7.h MIMX8MN6_cm7_features.h fsl_device_registers.h system_MIMX8MN6_cm7.c system_MIMX8MN6_cm7.h
  group utilities
    ../../../../../../devices/MIMX8MN6/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMX8MN6/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMX8MN6/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../components/uart/: iuart_adapter.c uart.h
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../../devices/MIMX8MN6/iar/: startup_MIMX8MN6_cm7.s
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
