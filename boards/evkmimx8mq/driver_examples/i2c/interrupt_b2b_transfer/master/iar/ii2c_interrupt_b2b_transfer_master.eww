<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>ii2c_interrupt_b2b_transfer_master</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>ii2c_interrupt_b2b_transfer_master</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>ii2c_interrupt_b2b_transfer_master</project>
        <configuration>ddr_debug</configuration>
      </member>
      <member>
        <project>ii2c_interrupt_b2b_transfer_master</project>
        <configuration>ddr_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>ii2c_interrupt_b2b_transfer_master</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>ii2c_interrupt_b2b_transfer_master</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>ddr_debug</name>
      <member>
        <project>ii2c_interrupt_b2b_transfer_master</project>
        <configuration>ddr_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>ddr_release</name>
      <member>
        <project>ii2c_interrupt_b2b_transfer_master</project>
        <configuration>ddr_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/ii2c_interrupt_b2b_transfer_master.ewp</path>
  </project>
</workspace>
