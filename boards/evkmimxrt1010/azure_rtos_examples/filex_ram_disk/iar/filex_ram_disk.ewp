# IAR project filex_ram_disk.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1011xxx5A NXP MIMXRT1011xxx5A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1011DAE5A; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; DATA_SECTION_IS_CACHEABLE=1; MCUXPRESSO_SDK; FX_INCLUDE_USER_DEFINE_FILE; TX_INCLUDE_USER_DEFINE_FILE; FSL_RTOS_THREADX
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../devices/MIMXRT1011/drivers; ../../../../../devices/MIMXRT1011; ../../../../../devices/MIMXRT1011/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../devices/MIMXRT1011/utilities; ../../../../../devices/MIMXRT1011/xip; ../../../xip; ../../../../../rtos/azure-rtos/filex/common/inc; ../../../../../rtos/azure-rtos/filex/ports/generic/inc; ../../../../../rtos/azure-rtos/threadx/common/inc; ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/iar/inc; ../../../../../CMSIS/Core/Include; ../../../../../devices/MIMXRT1011/utilities/str
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: filex_ram_disk.out
  ILINK.IlinkIcfFile: MIMXRT1011xxxxx_flexspi_nor.icf
  ILINK.IlinkAdditionalLibs: ../../../../../rtos/azure-rtos/binary/filex/cortex_m7/iar/libfilex_sp.a; ../../../../../rtos/azure-rtos/binary/threadx/cortex_m7/iar/libthreadx_sp.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1011DAE5A; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; DATA_SECTION_IS_CACHEABLE=1; MCUXPRESSO_SDK; FX_INCLUDE_USER_DEFINE_FILE; TX_INCLUDE_USER_DEFINE_FILE; FSL_RTOS_THREADX
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source
    ../: filex_ram_disk.c
  group azure-rtos/config
    ../: tx_user.h fx_user.h
  group azure-rtos/filex/common/inc
    ../../../../../rtos/azure-rtos/filex/common/inc/: fx_api.h fx_directory.h fx_fault_tolerant.h fx_file.h fx_media.h fx_system.h fx_unicode.h fx_user_sample.h fx_utility.h
  group azure-rtos/filex/ports/generic/inc
    ../../../../../rtos/azure-rtos/filex/ports/generic/inc/: fx_port.h
  group azure-rtos/threadx/common/inc
    ../../../../../rtos/azure-rtos/threadx/common/inc/: tx_api.h tx_block_pool.h tx_byte_pool.h tx_event_flags.h tx_initialize.h tx_mutex.h tx_queue.h tx_semaphore.h tx_thread.h tx_timer.h tx_trace.h tx_user_sample.h
  group azure-rtos/threadx/ports/cortex_m7/iar/inc
    ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/iar/inc/: tx_port.h
  group azure-rtos/threadx/ports/cortex_m7/iar/src
    ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/iar/src/: tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_schedule.s tx_thread_stack_build.s tx_thread_system_return.s tx_timer_interrupt.s
  group azure-rtos/threadx/ports/common
    ../../../../../rtos/azure-rtos/threadx/ports/common/: tx_initialize_low_level.c
  group doc
    ../: readme.md
  group drivers
    ../../../../../devices/MIMXRT1011/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group device
    ../../../../../devices/MIMXRT1011/: fsl_device_registers.h MIMXRT1011.h MIMXRT1011_features.h system_MIMXRT1011.c system_MIMXRT1011.h
  group utilities
    ../../../../../devices/MIMXRT1011/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1011/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../devices/MIMXRT1011/utilities/str/: fsl_str.c fsl_str.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1011/iar/: startup_MIMXRT1011.s
  group xip
    ../../../../../devices/MIMXRT1011/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1010_flexspi_nor_config.c evkmimxrt1010_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
