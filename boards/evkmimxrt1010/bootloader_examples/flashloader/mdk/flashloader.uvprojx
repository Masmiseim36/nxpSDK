# Keil uVision project flashloader.uvprojx, settings and files
target flashloader release (ARM-ADS)
  device: MIMXRT1011DAE5A NXP
  pack: NXP.MIMXRT1011_DFP.11.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: flashloader.out
  AfterMake: fromelf.exe --output "$Lflashloader.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1011DAE5A, CPU_IS_ARM_CORTEX_M7=1, BL_TARGET_RAM, MIMXRT1011, USB_STACK_BM, PINT_USE_SIMPLE_CALLBACK=1, SDK_DEBUGCONSOLE=1, MIMXRT1011_SERIES, OSA_USED, DEBUG, USE_RTOS=0
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb  -ffreestanding  -Wno-null-dereference  -Wno-unknown-attributes  -Wno-expansion-to-defined  -Wparentheses-equality  -Wno-invalid-noreturn
  c include: ..;../../../../../devices/MIMXRT1011/drivers;../../../../../CMSIS/Core/Include;../../../../../CMSIS/Core/Include/m-profile;../../../../../devices/MIMXRT1011;../../../../../devices/MIMXRT1011/periph;../../../../../devices/MIMXRT1011/utilities/debug_console_lite;../../../../../components/lists;../../../../../devices/MIMXRT1011/utilities/str;../../../../../components/uart;../../../../../components/osa;../../../../../middleware/usb/include;../../../../../middleware/usb/phy;../../../../../middleware/mcu_bootloader/src/autobaud;../../../../../middleware/mcu_bootloader/src/bootloader;../../../../../middleware/mcu_bootloader/src/crc;../../../../../middleware/mcu_bootloader/src/include;../../../../../middleware/mcu_bootloader/src/memory;../../../../../middleware/mcu_bootloader/src/memory/src;../../../../../middleware/mcu_bootloader/src/packet;../../../../../middleware/mcu_bootloader/src/property;../../../../../middleware/mcu_bootloader/src/sbloader;../../../../../middleware/mcu_bootloader/src/utilities;../../../../../middleware/mcu_bootloader/src/startup;../../../../../middleware/usb/device;../../../../../middleware/usb/device/class;../../../../../middleware/mcu_bootloader/src/bm_usb;../../../../../middleware/mcu_bootloader/src/drivers/ocotp;../../../../../middleware/mcu_bootloader/src/drivers/microseconds;../../../../../drivers/common;../../../../../devices/RT/RT1010/MIMXRT1011/drivers;../../../../../drivers/wdog01;../../../../../drivers/rtwdog;../../../../../drivers/igpio;../../../../../drivers/lpuart;../../../../../devices/RT/RT1010/MIMXRT1011;../../../../../middleware/mcu_bootloader/targets/MIMXRT1011/src;../../../../../middleware/mcu_bootloader/src/drivers/flexspi_nor;../../../../../middleware/mcu_bootloader/src/drivers/flexspi;../../../../../middleware/mcu_bootloader/src/drivers/smc;../../../../../middleware/mcu_bootloader/src/drivers/dcp;../../../../../middleware/mcu_bootloader/src/drivers/trng
  asm define: BL_HAS_BOOTLOADER_CONFIG=0, CPU_MIMXRT1011DAE5A, MIMXRT1011_SERIES, OSA_USED, DEBUG, NDEBUG
  asm include: ..;../../../../../devices/MIMXRT1011/drivers;../../../../../CMSIS/Core/Include;../../../../../CMSIS/Core/Include/m-profile;../../../../../devices/MIMXRT1011;../../../../../devices/MIMXRT1011/periph;../../../../../devices/MIMXRT1011/utilities/debug_console_lite;../../../../../components/lists;../../../../../devices/MIMXRT1011/utilities/str;../../../../../components/uart;../../../../../components/osa;../../../../../middleware/usb/include;../../../../../middleware/usb/phy;../../../../../middleware/mcu_bootloader/src/startup;../../../../../middleware/mcu_bootloader/src/autobaud;../../../../../middleware/mcu_bootloader/src/bootloader;../../../../../middleware/mcu_bootloader/src/crc;../../../../../middleware/mcu_bootloader/src/include;../../../../../middleware/mcu_bootloader/src/memory;../../../../../middleware/mcu_bootloader/src/memory/src;../../../../../middleware/mcu_bootloader/src/packet;../../../../../middleware/mcu_bootloader/src/property;../../../../../middleware/mcu_bootloader/src/sbloader;../../../../../middleware/mcu_bootloader/src/utilities;../../../../../middleware/usb/device;../../../../../middleware/usb/device/class;../../../../../middleware/mcu_bootloader/src/bm_usb;../../../../../middleware/mcu_bootloader/src/drivers/ocotp;../../../../../middleware/mcu_bootloader/src/drivers/microseconds;../../../../../drivers/common;../../../../../devices/RT/RT1010/MIMXRT1011/drivers;../../../../../drivers/wdog01;../../../../../drivers/rtwdog;../../../../../drivers/igpio;../../../../../drivers/lpuart;../../../../../devices/RT/RT1010/MIMXRT1011;../../../../../middleware/mcu_bootloader/targets/MIMXRT1011/src;../../../../../middleware/mcu_bootloader/src/drivers/flexspi_nor;../../../../../middleware/mcu_bootloader/src/drivers/flexspi;../../../../../middleware/mcu_bootloader/src/drivers/smc;../../../../../middleware/mcu_bootloader/src/drivers/dcp;../../../../../middleware/mcu_bootloader/src/drivers/trng
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1011_ram_flashloader.scf
  link misc: --remove --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: pin_mux.c pin_mux.h fsl_os_abstraction_config.h mcux_config.h
  group board
    ../: clock_config.h clock_config.c
  group drivers
    ../../../../../devices/MIMXRT1011/drivers/: fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c
    ../../../../../devices/RT/RT1010/MIMXRT1011/drivers/: fsl_clock.h fsl_iomuxc.h
    ../../../../../drivers/wdog01/: fsl_wdog.h
    ../../../../../drivers/rtwdog/: fsl_rtwdog.h
    ../../../../../drivers/lpuart/: fsl_lpuart.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv7m_cachel1.h armv7m_mpu.h
  group device
    ../../../../../devices/MIMXRT1011/: fsl_device_registers.h MIMXRT1011.h MIMXRT1011_features.h MIMXRT1011_COMMON.h
  group device/periph
    ../../../../../devices/MIMXRT1011/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_AIPSTZ.h PERI_AOI.h PERI_CCM.h PERI_CCM_ANALOG.h PERI_CM7_MCM.h PERI_CSU.h PERI_DCDC.h PERI_DCP.h PERI_DMA.h PERI_DMAMUX.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_KPP.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_OCOTP.h PERI_OTFAD.h PERI_PGC.h PERI_PIT.h PERI_PMU.h PERI_PWM.h PERI_RTWDOG.h PERI_SNVS.h PERI_SPDIF.h PERI_SRC.h PERI_TEMPMON.h PERI_TRNG.h PERI_USB.h PERI_USBNC.h PERI_USBPHY.h PERI_USB_ANALOG.h PERI_WDOG.h PERI_XBARA.h PERI_XTALOSC24M.h
  group utilities
    ../../../../../devices/MIMXRT1011/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
    ../../../../../devices/MIMXRT1011/utilities/: fsl_memcpy.S
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group utilities/str
    ../../../../../devices/MIMXRT1011/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../devices/MIMXRT1011/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c fsl_os_abstraction.h
  group usb/include
    ../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group usb/phy
    ../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h usb_phy.c usb_phy.h
  group source/src/autobaud
    ../../../../../middleware/mcu_bootloader/src/autobaud/: autobaud.h
  group source/src/autobaud/src
    ../../../../../middleware/mcu_bootloader/src/autobaud/src/: autobaud_irq.c
  group source/src/bootloader
    ../../../../../middleware/mcu_bootloader/src/bootloader/: bl_peripheral_interface.h bl_user_entry.h bl_version.h bootloader.h bl_command.h bl_context.h bl_peripheral.h bl_shutdown_cleanup.h bl_irq_common.h bl_app_crc_check.h
  group source/src/bootloader/src
    ../../../../../middleware/mcu_bootloader/src/bootloader/src/: bl_user_entry.c bl_main.c bl_context.c bl_exception_handler.c bl_tree_root.c bl_command.c bl_shutdown_cleanup.c bl_app_crc_check.c bl_misc.c
  group source/src/crc
    ../../../../../middleware/mcu_bootloader/src/crc/: crc16.h crc32.h
  group source/src/crc/src
    ../../../../../middleware/mcu_bootloader/src/crc/src/: crc16.c crc32.c
  group source/src/include
    ../../../../../middleware/mcu_bootloader/src/include/: bootloader_common.h bootloader_core.h
  group source/src/memory
    ../../../../../middleware/mcu_bootloader/src/memory/: memory.h
  group source/src/memory/src
    ../../../../../middleware/mcu_bootloader/src/memory/src/: sram_init.h memory.c normal_memory.h normal_memory.c pattern_fill.h pattern_fill_mdk.s
  group source/src/packet
    ../../../../../middleware/mcu_bootloader/src/packet/: command_packet.h serial_packet.h
  group source/src/packet/src
    ../../../../../middleware/mcu_bootloader/src/packet/src/: serial_packet.c
  group source/src/property
    ../../../../../middleware/mcu_bootloader/src/property/: property.h
  group source/src/sbloader
    ../../../../../middleware/mcu_bootloader/src/sbloader/: sbloader.h sb_file_format.h
  group source/src/sbloader/src
    ../../../../../middleware/mcu_bootloader/src/sbloader/src/: sbloader.c
  group source/src/utilities
    ../../../../../middleware/mcu_bootloader/src/utilities/: fsl_rtos_abstraction.h fsl_assert.h vector_table_info.h
  group source/src/utilities/src
    ../../../../../middleware/mcu_bootloader/src/utilities/src/: fsl_assert.c fsl_rtos_abstraction.c debug_util.c
  group source/src/startup
    ../../../../../middleware/mcu_bootloader/src/startup/: startup.c
  group usb/device
    ../../../../../middleware/usb/device/: usb_device_ehci.c usb_device_ehci.h usb_device.h usb_device_dci.c usb_device_dci.h usb_device.h usb_device_dci.h usb_device_ch9.c usb_device_ch9.h
  group usb
    ../../../../../middleware/usb/: ChangeLogKSDK.txt
  group usb/device/class
    ../../../../../middleware/usb/device/class/: usb_device_class.c usb_device_class.h usb_device_hid.c usb_device_hid.h
  group source/src/bm_usb
    ../../../../../middleware/mcu_bootloader/src/bm_usb/: bootloader_hid_report_ids.h fat_directory_entry.h composite.h composite.c hid_bootloader.h hid_bootloader.c usb_descriptor.h usb_descriptor.c
  group source/src/drivers/ocotp
    ../../../../../middleware/mcu_bootloader/src/drivers/ocotp/: bl_ocotp.c bl_ocotp.h
  group source/src/drivers/microseconds
    ../../../../../middleware/mcu_bootloader/src/drivers/microseconds/: microseconds.h
  group source/src/drivers/microseconds/src
    ../../../../../middleware/mcu_bootloader/src/drivers/microseconds/src/: microseconds_pit.c
  group mcu_bootloader
    ../../../../../devices/RT/RT1010/MIMXRT1011/: fsl_device_registers.h system_MIMXRT1011.h MIMXRT1011.h MIMXRT1011_features.h
  group mcu_bootloader/targets/MIMXRT1011/src/startup
    ../../../../../middleware/mcu_bootloader/targets/MIMXRT1011/src/startup/: system_MIMXRT1011.c
  group mcu_bootloader/targets/MIMXRT1011/src/startup/arm
    ../../../../../middleware/mcu_bootloader/targets/MIMXRT1011/src/startup/arm/: startup_MIMXRT1011.s
  group sources/targets/MIMXRT1011/src
    ../../../../../middleware/mcu_bootloader/targets/MIMXRT1011/src/: bootloader_config.h bl_clock_config_MIMXRT1011.c hardware_init_MIMXRT1011.c memory_map_MIMXRT1011.c external_memory_property_map_MIMXRT1011.c flexspi_nor_flash_MIMXRT1011.c bl_peripherals_MIMXRT1011.c peripherals_pinmux.h target_config.h fusemap.h bl_lpuart_irq_config_MIMXRT1011.c usb_device_config.h sram_init_MIMXRT1011.c bl_dcp_MIMXRT1011.c bl_romapi_MIMXRT1011.c
  group sources/targets/common/src
    ../../../../../middleware/mcu_bootloader/targets/common/src/: pinmux_utility_imxrt_series.c
  group sources/src/bootloader/src
    ../../../../../middleware/mcu_bootloader/src/bootloader/src/: lpuart_peripheral_interface.c bl_nor_encrypt_otfad.c usb_hid_msc_peripheral_interface.c
  group sources/src/bootloader
    ../../../../../middleware/mcu_bootloader/src/bootloader/: bl_nor_encrypt.h bl_keyblob.h
  group sources/src/memory/src
    ../../../../../middleware/mcu_bootloader/src/memory/src/: flexspi_nor_memory.c flexspi_nor_memory.h
  group sources/src/property/src
    ../../../../../middleware/mcu_bootloader/src/property/src/: property_imx.c
  group sources/src/drivers/flexspi_nor
    ../../../../../middleware/mcu_bootloader/src/drivers/flexspi_nor/: flexspi_nor_flash.h
  group sources/src/drivers/flexspi
    ../../../../../middleware/mcu_bootloader/src/drivers/flexspi/: bl_flexspi.h
  group sources/src/drivers/smc
    ../../../../../middleware/mcu_bootloader/src/drivers/smc/: smc.h
  group sources/src/drivers/dcp
    ../../../../../middleware/mcu_bootloader/src/drivers/dcp/: bl_dcp.h
  group sources/src/drivers/trng
    ../../../../../middleware/mcu_bootloader/src/drivers/trng/: bl_trng.h
