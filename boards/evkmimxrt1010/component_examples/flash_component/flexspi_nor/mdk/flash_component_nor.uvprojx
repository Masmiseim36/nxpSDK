# Keil uVision project flash_component_nor.uvprojx, settings and files
target flash_component_nor debug (ARM-ADS)
  device: MIMXRT1011DAE5A NXP
  pack: NXP.MIMXRT1011_DFP.11.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: flash_component_nor.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT1011DAE5A, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../devices/MIMXRT1011/drivers;../../../../../../components/flash/nor/flexspi;../../../../../../devices/MIMXRT1011;../../../../../../devices/MIMXRT1011/utilities/str;../../../../../../devices/MIMXRT1011/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../devices/MIMXRT1011/xip;../../../../xip;../../../../../../CMSIS/Core/Include;../../../../../../components/flash/nor
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1011xxxxx_ram.scf
  link misc: --remove --entry=Reset_Handler
  group source
    ../: nor_flash.c nor_flash_ops.c app.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MIMXRT1011/drivers/: fsl_cache.c fsl_cache.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_flexspi.c fsl_flexspi.h
  group nor_flash
    ../../../../../../components/flash/nor/flexspi/: fsl_flexspi_nor_flash.c fsl_flexspi_nor_flash.h
    ../../../../../../components/flash/nor/: fsl_nor_flash.h
  group device
    ../../../../../../devices/MIMXRT1011/: fsl_device_registers.h MIMXRT1011.h MIMXRT1011_features.h system_MIMXRT1011.c system_MIMXRT1011.h
  group utilities
    ../../../../../../devices/MIMXRT1011/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1011/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1011/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMXRT1011/arm/: startup_MIMXRT1011.S
  group xip
    ../../../../../../devices/MIMXRT1011/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1010_flexspi_nor_config.c evkmimxrt1010_flexspi_nor_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
target flash_component_nor flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1011DAE5A NXP
  pack: NXP.MIMXRT1011_DFP.11.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: flash_component_nor.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1011DAE5A, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1011xxxxx_flexspi_nor.scf
  link misc: --remove --entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
target flash_component_nor release (ARM-ADS)
  device: MIMXRT1011DAE5A NXP
  pack: NXP.MIMXRT1011_DFP.11.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: flash_component_nor.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1011DAE5A, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1011xxxxx_ram.scf
  link misc: --remove --entry=Reset_Handler
target flash_component_nor flexspi_nor_release (ARM-ADS)
  device: MIMXRT1011DAE5A NXP
  pack: NXP.MIMXRT1011_DFP.11.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: flash_component_nor.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1011DAE5A, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1011xxxxx_flexspi_nor.scf
  link misc: as above
