# IAR project hello_world_swo.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1011xxx5A NXP MIMXRT1011xxx5A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; PRINTF_ADVANCED_ENABLE=0; PRINTF_FLOAT_ENABLE=0; SCANF_ADVANCED_ENABLE=0; SCANF_FLOAT_ENABLE=0; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1011DAE5A; MIMXRT1011_SERIES; SERIAL_PORT_TYPE_SWO=1
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../xip; ../../../../../devices/MIMXRT1011/drivers; ../../../../../CMSIS/Core/Include; ../../../../../CMSIS/Core/Include/m-profile; ../../../../../devices/MIMXRT1011; ../../../../../devices/MIMXRT1011/periph; ../../../../../devices/MIMXRT1011/xip; ../../../../../devices/MIMXRT1011/utilities/debug_console; ../../../../../components/lists; ../../../../../devices/MIMXRT1011/utilities/str; ../../../../../components/serial_manager
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT1011DAE5A; MIMXRT1011_SERIES
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: hello_world_swo.out
  ILINK.IlinkIcfFile: MIMXRT1011xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration ram_0x1400_debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: MIMXRT1011xxxxx_ram_0x1400.icf
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_BOOT_HEADER_ENABLE=1; XIP_EXTERNAL_FLASH=1; PRINTF_ADVANCED_ENABLE=0; PRINTF_FLOAT_ENABLE=0; SCANF_ADVANCED_ENABLE=0; SCANF_FLOAT_ENABLE=0; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1011DAE5A; MIMXRT1011_SERIES; SERIAL_PORT_TYPE_SWO=1
  ILINK.IlinkIcfFile: MIMXRT1011xxxxx_flexspi_nor.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; PRINTF_ADVANCED_ENABLE=0; PRINTF_FLOAT_ENABLE=0; SCANF_ADVANCED_ENABLE=0; SCANF_FLOAT_ENABLE=0; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1011DAE5A; MIMXRT1011_SERIES; SERIAL_PORT_TYPE_SWO=1
  ICCARM.CCOptLevel: 3
configuration ram_0x1400_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT1011xxxxx_ram_0x1400.icf
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; XIP_BOOT_HEADER_ENABLE=1; XIP_EXTERNAL_FLASH=1; PRINTF_ADVANCED_ENABLE=0; PRINTF_FLOAT_ENABLE=0; SCANF_ADVANCED_ENABLE=0; SCANF_FLOAT_ENABLE=0; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1011DAE5A; MIMXRT1011_SERIES; SERIAL_PORT_TYPE_SWO=1
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT1011xxxxx_flexspi_nor.icf
  group source
    ../: hello_world_swo.c fsl_debug_console_conf.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group xip
    ../../../xip/: evkmimxrt1010_flexspi_nor_config.c evkmimxrt1010_flexspi_nor_config.h
    ../../../../../devices/MIMXRT1011/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group drivers
    ../../../../../devices/MIMXRT1011/drivers/: fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_gpc.c fsl_gpc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_src.c fsl_src.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv7m_cachel1.h armv7m_mpu.h
  group device
    ../../../../../devices/MIMXRT1011/: fsl_device_registers.h MIMXRT1011.h MIMXRT1011_features.h MIMXRT1011_COMMON.h system_MIMXRT1011.c system_MIMXRT1011.h
  group device/periph
    ../../../../../devices/MIMXRT1011/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_AIPSTZ.h PERI_AOI.h PERI_CCM.h PERI_CCM_ANALOG.h PERI_CM7_MCM.h PERI_CSU.h PERI_DCDC.h PERI_DCP.h PERI_DMA.h PERI_DMAMUX.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_KPP.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_OCOTP.h PERI_OTFAD.h PERI_PGC.h PERI_PIT.h PERI_PMU.h PERI_PWM.h PERI_RTWDOG.h PERI_SNVS.h PERI_SPDIF.h PERI_SRC.h PERI_TEMPMON.h PERI_TRNG.h PERI_USB.h PERI_USBNC.h PERI_USBPHY.h PERI_USB_ANALOG.h PERI_WDOG.h PERI_XBARA.h PERI_XTALOSC24M.h
  group startup/iar
    ../../../../../devices/MIMXRT1011/iar/: startup_MIMXRT1011.s
  group utilities
    ../../../../../devices/MIMXRT1011/utilities/debug_console/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../devices/MIMXRT1011/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console
    ../../../../../devices/MIMXRT1011/utilities/debug_console/: fsl_debug_console.h fsl_debug_console.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_swo.h fsl_component_serial_port_swo.c
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
