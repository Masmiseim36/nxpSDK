# Keil uVision project safety_iec60730b.uvprojx, settings and files
target safety_iec60730b debug (ARM-ADS)
  device: MIMXRT1011DAE5A NXP
  pack: NXP.MIMXRT1011_DFP.11.0.0
  cpu: IRAM(0x00000000,0x010000) IRAM2(0x20000000,0x010000) IROM(0x60000000,0x800000) XRAM(0x20200000,0x020000) XRAM2(0x80000000,0x02000000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: safety_iec60730b.out +hex
  AfterMake: ..\..\..\..\..\middleware\safety_iec60730b\tools\crc\crc_hex.bat -..\..\..\..\boards\evkmimxrt1010\demo_apps\safety_iec60730b\mdk\debug\safety_iec60730b.hex -..\..\..\..\boards\evkmimxrt1010\demo_apps\safety_iec60730b\mdk\debug\safety_iec60730b_crc.hex -..\..\..\..\tools\srecord\srec_cat -CRC32
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT1011DAE5A, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, SERIAL_PORT_TYPE_UART=1
  c misc: -gdwarf-3
  c include: ../../../../../middleware/safety_iec60730b/boards/common/cm4_cm7/startup/cm7;..;../../../../../middleware/safety_iec60730b/boards/evkmimxrt1010/xip;linker;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/register;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/ram;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/flash;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/stack;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/programCounter;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7;../../../../../middleware/safety_iec60730b/safety/v4_1;../../../../../middleware/safety_iec60730b/safety/v4_1/compiler;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/wdog;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/tsi;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/dio;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/clock;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/aio;../../../../../devices/MIMXRT1011;../../../../../devices/MIMXRT1011/drivers;../../../../../devices/MIMXRT1011/utilities/str;../../../../../devices/MIMXRT1011/utilities/debug_console;../../../../../middleware/freemaster/src/common;../../../../../middleware/freemaster/src/platforms/gen32le;../../../../../middleware/freemaster/src/drivers/mcuxsdk/can;../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial;../../../../../components/serial_manager;../../../../../components/lists;../../../../../components/uart;../../../../../CMSIS/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../../../../../middleware/safety_iec60730b/boards/common/cm4_cm7/startup/cm7;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/register;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/ram;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/flash;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/stack;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/programCounter;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7;../../../../../middleware/safety_iec60730b/safety/v4_1;../../../../../middleware/safety_iec60730b/safety/v4_1/compiler;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/wdog;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/tsi;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/dio;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/clock;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/aio;../../../../../devices/MIMXRT1011
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: linker/evkmimxrt1010_safety_flash.sct
  link misc: --remove --datacompressor=off
  group source
    ../: freemaster_cfg.h safety_test_items.h safety_test_items.c isr.h safety_config.h project_setup_evkmimxrt1010.h project_setup_evkmimxrt1010.c safety_cm7_imxrt.c safety_cm7_imxrt.h main_imxrt.c
  group doc
    ../: readme.txt
  group board
    ../: pin_mux.c pin_mux.h clock_config.c clock_config.h board.c board.h
  group linker
    ../../../../../middleware/safety_iec60730b/tools/crc/: crc_hex.bat
    linker/: evkmimxrt1010_safety_flash.sct linker_config.h
  group tools/srecord
    ../../../../../tools/srecord/: srecord-1.64.zip
  group startup
    ../../../../../middleware/safety_iec60730b/boards/common/cm4_cm7/startup/cm7/: start.c startup_mdk.c vectors_mdk.c vectors_mdk.h
  group device
    ../../../../../middleware/safety_iec60730b/boards/evkmimxrt1010/xip/: evkmimxrt1010_flexspi_nor_config.c evkmimxrt1010_flexspi_nor_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../../../devices/MIMXRT1011/: fsl_device_registers.h MIMXRT1011.h MIMXRT1011_features.h
  group GUI
    ../GUI/: safety.pmp
  group safety/v4_1/register
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/register/: iec60730b_cm4_cm7_reg.h
  group safety/v4_1/ram
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/ram/: iec60730b_cm4_cm7_ram.h
  group safety/v4_1/flash
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/flash/: iec60730b_cm4_cm7_flash.h
  group safety/v4_1/stack
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/stack/: iec60730b_cm4_cm7_stack.h
  group safety/v4_1/programCounter
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/programCounter/: iec60730b_cm4_cm7_pc.h iec60730b_cm4_cm7_pc_object.S
  group safety/v4_1
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/: iec60730b_core.h
    ../../../../../middleware/safety_iec60730b/safety/v4_1/: iec60730b.h iec60730b_types.h IEC60730B_M4_M7_KEIL_v4_1.lib IEC60730B_M4_M7_COM_KEIL_v4_1.lib
  group safety/v4_1/compiler
    ../../../../../middleware/safety_iec60730b/safety/v4_1/compiler/: asm_mac_common.h
  group safety/v4_1/wdog
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/wdog/: iec60730b_wdog.c iec60730b_wdog.h
  group safety/v4_1/tsi
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/tsi/: iec60730b_tsi.h
  group safety/v4_1/dio
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/dio/: iec60730b_dio_ext.h iec60730b_dio.h
  group safety/v4_1/clock
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/clock/: iec60730b_clock.h
  group safety/v4_1/aio
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/aio/: iec60730b_aio.h
  group MIMXRT1011
    ../../../../../devices/MIMXRT1011/: system_MIMXRT1011.c system_MIMXRT1011.h
  group drivers
    ../../../../../devices/MIMXRT1011/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_iomuxc.h
  group utilities
    ../../../../../devices/MIMXRT1011/utilities/: fsl_assert.c
    ../../../../../devices/MIMXRT1011/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1011/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group freemaster
    ../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_defcfg.h freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h freemaster_can.c freemaster_can.h freemaster_sha.c freemaster_pdbdm.c freemaster_serial.c freemaster_serial.h
  group freemaster/platforms
    ../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group freemaster/drivers
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mscan.c freemaster_mscan.h freemaster_mcan.c freemaster_mcan.h
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_usb.c freemaster_serial_usb.h
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
