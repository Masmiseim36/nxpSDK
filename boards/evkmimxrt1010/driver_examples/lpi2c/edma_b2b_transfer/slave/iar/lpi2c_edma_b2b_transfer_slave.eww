<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>lpi2c_edma_b2b_transfer_slave</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>lpi2c_edma_b2b_transfer_slave</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>lpi2c_edma_b2b_transfer_slave</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
      <member>
        <project>lpi2c_edma_b2b_transfer_slave</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>lpi2c_edma_b2b_transfer_slave</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>lpi2c_edma_b2b_transfer_slave</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_debug</name>
      <member>
        <project>lpi2c_edma_b2b_transfer_slave</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_release</name>
      <member>
        <project>lpi2c_edma_b2b_transfer_slave</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/lpi2c_edma_b2b_transfer_slave.ewp</path>
  </project>
</workspace>
