# IAR project ew_gui_brick_game.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1011xxx5A NXP MIMXRT1011xxx5A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1011DAE5A; SDK_DEBUGCONSOLE=1; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565; EW_SURFACE_ROTATION=0; EW_USE_FREE_RTOS=0; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../GeneratedCode; ../../../../../components/ili9341; ../../../../../components/ft6x06; ../../../../../devices/MIMXRT1011/drivers; ../../../../../devices/MIMXRT1011/cmsis_drivers; ../../../../../devices/MIMXRT1011/utilities/debug_console_lite; ../../../../../middleware/EmbeddedWizard/TargetSpecific/evkmimxrt1010; ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1010/RGB565; ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1010/RTE; ../../../../../devices/MIMXRT1011; ../../../../../components/uart; ../../../../../components/lists; ../../../../../devices/MIMXRT1011/xip; ../../../xip; ../../../../../CMSIS/Core/Include; ../../../../../CMSIS/Driver/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_CLEAR_BSS; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: ew_gui_brick_game.out
  ILINK.IlinkIcfFile: MIMXRT1011xxxxx_flexspi_nor.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1010/RTE/libewrte-m7-iar.a; ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1010/RGB565/libewgfx-m7-iar.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1011DAE5A; SDK_DEBUGCONSOLE=1; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565; EW_SURFACE_ROTATION=0; EW_USE_FREE_RTOS=0; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG; __STARTUP_CLEAR_BSS; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: ili9341_spi.c ili9341_spi.h RTE_Device.h main.c ewmain.c ewmain.h DeviceDriver.c DeviceDriver.h
  group board
    ../: ewconfig.h ewdef.h pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group GeneratedCode
    ../GeneratedCode/: Application.c BrickGame.c Core.c Effects.c Graphics.c Resources.c Templates.c Views.c Application.h BrickGame.h Core.h Effects.h Graphics.h Resources.h Templates.h Views.h _ApplicationApplication.h _BrickGameBall.h _BrickGameBallPosition.h _BrickGameBrickGame.h _BrickGameBrickRow.h _BrickGameBricks.h _BrickGameDataClass.h _BrickGameDescrFont.h _BrickGameLandscape.h _BrickGameLcdDisplay.h _BrickGameLcdNumbers.h _BrickGamePaddle.h _BrickGameStars.h _CoreCursorEvent.h _CoreCursorGrabEvent.h _CoreCursorHit.h _CoreDialogContext.h _CoreDragEvent.h _CoreEvent.h _CoreGroup.h _CoreKeyEvent.h _CoreKeyPressHandler.h _CoreLayoutContext.h _CoreLayoutQuadContext.h _CoreModalContext.h _CoreOutline.h _CoreQuadView.h _CoreRectView.h _CoreResource.h _CoreRoot.h _CoreSimpleTouchHandler.h _CoreTask.h _CoreTaskQueue.h _CoreTimer.h _CoreView.h _EffectsEffectTimerClass.h _GraphicsCanvas.h _ResourcesBitmap.h _ResourcesFont.h _TemplatesDeviceClass.h _ViewsImage.h _ViewsRectangle.h _ViewsText.h ewlocale.h
  group doc
    ../: readme.txt
  group lcd
    ../../../../../components/ili9341/: fsl_ili9341.h fsl_ili9341.c
  group touchpanel
    ../../../../../components/ft6x06/: fsl_ft6x06.h fsl_ft6x06.c
  group drivers
    ../../../../../devices/MIMXRT1011/drivers/: fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_cache.c fsl_cache.h fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_lpi2c.c fsl_lpi2c.h fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_lpspi_edma.h fsl_lpspi_edma.c fsl_snvs_hp.c fsl_snvs_hp.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_lpspi.c fsl_lpspi.h
    ../../../../../devices/MIMXRT1011/cmsis_drivers/: fsl_lpspi_cmsis.h fsl_lpspi_cmsis.c fsl_lpi2c_cmsis.h fsl_lpi2c_cmsis.c
  group utilities
    ../../../../../devices/MIMXRT1011/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group EmbeddedWizard/TargetSpecific/evkmimxrt1010
    ../../../../../middleware/EmbeddedWizard/TargetSpecific/evkmimxrt1010/: ew_bsp_clock.c ew_bsp_console.c ew_bsp_display.c ew_bsp_event.c ew_bsp_inout.c ew_bsp_system.c ew_bsp_touch.c ew_bsp_clock.h ew_bsp_console.h ew_bsp_display.h ew_bsp_event.h ew_bsp_inout.h ew_bsp_system.h ew_bsp_touch.h
  group EmbeddedWizard/PlatformPackage/evkmimxrt1010/RGB565
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1010/RGB565/: ewextgfx.c ewextbmp.h ewextfnt.h ewextgfx.h ewextpxl_RGB565.h ewgfx.h ewgfxcore.h ewgfxdefs.h ewgfxdriver.h ewgfxlinks.h ewgfxres.h ewgfxtasks.h
  group EmbeddedWizard/PlatformPackage/evkmimxrt1010/RTE
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1010/RTE/: ewextrte.c ewextrte.h ewrte.h
  group device
    ../../../../../devices/MIMXRT1011/: fsl_device_registers.h MIMXRT1011.h MIMXRT1011_features.h system_MIMXRT1011.c system_MIMXRT1011.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1011/iar/: startup_MIMXRT1011.s
  group xip
    ../../../../../devices/MIMXRT1011/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1010_flexspi_nor_config.c evkmimxrt1010_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group CMSIS_driver
    ../../../../../CMSIS/Driver/Include/: Driver_I2C.h Driver_Common.h Driver_SPI.h
