# Keil uVision project freertos_percepio_snapshot.uvprojx, settings and files
target freertos_percepio_snapshot flexspi_nor_debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1011DAE5A NXP
  pack: NXP.MIMXRT1011_DFP.11.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: freertos_percepio_snapshot.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1011DAE5A, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc --diag_suppress=66,1296,186 --diag_suppress=1296,186
  c include: ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F;..;../GenericRecorderLibSrc/Include;../../../..;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../rtos/amazon-freertos/lib/include;../../../../../../rtos/amazon-freertos/lib/include/private;../../../../../../devices/MIMXRT1011/drivers;../../../../../../devices/MIMXRT1011/drivers;../../../../../../devices/MIMXRT1011;../../../../../../devices/MIMXRT1011/utilities/str;../../../../../../devices/MIMXRT1011/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/serial_manager;../../../../../../devices/MIMXRT1011/drivers;../../../../../../components/lists;../../../../../../devices/MIMXRT1011/drivers;../../../../../../devices/MIMXRT1011/drivers;../../../../../../devices/MIMXRT1011/xip;../../../../xip
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../GenericRecorderLibSrc/Include;../../../..
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1011xxxxx_flexspi_nor.scf
  link misc: --remove --keep=*(.boot_hdr.ivt) --keep=*(.boot_hdr.boot_data) --keep=*(.boot_hdr.conf) --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group source
    ../: main.c FreeRTOSConfig.h trcConfig.h
  group percepio
    ../GenericRecorderLibSrc/: trcUser.c trcKernelPortFreeRTOS.c trcKernel.c trcHardwarePort.c trcBase.c
  group percepio-Include
    ../GenericRecorderLibSrc/Include/: trcUser.h trcTypes.h trcKernelPort.h trcKernelHooks.h trcKernel.h trcHardwarePort.h trcBase.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MIMXRT1011/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h fsl_gpio.c fsl_gpio.h
  group amazon-freertos-freertos
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos-freertos-portable
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
  group amazon-freertos-include
    ../../../../../../rtos/amazon-freertos/lib/include/: FreeRTOS.h event_groups.h freertos_tasks_c_additions.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
    ../../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h stack_macros.h threading_alt.h
  group device
    ../../../../../../devices/MIMXRT1011/: MIMXRT1011.h MIMXRT1011_features.h fsl_device_registers.h system_MIMXRT1011.c system_MIMXRT1011.h
  group utilities
    ../../../../../../devices/MIMXRT1011/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1011/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1011/utilities/: fsl_assert.c
  group component-uart
    ../../../../../../components/uart/: lpuart_adapter.c uart.h
  group component-serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../../devices/MIMXRT1011/arm/: startup_MIMXRT1011.s
  group xip
    ../../../../../../devices/MIMXRT1011/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../../xip/: evkmimxrt1010_flexspi_nor_config.c evkmimxrt1010_flexspi_nor_config.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
target freertos_percepio_snapshot release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1011DAE5A NXP
  pack: NXP.MIMXRT1011_DFP.11.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: freertos_percepio_snapshot.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: NDEBUG, CPU_MIMXRT1011DAE5A, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc --diag_suppress=1296,186
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../GenericRecorderLibSrc/Include;../../../..
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1011xxxxx_ram.scf
  link misc: --remove
target freertos_percepio_snapshot flexspi_nor_release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1011DAE5A NXP
  pack: NXP.MIMXRT1011_DFP.11.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: freertos_percepio_snapshot.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1011DAE5A, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../GenericRecorderLibSrc/Include;../../../..
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1011xxxxx_flexspi_nor.scf
  link misc: as above
