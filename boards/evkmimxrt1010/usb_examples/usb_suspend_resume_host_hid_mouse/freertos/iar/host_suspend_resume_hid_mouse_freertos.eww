<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>host_suspend_resume_hid_mouse_freertos</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
      <member>
        <project>host_suspend_resume_hid_mouse_freertos</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_debug</name>
      <member>
        <project>host_suspend_resume_hid_mouse_freertos</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_release</name>
      <member>
        <project>host_suspend_resume_hid_mouse_freertos</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/host_suspend_resume_hid_mouse_freertos.ewp</path>
  </project>
</workspace>
