# IAR project wifi_serial_demo.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1011xxx5A NXP MIMXRT1011xxx5A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1011DAE5A; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; DEBUG_CONSOLE_ENABLE_ECHO=1; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_USBCDC=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; USB_DEVICE_CONFIG_CDC_ACM=1; SDK_OS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../common; ..; ../../../../../components/serial_mwm; ../../../../../components/serial_manager; ../../../../../components/serial_manager/usb_cdc_adapter; ../../../../../middleware/usb/device; ../../../../../middleware/usb/include; ../../../../../devices/MIMXRT1011/drivers; ../../../../../rtos/freertos/freertos-kernel/include; ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F; ../../../../../devices/MIMXRT1011; ../../../../../devices/MIMXRT1011/utilities/debug_console; ../../../../../components/lists; ../../../../../devices/MIMXRT1011/utilities; ../../../../../devices/MIMXRT1011/xip; ../../../xip; ../../../../../middleware/usb/output/source/device/class; ../../../../../middleware/usb/output/source/device; ../../../../../components/osa; ../../../../../middleware/usb/phy; ../../../../../CMSIS/Core/Include; ../../../../../devices/MIMXRT1011/utilities/str
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../../../../../rtos/freertos/freertos-kernel/include
  ILINK.IlinkOutputFile: wifi_serial_demo.out
  ILINK.IlinkIcfFile: MIMXRT1011xxxxx_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1011DAE5A; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; DEBUG_CONSOLE_ENABLE_ECHO=1; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_USBCDC=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; USB_DEVICE_CONFIG_CDC_ACM=1; SDK_OS_FREE_RTOS
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: FreeRTOSConfig.h main.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.md
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_port_usb.h fsl_component_serial_port_usb.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/serial_manager/usb_cdc_adapter
    ../: usb_device_config.h
    ../../../../../components/serial_manager/usb_cdc_adapter/: usb_device_descriptor.h usb_device_descriptor.c
  group component/serial_mwm
    ../../../../../components/serial_mwm/: serial_mwm_lpuart.c serial_mwm.h serial_mwm.c serial_mwm_port.h
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c
  group usb/device/source
    ../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h usb_device_dci.h
    ../../../../../middleware/usb/output/source/device/: usb_device_ch9.c usb_device_ch9.h
  group usb/device/source/ehci
    ../../../../../middleware/usb/device/: usb_device_ehci.c usb_device_ehci.h
  group usb/device/include
    ../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group usb/device/class
    ../../../../../middleware/usb/output/source/device/class/: usb_device_class.c usb_device_class.h
  group usb/device/class/cdc
    ../../../../../middleware/usb/output/source/device/class/: usb_device_cdc_acm.c usb_device_cdc_acm.h
  group usb/phy
    ../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group usb/include
    ../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group drivers
    ../../../../../devices/MIMXRT1011/drivers/: fsl_cache.c fsl_cache.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group drivers/freertos
    ../../../../../devices/MIMXRT1011/drivers/: fsl_lpuart_freertos.h fsl_lpuart_freertos.c
  group freertos/freertos-kernel
    ../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/portable
    ../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos-kernel/portable/IAR/ARM_CM4F
    ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos-kernel/include
    ../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group device
    ../../../../../devices/MIMXRT1011/: fsl_device_registers.h MIMXRT1011.h MIMXRT1011_features.h system_MIMXRT1011.c system_MIMXRT1011.h
  group utilities
    ../../../../../devices/MIMXRT1011/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1011/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../devices/MIMXRT1011/utilities/str/: fsl_str.c fsl_str.h
  group startup
    ../../../../../devices/MIMXRT1011/iar/: startup_MIMXRT1011.s
  group xip
    ../../../../../devices/MIMXRT1011/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1010_flexspi_nor_config.c evkmimxrt1010_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
