# Keil uVision project qca_demo.uvprojx, settings and files
target qca_demo flexspi_nor_debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1011DAE5A NXP
  pack: NXP.MIMXRT1011_DFP.11.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: qca_demo.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1011DAE5A, A_LITTLE_ENDIAN, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc --diag_suppress=66,1296,186 --diag_suppress=1296,186
  c include: ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F;../../..;..;../../../../../CMSIS/Include;../../../../../devices;../../../../../rtos/amazon-freertos/lib/include;../../../../../rtos/amazon-freertos/lib/include/private;../../../../../middleware/wifi_qca/port/boards/evkmimxrt1010/freertos/silex2401;../../../../../middleware/wifi_qca;../../../../../middleware/wifi_qca/include;../../../../../middleware/wifi_qca/include/AR6002;../../../../../middleware/wifi_qca/include/AR6002/hw2.0/hw;../../../../../middleware/wifi_qca/include/AR6002/hw4.0/hw;../../../../../middleware/wifi_qca/custom_src/stack_custom;../../../../../middleware/wifi_qca/custom_src/include;../../../../../middleware/wifi_qca/common_src/include;../../../../../middleware/wifi_qca/common_src/stack_common;../../../../../middleware/wifi_qca/common_src/hcd;../../../../../middleware/wifi_qca/common_src/wmi;../../../../../middleware/wifi_qca/port;../../../../../devices/MIMXRT1011/drivers;../../../../../devices/MIMXRT1011/drivers;../../../../../devices/MIMXRT1011;../../../../../devices/MIMXRT1011/utilities/str;../../../../../devices/MIMXRT1011/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/serial_manager;../../../../../devices/MIMXRT1011/drivers;../../../../../components/lists;../../../../../devices/MIMXRT1011/drivers;../../../../../devices/MIMXRT1011/drivers;../../../../../devices/MIMXRT1011/xip;../../../xip;../../../../../middleware/wifi_qca/port/boards/evkmimxrt1010/freertos;../../../../../middleware/wifi_qca/port/env/freertos;../../../../../middleware/wifi_qca/port/drivers/lpspi_edma_freertos;../../../../../devices/MIMXRT1011/drivers;../../../../../devices/MIMXRT1011/drivers;../../../../../devices/MIMXRT1011/drivers;../../../../../devices/MIMXRT1011/drivers
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../../..;..
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1011xxxxx_flexspi_nor.scf
  link misc: --remove --keep=*(.boot_hdr.ivt) --keep=*(.boot_hdr.boot_data) --keep=*(.boot_hdr.conf) --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group source
    ../: FreeRTOSConfig.h main.c wlan_qca400x.c wlan_qcom.c wlan_qcom.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group wifi_qca-port-shields-silex2401
    ../../../../../middleware/wifi_qca/port/boards/evkmimxrt1010/freertos/silex2401/: wifi_shield_silex2401.h
  group amazon-freertos-freertos-portable
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
  group wifi_qca-include
    ../../../../../middleware/wifi_qca/: atheros_stack_offload.h atheros_wifi.h atheros_wifi_api.h atheros_wifi_internal.h qcom_api.h
    ../../../../../middleware/wifi_qca/include/: athdefs.h bmi_msg.h dbglog.h dbglog_id.h htc.h htc_services.h p2p.h pkt_log.h pmu.h targaddrs.h wlan_defs.h wmi.h
  group wifi_qca-common_src-api_interface
    ../../../../../middleware/wifi_qca/common_src/api_interface/: api_init.c api_ioctl.c api_txrx.c api_wmi_rx.c
  group wifi_qca-common_src-bmi
    ../../../../../middleware/wifi_qca/common_src/bmi/: bmi.c
  group wifi_qca-common_src-driver
    ../../../../../middleware/wifi_qca/common_src/driver/: driver_diag.c driver_init.c driver_main.c driver_netbuf.c driver_txrx.c
  group wifi_qca-common_src-hcd
    ../../../../../middleware/wifi_qca/common_src/hcd/: hcd_api.h
  group wifi_qca-common_src-htc
    ../../../../../middleware/wifi_qca/common_src/hcd/: spi_hcd.c
    ../../../../../middleware/wifi_qca/common_src/htc/: htc.c
  group wifi_qca-common_src-hw_interface
    ../../../../../middleware/wifi_qca/common_src/hw_interface/: hw_api.c
  group wifi_qca-common_src-include
    ../../../../../middleware/wifi_qca/common_src/include/: a_debug.h a_drv.h a_drv_api.h aggr_recv_api.h bmi.h common_api.h dbglog_api.h driver_cxt.h dset.h dset_api.h hif_internal.h htc_api.h ieee80211.h netbuf.h spi_hcd_if.h wlan_api.h wmi_api.h
  group wifi_qca-common_src-qapi
    ../../../../../middleware/wifi_qca/common_src/qapi/: qcom_api.c qcom_dns.c qcom_legacy.c
    ../../../../../middleware/wifi_qca/common_src/stack_common/: api_stack_offload.c
  group wifi_qca-common_src-reorder
    ../../../../../middleware/wifi_qca/common_src/reorder/: rcv_aggr.c
  group wifi_qca-common_src-stack_common
    ../../../../../middleware/wifi_qca/common_src/stack_common/: common_stack_offload.h
    ../../../../../middleware/wifi_qca/common_src/storerecall/: dset_api.c
  group wifi_qca-common_src-storerecall
    ../../../../../middleware/wifi_qca/common_src/storerecall/: dset.c storerecall.c
  group wifi_qca-common_src-util
    ../../../../../middleware/wifi_qca/common_src/util/: util.c
  group wifi_qca-common_src-wmi
    ../../../../../middleware/wifi_qca/common_src/wmi/: wmi.c wmi_host.h
  group wifi_qca-custom_src-api_interface
    ../../../../../middleware/wifi_qca/custom_src/api_interface/: cust_api_init.c cust_api_ioctl.c cust_api_txrx.c cust_api_wmi_rx.c
  group wifi_qca-custom_src-driver
    ../../../../../middleware/wifi_qca/custom_src/driver/: cust_driver_main.c cust_driver_netbuf.c
  group wifi_qca-custom_src-hw_interface
    ../../../../../middleware/wifi_qca/custom_src/hw_interface/: cust_spi_hcd.c
  group wifi_qca-custom_src-include
    ../../../../../middleware/wifi_qca/custom_src/include/: a_config.h a_osapi.h a_types.h cust_netbuf.h custom_wlan_api.h wlan_config.h
  group wifi_qca-custom_src-qapi
    ../../../../../middleware/wifi_qca/custom_src/qapi/: custom_qcom_api.c
  group wifi_qca-custom_src-stack_custom
    ../../../../../middleware/wifi_qca/custom_src/stack_custom/: cust_api_stack_offload.c cust_api_stack_txrx.c custom_stack_offload.h qca_structs.h
  group wifi_qca-include-AR6002
    ../../../../../middleware/wifi_qca/include/AR6002/: AR6K_version.h
  group wifi_qca-include-AR6002-hw2.0-hw
    ../../../../../middleware/wifi_qca/include/AR6002/hw2.0/hw/: hw20_apb_map.h hw20_gpio_reg.h hw20_mbox_host_reg.h hw20_mbox_reg.h hw20_rtc_reg.h hw20_si_reg.h hw20_uart_reg.h hw20_vmc_reg.h
  group wifi_qca-include-AR6002-hw4.0-hw
    ../../../../../middleware/wifi_qca/include/AR6002/hw4.0/hw/: hw40_rtc_reg.h hw40_rtc_wlan_reg.h
  group wifi_qca-port
    ../../../../../middleware/wifi_qca/port/: wifi_common.h wifi_shield_common.h
  group amazon-freertos-freertos
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos-include
    ../../../../../rtos/amazon-freertos/lib/include/: FreeRTOS.h event_groups.h freertos_tasks_c_additions.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
    ../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h stack_macros.h threading_alt.h
  group drivers
    ../../../../../devices/MIMXRT1011/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h fsl_gpio.c fsl_gpio.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.c fsl_lpspi_edma.h fsl_edma.c fsl_edma.h fsl_dmamux.c fsl_dmamux.h
  group device
    ../../../../../devices/MIMXRT1011/: MIMXRT1011.h MIMXRT1011_features.h fsl_device_registers.h system_MIMXRT1011.c system_MIMXRT1011.h
  group utilities
    ../../../../../devices/MIMXRT1011/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1011/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1011/utilities/: fsl_assert.c
  group component-uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MIMXRT1011/arm/: startup_MIMXRT1011.s
  group xip
    ../../../../../devices/MIMXRT1011/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../xip/: evkmimxrt1010_flexspi_nor_config.c evkmimxrt1010_flexspi_nor_config.h
  group wifi_qca-port-shields
    ../../../../../middleware/wifi_qca/port/boards/evkmimxrt1010/freertos/: wifi_shield.c wifi_shield.h
  group wifi_qca-port-env-freertos
    ../../../../../middleware/wifi_qca/port/env/freertos/: wifi_env.c wifi_env.h wifi_env_port.h wifi_port.h
  group wifi_qca-port-drivers-lpspi_edma_freertos
    ../../../../../middleware/wifi_qca/port/drivers/lpspi_edma_freertos/: wifi_spi.c wifi_spi.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
target qca_demo flexspi_nor_release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1011DAE5A NXP
  pack: NXP.MIMXRT1011_DFP.11.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: qca_demo.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1011DAE5A, A_LITTLE_ENDIAN, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../../..;..
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1011xxxxx_flexspi_nor.scf
  link misc: as above
