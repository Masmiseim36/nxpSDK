# Keil uVision project fxas21002_poll.uvprojx, settings and files
target fxas21002_poll debug (ARM-ADS)
  device: MIMXRT1011DAE5A NXP
  pack: NXP.MIMXRT1011_DFP.11.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: fxas21002_poll.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT1011DAE5A, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../..;..;../../../../../../evkmimxrt1010;../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../devices/MIMXRT1011/drivers;../../../../../../../devices/MIMXRT1011/cmsis_drivers;../../../../../../../middleware/issdk/drivers/systick;../../../../../../../middleware/issdk/drivers/gpio;../../../../../../../middleware/issdk/drivers/gpio/i.mx;../../../../../../../middleware/issdk/sensors;../../../../../../../devices/MIMXRT1011;../../../../../../../devices/MIMXRT1011/utilities/str;../../../../../../../devices/MIMXRT1011/utilities/debug_console;../../../../../../../components/uart;../../../../../../../components/serial_manager;../../../../../../../components/lists;../../../../../../../devices/MIMXRT1011/xip;../../../../../../evkmimxrt1010/xip;../../../../../../../CMSIS/Driver/Include;../../../../../../../devices/MIMXRT1011/utilities
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1011xxxxx_ram.scf
  link misc: --remove
  group board
    ../../../../../: evkmimxrt1010.c evkmimxrt1010.h frdm_stbc_agm01_shield.h issdk_hal.h RTE_Device.h
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source
    ../: fxas21002_poll.c
  group doc
    ../: readme.txt readme.txt
  group drivers
    ../../../../../../../devices/MIMXRT1011/drivers/: fsl_clock.c fsl_clock.h fsl_edma.c fsl_edma.h fsl_dmamux.c fsl_dmamux.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.c fsl_lpspi_edma.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_common.c fsl_common.h fsl_iomuxc.h fsl_gpio.c fsl_gpio.h
    ../../../../../../../devices/MIMXRT1011/cmsis_drivers/: fsl_lpi2c_cmsis.c fsl_lpi2c_cmsis.h fsl_lpspi_cmsis.c fsl_lpspi_cmsis.h fsl_lpuart_cmsis.c fsl_lpuart_cmsis.h
  group utilities
    ../../../../../../../middleware/issdk/drivers/systick/: systick_utils.c systick_utils.h
    ../../../../../../../devices/MIMXRT1011/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/MIMXRT1011/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MIMXRT1011/utilities/: fsl_assert.c
  group gpio_driver
    ../../../../../../../middleware/issdk/drivers/gpio/: Driver_GPIO.h
    ../../../../../../../middleware/issdk/drivers/gpio/i.mx/: gpio_driver.c gpio_driver.h
  group interfaces
    ../../../../../../../middleware/issdk/sensors/: register_io_i2c.c register_io_i2c.h register_io_spi.c register_io_spi.h sensor_drv.h sensor_io_i2c.c sensor_io_i2c.h sensor_io_spi.c sensor_io_spi.h
  group sensors
    ../../../../../../../middleware/issdk/sensors/: fxas21002.h fxas21002_drv.c fxas21002_drv.h
  group device
    ../../../../../../../devices/MIMXRT1011/: MIMXRT1011.h MIMXRT1011_features.h fsl_device_registers.h system_MIMXRT1011.c system_MIMXRT1011.h
  group component-uart
    ../../../../../../../components/uart/: lpuart_adapter.c uart.h
  group component-serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../../../devices/MIMXRT1011/arm/: startup_MIMXRT1011.S
  group xip
    ../../../../../../../devices/MIMXRT1011/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../../../../evkmimxrt1010/xip/: evkmimxrt1010_flexspi_nor_config.c evkmimxrt1010_flexspi_nor_config.h
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_I2C.h Driver_Common.h Driver_SPI.h Driver_USART.h
target fxas21002_poll flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1011DAE5A NXP
  pack: NXP.MIMXRT1011_DFP.11.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: fxas21002_poll.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1011DAE5A, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1011xxxxx_flexspi_nor.scf
  link misc: --remove --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
target fxas21002_poll release (ARM-ADS)
  device: MIMXRT1011DAE5A NXP
  pack: NXP.MIMXRT1011_DFP.11.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: fxas21002_poll.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1011DAE5A, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1011xxxxx_ram.scf
  link misc: --remove
target fxas21002_poll flexspi_nor_release (ARM-ADS)
  device: MIMXRT1011DAE5A NXP
  pack: NXP.MIMXRT1011_DFP.11.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: fxas21002_poll.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1011DAE5A, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1011xxxxx_flexspi_nor.scf
  link misc: --remove --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
