# Keil uVision project flexio_spi_interrupt_transfer_master.uvprojx, settings and files
target flexio_spi_interrupt_transfer_master debug (ARM-ADS)
  device: MIMXRT1015DAF5A NXP
  pack: NXP.MIMXRT1015_DFP.11.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: flexio_spi_interrupt_transfer_master.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT1015DAF5A, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../..;..;../../../../../..;../../../../../../../../CMSIS/Include;../../../../../../../../devices;../../../../../../../../devices/MIMXRT1015/drivers;../../../../../../../../devices/MIMXRT1015;../../../../../../../../devices/MIMXRT1015/utilities/str;../../../../../../../../devices/MIMXRT1015/utilities/debug_console;../../../../../../../../components/uart;../../../../../../../../components/serial_manager;../../../../../../../../components/lists;../../../../../../../../devices/MIMXRT1015/xip;../../../../../../xip;../../../../../../../../devices/MIMXRT1015/utilities
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1015xxxxx_ram.scf
  link misc: --remove
  group source
    ../: flexio_spi_interrupt_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../../devices/MIMXRT1015/drivers/: fsl_clock.c fsl_clock.h fsl_flexio.c fsl_flexio.h fsl_flexio_spi.c fsl_flexio_spi.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h fsl_gpio.c fsl_gpio.h
  group device
    ../../../../../../../../devices/MIMXRT1015/: MIMXRT1015.h MIMXRT1015_features.h fsl_device_registers.h system_MIMXRT1015.c system_MIMXRT1015.h
  group utilities
    ../../../../../../../../devices/MIMXRT1015/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../../devices/MIMXRT1015/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../../devices/MIMXRT1015/utilities/: fsl_assert.c
  group component-uart
    ../../../../../../../../components/uart/: lpuart_adapter.c uart.h
  group component-serial_manager
    ../../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../../../../devices/MIMXRT1015/arm/: startup_MIMXRT1015.S
  group xip
    ../../../../../../../../devices/MIMXRT1015/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../../../../xip/: evkmimxrt1015_flexspi_nor_config.c evkmimxrt1015_flexspi_nor_config.h
  group CMSIS
    ../../../../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
target flexio_spi_interrupt_transfer_master flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1015DAF5A NXP
  pack: NXP.MIMXRT1015_DFP.11.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: flexio_spi_interrupt_transfer_master.out
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1015DAF5A, SERIAL_PORT_TYPE_UART=1
  c misc: -ffunction-sections  -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1015xxxxx_flexspi_nor.scf
  link misc: --remove --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
target flexio_spi_interrupt_transfer_master release (ARM-ADS)
  device: MIMXRT1015DAF5A NXP
  pack: NXP.MIMXRT1015_DFP.11.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: flexio_spi_interrupt_transfer_master.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1015DAF5A, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1015xxxxx_ram.scf
  link misc: --remove
target flexio_spi_interrupt_transfer_master flexspi_nor_release (ARM-ADS)
  device: MIMXRT1015DAF5A NXP
  pack: NXP.MIMXRT1015_DFP.11.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: flexio_spi_interrupt_transfer_master.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1015DAF5A, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1015xxxxx_flexspi_nor.scf
  link misc: --remove --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
