<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>qtmr_inputcapture_outputpwm_dma</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>qtmr_inputcapture_outputpwm_dma</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>qtmr_inputcapture_outputpwm_dma</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
      <member>
        <project>qtmr_inputcapture_outputpwm_dma</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>qtmr_inputcapture_outputpwm_dma</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>qtmr_inputcapture_outputpwm_dma</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_debug</name>
      <member>
        <project>qtmr_inputcapture_outputpwm_dma</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_release</name>
      <member>
        <project>qtmr_inputcapture_outputpwm_dma</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/qtmr_inputcapture_outputpwm_dma.ewp</path>
  </project>
</workspace>
