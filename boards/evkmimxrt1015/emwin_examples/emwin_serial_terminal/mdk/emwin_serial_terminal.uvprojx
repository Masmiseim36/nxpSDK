# Keil uVision project emwin_serial_terminal.uvprojx, settings and files
target emwin_serial_terminal flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1015DAF5A NXP
  pack: NXP.MIMXRT1015_DFP.11.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: emwin_serial_terminal.out
  AfterMake: fromelf.exe --output "$Lemwin_serial_terminal.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, XIP_BOOT_HEADER_ENABLE=1, XIP_EXTERNAL_FLASH=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1015DAF5A, MIMXRT1015_SERIES
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../../devices/MIMXRT1015/drivers;../../../../../middleware/emwin/emWin_header;../../../../../middleware/emwin/emWin_Config;../../../xip;../../../../../CMSIS/Core/Include;../../../../../CMSIS/Core/Include/m-profile;../../../../../CMSIS/Driver/Include;../../../../../devices/MIMXRT1015;../../../../../devices/MIMXRT1015/periph;../../../../../devices/MIMXRT1015/xip;../../../../../devices/MIMXRT1015/cmsis_drivers;../../../../../devices/MIMXRT1015/utilities/debug_console_lite;../../../../../devices/MIMXRT1015/utilities/str;../../../../../components/uart;../../../../../components/video;../../../../../components/video/display;../../../../../components/touch/ft6x06;../../../../../components/display/ili9341
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1015DAF5A, MIMXRT1015_SERIES
  asm include: ..;../../../../../devices/MIMXRT1015/drivers;../../../xip;../../../../../CMSIS/Core/Include;../../../../../CMSIS/Core/Include/m-profile;../../../../../CMSIS/Driver/Include;../../../../../devices/MIMXRT1015;../../../../../devices/MIMXRT1015/periph;../../../../../devices/MIMXRT1015/xip;../../../../../devices/MIMXRT1015/cmsis_drivers;../../../../../devices/MIMXRT1015/utilities/debug_console_lite;../../../../../devices/MIMXRT1015/utilities/str;../../../../../components/uart;../../../../../components/video;../../../../../components/video/display;../../../../../components/touch/ft6x06;../../../../../components/display/ili9341
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1015xxxxx_flexspi_nor_ocram.scf
  link misc: ../../../../../middleware/emwin/emWin_library/Keil/emWin_M7.lib --remove --predefine=\"-DXIP_BOOT_HEADER_ENABLE=1\" --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group board
    ../: board.c board.h clock_config.c clock_config.h board.h board.c clock_config.h clock_config.c
  group source
    ../: emwin_serial_terminal.c emwin_support.c emwin_support.h RTE_Device.h pin_mux.c pin_mux.h hardware_init.c app.h mcux_config.h
  group drivers
    ../../../../../devices/MIMXRT1015/drivers/: fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_cache.c fsl_cache.h fsl_dcdc.c fsl_dcdc.h fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_gpc.c fsl_gpc.h fsl_gpio.h fsl_gpio.c fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpspi_edma.h fsl_lpspi_edma.c fsl_lpspi.c fsl_lpspi.h fsl_lpuart.h fsl_lpuart.c fsl_pmu.h fsl_pmu.c fsl_src.c fsl_src.h
    ../../../../../devices/MIMXRT1015/cmsis_drivers/: fsl_lpi2c_cmsis.h fsl_lpi2c_cmsis.c fsl_lpspi_cmsis.h fsl_lpspi_cmsis.c
  group emwin/emWin_header
    ../../../../../middleware/emwin/emWin_header/: AppWizard.h BUTTON.h BUTTON_Private.h CALENDAR.h CHECKBOX.h CHECKBOX_Private.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Type.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h GAUGE.h GAUGE_Private.h GRAPH.h GRAPH_Private.h GUI.h GUIDRV_BitPlains.h GUIDRV_DCache.h GUIDRV_DCache_Private.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_FlexColor_Private.h GUIDRV_IST3088.h GUIDRV_IST3088_Private.h GUIDRV_Lin.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_Null.h GUIDRV_S1D13748.h GUIDRV_S1D13748_Private.h GUIDRV_S1D13781.h GUIDRV_S1D13781_Private.h GUIDRV_S1D15G00.h GUIDRV_SH_MEM.h GUIDRV_SH_MEM_Private.h GUIDRV_SLin.h GUIDRV_SLin_Private.h GUIDRV_SPage.h GUIDRV_SPage_Private.h GUIDRV_SSD1926.h GUIDRV_SSD1926_Private.h GUITDRV_ADS7846.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GCache_Private.h GUI_GIF_Private.h GUI_JPEG_Private.h GUI_Private.h GUI_Resource.h GUI_SIM_Win32.h GUI_SPRITE_Private.h GUI_SPY_Private.h GUI_SVG_Global.h GUI_SVG_NanoVG.h GUI_SVG_NemaVG.h GUI_SVG_OpenVG.h GUI_SVG_Private.h GUI_SVG_VGLite.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_Type.h GUI_VNC.h GUI_Version.h GUI__BiDi_Brackets.h GUI__BiDi_Types.h Global.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h IMAGE.h IMAGE_Private.h IP_FS.h JPEGConf.h KEYBOARD.h KEYBOARD_Private.h KNOB.h KNOB_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LCD_X_8080_16.h LCD_X_8080_8.h LCD_X_I2C.h LCD_X_Serial_3Pin.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MOVIE.h MOVIE_Private.h MULTIEDIT.h MULTIEDIT_Private.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h QRCODE.h QRCODE_Private.h RADIO.h RADIO_Private.h ROTARY.h ROTARY_Private.h SCROLLBAR.h SCROLLBAR_Private.h SCROLLER.h SCROLLER_Private.h SEGGER.h SLIDER.h SLIDER_Private.h SPINBOX.h SPINBOX_Private.h SWIPELIST.h SWIPELIST_Private.h SWITCH.h SWITCH_Private.h TEXT.h TEXT_Private.h TICKER.h TICKER_Private.h TREEVIEW.h TREEVIEW_Private.h WHEEL.h WHEEL_Private.h WIDGET.h WIDGET_ID.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h WM_Layout.h
  group emwin/emWin_Config
    ../../../../../middleware/emwin/emWin_Config/: GUIConf.h LCDConf.h
  group xip
    ../../../xip/: evkmimxrt1015_flexspi_nor_config.c evkmimxrt1015_flexspi_nor_config.h
    ../../../../../devices/MIMXRT1015/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv7m_cachel1.h armv7m_mpu.h
  group CMSIS_driver/Include
    ../../../../../CMSIS/Driver/Include/: Driver_I2C.h Driver_Common.h Driver_SPI.h Driver_Common.h
  group device
    ../../../../../devices/MIMXRT1015/: fsl_device_registers.h MIMXRT1015.h MIMXRT1015_features.h MIMXRT1015_COMMON.h system_MIMXRT1015.c system_MIMXRT1015.h
  group device/periph
    ../../../../../devices/MIMXRT1015/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_AIPSTZ.h PERI_AOI.h PERI_BEE.h PERI_CCM.h PERI_CCM_ANALOG.h PERI_CM7_MCM.h PERI_CSU.h PERI_DCDC.h PERI_DCP.h PERI_DMA.h PERI_DMAMUX.h PERI_ENC.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_KPP.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_OCOTP.h PERI_PGC.h PERI_PIT.h PERI_PMU.h PERI_PWM.h PERI_RTWDOG.h PERI_SNVS.h PERI_SPDIF.h PERI_SRC.h PERI_TEMPMON.h PERI_TMR.h PERI_TRNG.h PERI_USB.h PERI_USBNC.h PERI_USBPHY.h PERI_USB_ANALOG.h PERI_WDOG.h PERI_XBARA.h PERI_XBARB.h PERI_XTALOSC24M.h
  group startup/arm
    ../../../../../devices/MIMXRT1015/arm/: startup_MIMXRT1015.S
  group utilities
    ../../../../../devices/MIMXRT1015/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
    ../../../../../devices/MIMXRT1015/utilities/: fsl_memcpy.S
  group utilities/str
    ../../../../../devices/MIMXRT1015/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../devices/MIMXRT1015/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group video
    ../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../components/video/display/: fsl_display.h
  group touchpanel
    ../../../../../components/touch/ft6x06/: fsl_ft6x06.h fsl_ft6x06.c
  group lcdc
    ../../../../../components/display/ili9341/: fsl_ili9341.h fsl_ili9341.c
  group doc
    ../: readme.md
target emwin_serial_terminal flexspi_nor_release (ARM-ADS)
  device: MIMXRT1015DAF5A NXP
  pack: NXP.MIMXRT1015_DFP.11.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: emwin_serial_terminal.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, XIP_BOOT_HEADER_ENABLE=1, XIP_EXTERNAL_FLASH=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1015DAF5A, MIMXRT1015_SERIES
  c misc: as above
  c include: as above
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1015DAF5A, MIMXRT1015_SERIES
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1015xxxxx_flexspi_nor_ocram.scf
  link misc: as above
