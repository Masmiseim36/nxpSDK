# Keil uVision project lvgl_demo_benchmark.uvprojx, settings and files
target lvgl_demo_benchmark flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1015DAF5A NXP
  pack: NXP.MIMXRT1015_DFP.11.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: lvgl_demo_benchmark.out
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1015DAF5A, LV_CONF_INCLUDE_SIMPLE=1, LV_DEMO_CONF_INCLUDE_SIMPLE=1, SERIAL_PORT_TYPE_UART=1, SDK_OS_FREE_RTOS, MCUXPRESSO_SDK
  c misc: -ffunction-sections  -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../..;..;../../../../../middleware/lvgl/lv_examples/src/lv_demo_benchmark;../../../../../middleware/lvgl/lv_examples;../../../../../middleware/lvgl/lvgl/examples/assets;../../../../../middleware/lvgl/lv_examples/src/lv_demo_stress/assets;../../../../../components/ili9341;../../../../../components/ft6x06;../../../../../devices/MIMXRT1015/drivers;../../../../../devices/MIMXRT1015/cmsis_drivers;../../../../../middleware/lvgl/lvgl;../../../../../middleware/lvgl/lvgl/src;../../../../../middleware/lvgl;../../../../../devices/MIMXRT1015;../../../../../devices/MIMXRT1015/utilities/str;../../../../../devices/MIMXRT1015/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../devices/MIMXRT1015/xip;../../../xip;../../../../../CMSIS/Core/Include;../../../../../CMSIS/Driver/Include;../../../../../rtos/freertos/freertos_kernel/include;../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM4F
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1015xxxxx_flexspi_nor_ocram.scf
  link misc: --remove --entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group board
    ../../: RTE_Device.h lvgl_support.h lvgl_support.c
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source
    ../: lvgl_demo_benchmark.c lv_conf.h lv_demo_conf.h FreeRTOSConfig.h
  group lvgl/lv_examples/src/lv_demo_benchmark
    ../../../../../middleware/lvgl/lv_examples/src/lv_demo_benchmark/: lv_demo_benchmark.c lv_demo_benchmark.h
  group lvgl/lv_examples
    ../../../../../middleware/lvgl/lv_examples/: lv_demo.h
  group lvgl/lvgl/examples/assets
    ../../../../../middleware/lvgl/lvgl/examples/assets/: img_cogwheel_alpha16.c img_cogwheel_rgb.c img_cogwheel_argb.c img_cogwheel_indexed16.c img_cogwheel_chroma_keyed.c
  group lvgl/lv_examples/assets
    ../../../../../middleware/lvgl/lv_examples/src/lv_demo_stress/assets/: lv_font_montserrat_28_compr_az.c lv_font_montserrat_16_compr_az.c lv_font_montserrat_12_compr_az.c
  group doc
    ../: readme.txt
  group lcd
    ../../../../../components/ili9341/: fsl_ili9341.h fsl_ili9341.c
  group touchpanel
    ../../../../../components/ft6x06/: fsl_ft6x06.h fsl_ft6x06.c
  group drivers
    ../../../../../devices/MIMXRT1015/drivers/: fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_cache.c fsl_cache.h fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_lpi2c.c fsl_lpi2c.h fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_lpspi_edma.h fsl_lpspi_edma.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_lpspi.c fsl_lpspi.h
    ../../../../../devices/MIMXRT1015/cmsis_drivers/: fsl_lpspi_cmsis.h fsl_lpspi_cmsis.c fsl_lpi2c_cmsis.h fsl_lpi2c_cmsis.c
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group lvgl/lvgl
    ../../../../../middleware/lvgl/lvgl/: lvgl.h
  group lvgl/lvgl/src
    ../../../../../middleware/lvgl/lvgl/src/: lvgl.h lv_conf_kconfig.h lv_api_map.h lv_conf_internal.h
  group lvgl/lvgl/src/core
    ../../../../../middleware/lvgl/lvgl/src/core/: lv_disp.c lv_disp.h lv_event.c lv_event.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_indev_scroll.c lv_indev_scroll.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_draw.c lv_obj_draw.h lv_obj_pos.c lv_obj_pos.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_theme.c lv_theme.h
  group lvgl/lvgl/src/draw
    ../../../../../middleware/lvgl/lvgl/src/draw/: lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_blend.c lv_draw_blend.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
  group lvgl/lvgl/src/font
    ../../../../../middleware/lvgl/lvgl/src/font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_loader.c lv_font_loader.h lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c lv_symbol_def.h
  group lvgl/lvgl/src/gpu
    ../../../../../middleware/lvgl/lvgl/src/gpu/: lv_gpu_nxp_pxp.h lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.h lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_vglite.h lv_gpu_nxp_vglite.c lv_gpu_stm32_dma2d.h lv_gpu_stm32_dma2d.c
  group lvgl/lvgl/src/hal
    ../../../../../middleware/lvgl/lvgl/src/hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group lvgl/lvgl/src/misc
    ../../../../../middleware/lvgl/lvgl/src/misc/: lv_anim.c lv_anim.h lv_area.c lv_area.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_templ.c lv_templ.h lv_timer.c lv_timer.h lv_tlsf.c lv_tlsf.h lv_txt.c lv_txt.h lv_txt_ap.c lv_txt_ap.h lv_types.h lv_utils.c lv_utils.h
  group lvgl/lvgl/src/widgets
    ../../../../../middleware/lvgl/lvgl/src/widgets/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnmatrix.c lv_btnmatrix.h lv_canvas.c lv_canvas.h lv_checkbox.c lv_checkbox.h lv_dropdown.c lv_dropdown.h lv_img.c lv_img.h lv_label.c lv_label.h lv_line.c lv_line.h lv_objx_templ.c lv_objx_templ.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_switch.c lv_switch.h lv_table.c lv_table.h lv_textarea.c lv_textarea.h
  group lvgl/lvgl/src/extra
    ../../../../../middleware/lvgl/lvgl/src/extra/: lv_extra.c lv_extra.h
  group lvgl/lvgl/src/extra/layouts
    ../../../../../middleware/lvgl/lvgl/src/extra/layouts/: lv_layouts.h
  group lvgl/lvgl/src/extra/layouts/flex
    ../../../../../middleware/lvgl/lvgl/src/extra/layouts/flex/: lv_flex.c lv_flex.h
  group lvgl/lvgl/src/extra/layouts/grid
    ../../../../../middleware/lvgl/lvgl/src/extra/layouts/grid/: lv_grid.c lv_grid.h
  group lvgl/lvgl/src/extra/themes
    ../../../../../middleware/lvgl/lvgl/src/extra/themes/: lv_themes.h
  group lvgl/lvgl/src/extra/themes/basic
    ../../../../../middleware/lvgl/lvgl/src/extra/themes/basic/: lv_theme_basic.c lv_theme_basic.h
  group lvgl/lvgl/src/extra/themes/default
    ../../../../../middleware/lvgl/lvgl/src/extra/themes/default/: lv_theme_default.c lv_theme_default.h
  group lvgl/lvgl/src/extra/themes/mono
    ../../../../../middleware/lvgl/lvgl/src/extra/themes/mono/: lv_theme_mono.c lv_theme_mono.h
  group lvgl/lvgl/src/extra/widgets
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/: lv_widgets.h
  group lvgl/lvgl/src/extra/widgets/animimg
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/animimg/: lv_animimg.c lv_animimg.h
  group lvgl/lvgl/src/extra/widgets/calendar
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h
  group lvgl/lvgl/src/extra/widgets/chart
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/chart/: lv_chart.c lv_chart.h
  group lvgl/lvgl/src/extra/widgets/colorwheel
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c lv_colorwheel.h
  group lvgl/lvgl/src/extra/widgets/imgbtn
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c lv_imgbtn.h
  group lvgl/lvgl/src/extra/widgets/keyboard
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c lv_keyboard.h
  group lvgl/lvgl/src/extra/widgets/led
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/led/: lv_led.c lv_led.h
  group lvgl/lvgl/src/extra/widgets/list
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/list/: lv_list.c lv_list.h
  group lvgl/lvgl/src/extra/widgets/meter
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/meter/: lv_meter.c lv_meter.h
  group lvgl/lvgl/src/extra/widgets/msgbox
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c lv_msgbox.h
  group lvgl/lvgl/src/extra/widgets/span
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/span/: lv_span.c lv_span.h
  group lvgl/lvgl/src/extra/widgets/spinbox
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c lv_spinbox.h
  group lvgl/lvgl/src/extra/widgets/spinner
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/spinner/: lv_spinner.c lv_spinner.h
  group lvgl/lvgl/src/extra/widgets/tabview
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/tabview/: lv_tabview.c lv_tabview.h
  group lvgl/lvgl/src/extra/widgets/tileview
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/tileview/: lv_tileview.c lv_tileview.h
  group lvgl/lvgl/src/extra/widgets/win
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/win/: lv_win.c lv_win.h
  group device
    ../../../../../devices/MIMXRT1015/: fsl_device_registers.h MIMXRT1015.h MIMXRT1015_features.h system_MIMXRT1015.c system_MIMXRT1015.h
  group utilities
    ../../../../../devices/MIMXRT1015/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1015/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1015/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1015/arm/: startup_MIMXRT1015.S
  group xip
    ../../../../../devices/MIMXRT1015/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1015_flexspi_nor_config.c evkmimxrt1015_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group CMSIS_driver
    ../../../../../CMSIS/Driver/Include/: Driver_I2C.h Driver_Common.h Driver_SPI.h
  group freertos/freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    ../../../../../rtos/freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos_kernel/portable/GCC/ARM_CM4F
    ../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos/freertos_kernel/portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
target lvgl_demo_benchmark flexspi_nor_release (ARM-ADS)
  device: MIMXRT1015DAF5A NXP
  pack: NXP.MIMXRT1015_DFP.11.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: lvgl_demo_benchmark.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1015DAF5A, LV_CONF_INCLUDE_SIMPLE=1, LV_DEMO_CONF_INCLUDE_SIMPLE=1, SERIAL_PORT_TYPE_UART=1, SDK_OS_FREE_RTOS, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1015xxxxx_flexspi_nor_ocram.scf
  link misc: as above
