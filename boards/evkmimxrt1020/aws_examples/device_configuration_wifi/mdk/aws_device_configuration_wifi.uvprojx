# Keil uVision project aws_device_configuration_wifi.uvprojx, settings and files
target aws_device_configuration_wifi flexspi_nor_sdram_debug (ARM-ADS)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: aws_device_configuration_wifi.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DEBUG, FNET_CFG_COMP_UV=1, CPU_MIMXRT1021DAG5A, USE_RTOS=1, MBEDTLS_CONFIG_FILE='\"aws_mbedtls_config.h\"', FNET_PORT_WIFI_QCA=1, A_LITTLE_ENDIAN, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc --diag_suppress=66,1296,186 --diag_suppress=177 --diag_suppress=1296,186
  c include: ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F;../../..;..;../ssl_server;../fnet_mdns;../config_files;../../../../../CMSIS/Include;../../../../../devices;../../../../../rtos/amazon-freertos/lib/include;../../../../../rtos/amazon-freertos/lib/include/private;../../../../../middleware/mbedtls/include;../../../../../middleware/mbedtls/port/ksdk;../../../../../devices/MIMXRT1021/drivers;../../../../../devices/MIMXRT1021/drivers;../../../../../devices/MIMXRT1021/drivers;../../../../../devices/MIMXRT1021/drivers;../../../../../middleware/wifi_qca/port/boards/evkmimxrt1020/freertos/gt202;../../../../../rtos/amazon-freertos/lib/third_party/mcu_vendor/nxp/mflash/mimxrt1021;../../../../../middleware/wifi_qca;../../../../../middleware/wifi_qca/include;../../../../../middleware/wifi_qca/include/AR6002;../../../../../middleware/wifi_qca/include/AR6002/hw2.0/hw;../../../../../middleware/wifi_qca/include/AR6002/hw4.0/hw;../../../../../middleware/wifi_qca/custom_src/stack_custom;../../../../../middleware/wifi_qca/custom_src/include;../../../../../middleware/wifi_qca/common_src/include;../../../../../middleware/wifi_qca/common_src/stack_common;../../../../../middleware/wifi_qca/common_src/hcd;../../../../../middleware/wifi_qca/common_src/wmi;../../../../../middleware/wifi_qca/port;../../../../../rtos/amazon-freertos/lib/include;../../../../../rtos/amazon-freertos/lib/include/private;../../../../../rtos/amazon-freertos/lib/include;../../../../../rtos/amazon-freertos/lib/include;../../../../../rtos/amazon-freertos/lib/include;../../../../../rtos/amazon-freertos/lib/include;../../../../../rtos/amazon-freertos/lib/include;../../../../../rtos/amazon-freertos/lib/third_party/jsmn;../../../../../rtos/amazon-freertos/lib/third_party/pkcs11;../../../../../devices/MIMXRT1021/drivers;../../../../../devices/MIMXRT1021/drivers;../../../../../devices/MIMXRT1021;../../../../../devices/MIMXRT1021/utilities/str;../../../../../devices/MIMXRT1021/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/serial_manager;../../../../../devices/MIMXRT1021/drivers;../../../../../components/lists;../../../../../devices/MIMXRT1021/drivers;../../../../../devices/MIMXRT1021/drivers;../../../../../devices/MIMXRT1021/xip;../../../xip;../../../../../middleware/wifi_qca/port/boards/evkmimxrt1020/freertos;../../../../../middleware/wifi_qca/port/env/freertos;../../../../../middleware/wifi_qca/port/drivers/lpspi_edma_freertos;../../../../../devices/MIMXRT1021/drivers;../../../../../devices/MIMXRT1021/drivers;../../../../../devices/MIMXRT1021/drivers;../../../../../devices/MIMXRT1021/drivers
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../../..;..;../config_files
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1021xxxxx_flexspi_nor_sdram.scf
  link misc: --remove --keep=*(.boot_hdr.ivt) --keep=*(.boot_hdr.boot_data) --keep=*(.boot_hdr.dcd_data) --keep=*(.boot_hdr.conf) --predefine="-D__stack_size__=0x400" --predefine="-D__heap_size__=0x200"
  group source
    ../: aws_clientcredential.h aws_logging_task.h aws_logging_task_dynamic_buffers.c device_configuration.c device_configuration.h aws_shadow_lightbulb_on_off.c main_wifi.c aws_mbedtls_config.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group amazon-freertos-config_files
    ../: FreeRTOSConfig.h
    ../config_files/: aws_demo_config.h aws_mqtt_agent_config.h aws_mqtt_config.h aws_pkcs11_config.h aws_secure_sockets_config.h aws_shadow_config.h aws_wifi_config.h FreeRTOSIPConfig.h
  group amazon-freertos:config_files
    ../config_files/: aws_bufferpool_config.h
  group source-ssl_server
    ../ssl_server/: sslsrv.c sslsrv.h sslsrv_config.h sslsrv_keys.h sslsrv_port_wifi.c sslsrv_port.h sslsrv_prv.h sslsrv_supp.c sslsrv_supp.h sslsrv_task.c sslsrv_tls.c sslsrv_tls.h
  group source-fnet_mdns
    ../fnet_mdns/: fnet_comp.h fnet_mdns.c fnet_mdns.h fnet_mdns_config.h fnet_mdns_port.h fnet_types.h fnet_user_config.h port_wifi.c
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1021/drivers/: fsl_trng.c fsl_trng.h fsl_dcp.c fsl_dcp.h fsl_cache.c fsl_cache.h fsl_flexspi.c fsl_flexspi.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h fsl_gpio.c fsl_gpio.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.c fsl_lpspi_edma.h fsl_edma.c fsl_edma.h fsl_dmamux.c fsl_dmamux.h
  group wifi_qca-port-shields-gt202
    ../../../../../middleware/wifi_qca/port/boards/evkmimxrt1020/freertos/gt202/: wifi_shield_gt202.h
  group amazon-freertos-mflash
    ../../../../../rtos/amazon-freertos/lib/third_party/mcu_vendor/nxp/mflash/mimxrt1021/: mflash_drv.c mflash_drv.h mflash_file.c mflash_file.h
  group amazon-freertos-secure_sockets
    ../../../../../rtos/amazon-freertos/lib/secure_sockets/portable/nxp/wifi_qca/: aws_secure_sockets.c
  group amazon-freertos-wifi_qca_400x
    ../../../../../rtos/amazon-freertos/lib/wifi/portable/nxp/qca_400x/: aws_wifi.c
  group wifi_qca-include
    ../../../../../middleware/wifi_qca/: atheros_stack_offload.h atheros_wifi.h atheros_wifi_api.h atheros_wifi_internal.h qcom_api.h
    ../../../../../middleware/wifi_qca/include/: athdefs.h bmi_msg.h dbglog.h dbglog_id.h htc.h htc_services.h p2p.h pkt_log.h pmu.h targaddrs.h wlan_defs.h wmi.h
  group wifi_qca-common_src-api_interface
    ../../../../../middleware/wifi_qca/common_src/api_interface/: api_init.c api_ioctl.c api_txrx.c api_wmi_rx.c
  group wifi_qca-common_src-bmi
    ../../../../../middleware/wifi_qca/common_src/bmi/: bmi.c
  group wifi_qca-common_src-driver
    ../../../../../middleware/wifi_qca/common_src/driver/: driver_diag.c driver_init.c driver_main.c driver_netbuf.c driver_txrx.c
  group wifi_qca-common_src-hcd
    ../../../../../middleware/wifi_qca/common_src/hcd/: hcd_api.h
  group wifi_qca-common_src-htc
    ../../../../../middleware/wifi_qca/common_src/hcd/: spi_hcd.c
    ../../../../../middleware/wifi_qca/common_src/htc/: htc.c
  group wifi_qca-common_src-hw_interface
    ../../../../../middleware/wifi_qca/common_src/hw_interface/: hw_api.c
  group wifi_qca-common_src-include
    ../../../../../middleware/wifi_qca/common_src/include/: a_debug.h a_drv.h a_drv_api.h aggr_recv_api.h bmi.h common_api.h dbglog_api.h driver_cxt.h dset.h dset_api.h hif_internal.h htc_api.h ieee80211.h netbuf.h spi_hcd_if.h wlan_api.h wmi_api.h
  group wifi_qca-common_src-qapi
    ../../../../../middleware/wifi_qca/common_src/qapi/: qcom_api.c qcom_dns.c qcom_legacy.c
    ../../../../../middleware/wifi_qca/common_src/stack_common/: api_stack_offload.c
  group wifi_qca-common_src-reorder
    ../../../../../middleware/wifi_qca/common_src/reorder/: rcv_aggr.c
  group wifi_qca-common_src-stack_common
    ../../../../../middleware/wifi_qca/common_src/stack_common/: common_stack_offload.h
    ../../../../../middleware/wifi_qca/common_src/storerecall/: dset_api.c
  group wifi_qca-common_src-storerecall
    ../../../../../middleware/wifi_qca/common_src/storerecall/: dset.c storerecall.c
  group wifi_qca-common_src-util
    ../../../../../middleware/wifi_qca/common_src/util/: util.c
  group wifi_qca-common_src-wmi
    ../../../../../middleware/wifi_qca/common_src/wmi/: wmi.c wmi_host.h
  group wifi_qca-custom_src-api_interface
    ../../../../../middleware/wifi_qca/custom_src/api_interface/: cust_api_init.c cust_api_ioctl.c cust_api_txrx.c cust_api_wmi_rx.c
  group wifi_qca-custom_src-driver
    ../../../../../middleware/wifi_qca/custom_src/driver/: cust_driver_main.c cust_driver_netbuf.c
  group wifi_qca-custom_src-hw_interface
    ../../../../../middleware/wifi_qca/custom_src/hw_interface/: cust_spi_hcd.c
  group wifi_qca-custom_src-include
    ../../../../../middleware/wifi_qca/custom_src/include/: a_config.h a_osapi.h a_types.h cust_netbuf.h custom_wlan_api.h wlan_config.h
  group wifi_qca-custom_src-qapi
    ../../../../../middleware/wifi_qca/custom_src/qapi/: custom_qcom_api.c
  group wifi_qca-custom_src-stack_custom
    ../../../../../middleware/wifi_qca/custom_src/stack_custom/: cust_api_stack_offload.c cust_api_stack_txrx.c custom_stack_offload.h qca_structs.h
  group wifi_qca-include-AR6002
    ../../../../../middleware/wifi_qca/include/AR6002/: AR6K_version.h
  group wifi_qca-include-AR6002-hw2.0-hw
    ../../../../../middleware/wifi_qca/include/AR6002/hw2.0/hw/: hw20_apb_map.h hw20_gpio_reg.h hw20_mbox_host_reg.h hw20_mbox_reg.h hw20_rtc_reg.h hw20_si_reg.h hw20_uart_reg.h hw20_vmc_reg.h
  group wifi_qca-include-AR6002-hw4.0-hw
    ../../../../../middleware/wifi_qca/include/AR6002/hw4.0/hw/: hw40_rtc_reg.h hw40_rtc_wlan_reg.h
  group wifi_qca-port
    ../../../../../middleware/wifi_qca/port/: wifi_common.h wifi_shield_common.h
  group amazon-freertos-freertos
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos-freertos-portable
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
  group amazon-freertos-include
    ../../../../../rtos/amazon-freertos/lib/include/: FreeRTOS.h event_groups.h freertos_tasks_c_additions.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
    ../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h stack_macros.h threading_alt.h
  group amazon-freertos-aws_iot
    ../../../../../rtos/amazon-freertos/lib/include/: FreeRTOS.h aws_appversion32.h aws_crypto.h aws_defender.h aws_greengrass_discovery.h aws_mqtt_agent.h aws_mqtt_lib.h aws_ota_agent.h aws_pkcs11.h aws_secure_sockets.h aws_shadow.h aws_system_init.h aws_tls.h aws_wifi.h event_groups.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
    ../../../../../rtos/amazon-freertos/lib/include/private/: aws_bufferpool.h aws_default_root_certificates.h aws_defender_cpu.h aws_defender_internals.h aws_defender_report.h aws_defender_report_cpu.h aws_defender_report_header.h aws_defender_report_tcp_conn.h aws_defender_report_types.h aws_defender_report_uptime.h aws_defender_report_utils.h aws_defender_tcp_conn.h aws_defender_uptime.h aws_doubly_linked_list.h aws_ggd_config_defaults.h aws_helper_secure_connect.h aws_lib_init.h aws_mqtt_agent_config_defaults.h aws_mqtt_buffer.h aws_mqtt_config_defaults.h aws_ota_agent_internal.h aws_ota_cbor.h aws_ota_cbor_internal.h aws_ota_pal.h aws_ota_types.h aws_secure_sockets_config_defaults.h aws_shadow_config_defaults.h aws_shadow_json.h deprecated_definitions.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h stack_macros.h threading_alt.h
  group amazon-freertos-bufferpool
    ../../../../../rtos/amazon-freertos/lib/bufferpool/: aws_bufferpool_static_thread_safe.c
  group amazon-freertos-crypto
    ../../../../../rtos/amazon-freertos/lib/crypto/: aws_crypto.c
  group amazon-freertos-mqtt
    ../../../../../rtos/amazon-freertos/lib/mqtt/: aws_mqtt_agent.c aws_mqtt_lib.c
  group amazon-freertos-pkcs11
    ../../../../../rtos/amazon-freertos/lib/pkcs11/mbedtls/: aws_pkcs11_mbedtls.c
    ../../../../../rtos/amazon-freertos/lib/pkcs11/portable/nxp/common/: aws_pkcs11_pal.c
  group amazon-freertos-shadow
    ../../../../../rtos/amazon-freertos/lib/shadow/: aws_shadow.c aws_shadow_json.c
  group amazon-freertos-tls
    ../../../../../rtos/amazon-freertos/lib/tls/: aws_tls.c
  group amazon-freertos-utils
    ../../../../../rtos/amazon-freertos/lib/utils/: aws_system_init.c
  group amazon-freertos-third_party-jsmn
    ../../../../../rtos/amazon-freertos/lib/third_party/jsmn/: jsmn.c jsmn.h
  group amazon-freertos-third_party-pkcs11
    ../../../../../rtos/amazon-freertos/lib/third_party/pkcs11/: pkcs11.h pkcs11f.h pkcs11t.h
  group mbedtls-mbedtls_include
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls-mbedtls_source
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls-mbedtls_port
    ../../../../../middleware/mbedtls/port/ksdk/: aes_alt.c aes_alt.h des_alt.c des_alt.h ecp_alt.c ecp_alt.h ecp_alt_ksdk.c ecp_curves_alt.c ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h
  group device
    ../../../../../devices/MIMXRT1021/: MIMXRT1021.h MIMXRT1021_features.h fsl_device_registers.h system_MIMXRT1021.c system_MIMXRT1021.h
  group utilities
    ../../../../../devices/MIMXRT1021/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1021/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1021/utilities/: fsl_assert.c
  group component-uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MIMXRT1021/arm/: startup_MIMXRT1021.s
  group xip
    ../../../../../devices/MIMXRT1021/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../xip/: evkmimxrt1020_flexspi_nor_config.c evkmimxrt1020_flexspi_nor_config.h evkmimxrt1020_sdram_ini_dcd.c evkmimxrt1020_sdram_ini_dcd.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h
  group wifi_qca-port-shields
    ../../../../../middleware/wifi_qca/port/boards/evkmimxrt1020/freertos/: wifi_shield.c wifi_shield.h
  group wifi_qca-port-env-freertos
    ../../../../../middleware/wifi_qca/port/env/freertos/: wifi_env.c wifi_env.h wifi_env_port.h wifi_port.h
  group wifi_qca-port-drivers-lpspi_edma_freertos
    ../../../../../middleware/wifi_qca/port/drivers/lpspi_edma_freertos/: wifi_spi.c wifi_spi.h
target aws_device_configuration_wifi flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: aws_device_configuration_wifi.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, NDEBUG, FNET_CFG_COMP_UV=1, CPU_MIMXRT1021DAG5A, USE_RTOS=1, MBEDTLS_CONFIG_FILE='\"aws_mbedtls_config.h\"', FNET_PORT_WIFI_QCA=1, A_LITTLE_ENDIAN, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../../..;..;../config_files
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1021xxxxx_flexspi_nor_sdram.scf
  link misc: as above
