<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>aws_greengrass_discovery_wifi</project>
        <configuration>flexspi_nor_sdram_debug</configuration>
      </member>
      <member>
        <project>aws_greengrass_discovery_wifi</project>
        <configuration>flexspi_nor_sdram_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_sdram_debug</name>
      <member>
        <project>aws_greengrass_discovery_wifi</project>
        <configuration>flexspi_nor_sdram_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_sdram_release</name>
      <member>
        <project>aws_greengrass_discovery_wifi</project>
        <configuration>flexspi_nor_sdram_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/aws_greengrass_discovery_wifi.ewp</path>
  </project>
</workspace>
