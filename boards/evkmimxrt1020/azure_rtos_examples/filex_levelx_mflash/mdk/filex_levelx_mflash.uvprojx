# Keil uVision project filex_levelx_mflash.uvprojx, settings and files
target filex_levelx_mflash debug (ARM-ADS)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: filex_levelx_mflash.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, __CLANG_ARM, CPU_MIMXRT1021DAG5A, LX_USE_MFLASH, DEMO_DISK_FLASH_OFFSET=MFLASH_FILE_BASEADDR, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, SAMPLE_PACKET_COUNT=20, DATA_SECTION_IS_CACHEABLE=1, MCUXPRESSO_SDK, LX_THREAD_SAFE_ENABLE, MFLASH_FILE_BASEADDR=5767168, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE, FSL_RTOS_THREADX
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../rtos/azure-rtos/levelx/common/inc;../../../../../components/flash/mflash/mimxrt1021;../../../../../devices/MIMXRT1021/drivers;../../../../../devices/MIMXRT1021;../../../../../devices/MIMXRT1021/utilities/str;../../../../../devices/MIMXRT1021/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../devices/MIMXRT1021/xip;../../../xip;../../../../../rtos/azure-rtos/filex/common/inc;../../../../../rtos/azure-rtos/filex/ports/generic/inc;../../../../../rtos/azure-rtos/threadx/common/inc;../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc;../../../../../components/flash/mflash;../../../../../CMSIS/Core/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1021xxxxx_ram.scf
  link misc: ../../../../../rtos/azure-rtos/binary/filex/cortex_m7/mdk/libfilex.lib ../../../../../rtos/azure-rtos/binary/threadx/cortex_m7/mdk/libthreadx.lib --remove --entry=Reset_Handler --diag_suppress 6314
  group board
    ../: pin_mux.c pin_mux.h board_setup.c board_setup.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group source
    ../: filex_levelx_mflash.c lx_mflash_driver.c fx_levelx_driver.c fx_levelx_driver.h
  group azure-rtos/config
    ../: tx_user.h fx_user.h
  group doc
    ../: readme.txt
  group azure-rtos/levelx/common/inc
    ../../../../../rtos/azure-rtos/levelx/common/inc/: lx_api.h lx_user_sample.h
  group azure-rtos/levelx/common/src
    ../../../../../rtos/azure-rtos/levelx/common/src/: fx_nand_flash_simulated_driver.c fx_nor_flash_simulator_driver.c lx_nand_flash_256byte_ecc_check.c lx_nand_flash_256byte_ecc_compute.c lx_nand_flash_block_full_update.c lx_nand_flash_block_obsoleted_check.c lx_nand_flash_block_reclaim.c lx_nand_flash_close.c lx_nand_flash_defragment.c lx_nand_flash_driver_block_erase.c lx_nand_flash_driver_block_erased_verify.c lx_nand_flash_driver_block_status_get.c lx_nand_flash_driver_block_status_set.c lx_nand_flash_driver_extra_bytes_get.c lx_nand_flash_driver_extra_bytes_set.c lx_nand_flash_driver_page_erased_verify.c lx_nand_flash_driver_read.c lx_nand_flash_driver_write.c lx_nand_flash_extended_cache_enable.c lx_nand_flash_initialize.c lx_nand_flash_logical_sector_find.c lx_nand_flash_next_block_to_erase_find.c lx_nand_flash_open.c lx_nand_flash_page_ecc_check.c lx_nand_flash_page_ecc_compute.c lx_nand_flash_partial_defragment.c lx_nand_flash_physical_page_allocate.c lx_nand_flash_sector_mapping_cache_invalidate.c lx_nand_flash_sector_read.c lx_nand_flash_sector_release.c lx_nand_flash_sector_write.c lx_nand_flash_simulator.c lx_nand_flash_system_error.c lx_nor_flash_block_reclaim.c lx_nor_flash_close.c lx_nor_flash_defragment.c lx_nor_flash_driver_block_erase.c lx_nor_flash_driver_read.c lx_nor_flash_driver_write.c lx_nor_flash_extended_cache_enable.c lx_nor_flash_initialize.c lx_nor_flash_logical_sector_find.c lx_nor_flash_next_block_to_erase_find.c lx_nor_flash_open.c lx_nor_flash_partial_defragment.c lx_nor_flash_physical_sector_allocate.c lx_nor_flash_sector_mapping_cache_invalidate.c lx_nor_flash_sector_read.c lx_nor_flash_sector_release.c lx_nor_flash_sector_write.c lx_nor_flash_simulator.c lx_nor_flash_system_error.c
  group flash/mflash/mimxrt1021
    ../../../../../components/flash/mflash/mimxrt1021/: mflash_drv.h mflash_drv.c
  group drivers
    ../../../../../devices/MIMXRT1021/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h
  group device
    ../../../../../devices/MIMXRT1021/: fsl_device_registers.h MIMXRT1021.h MIMXRT1021_features.h system_MIMXRT1021.c system_MIMXRT1021.h
  group utilities
    ../../../../../devices/MIMXRT1021/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1021/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1021/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1021/arm/: startup_MIMXRT1021.S
  group xip
    ../../../../../devices/MIMXRT1021/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1020_flexspi_nor_config.c evkmimxrt1020_flexspi_nor_config.h
  group azure-rtos/filex/common/inc
    ../../../../../rtos/azure-rtos/filex/common/inc/: fx_api.h fx_directory.h fx_directory_exFAT.h fx_fault_tolerant.h fx_file.h fx_media.h fx_system.h fx_unicode.h fx_user_sample.h fx_utility.h
  group azure-rtos/filex/ports/generic/inc
    ../../../../../rtos/azure-rtos/filex/ports/generic/inc/: fx_port.h
  group azure-rtos/threadx/common/inc
    ../../../../../rtos/azure-rtos/threadx/common/inc/: tx_api.h tx_block_pool.h tx_byte_pool.h tx_event_flags.h tx_initialize.h tx_mutex.h tx_queue.h tx_semaphore.h tx_thread.h tx_timer.h tx_trace.h tx_user_sample.h
  group azure-rtos/threadx/ports/common
    ../../../../../rtos/azure-rtos/threadx/ports/common/: tx_initialize_low_level.c
  group azure-rtos/threadx/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc/: tx_port.h
  group azure-rtos/threadx/ports/cortex_m7/ac6/src
    ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/src/: tx_thread_context_restore.S tx_thread_context_save.S tx_thread_interrupt_control.S tx_thread_interrupt_disable.S tx_thread_interrupt_restore.S tx_thread_schedule.S tx_thread_stack_build.S tx_thread_system_return.S tx_timer_interrupt.S
  group flash/mflash
    ../../../../../components/flash/mflash/: mflash_common.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
target filex_levelx_mflash flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: filex_levelx_mflash.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, __CLANG_ARM, CPU_MIMXRT1021DAG5A, LX_USE_MFLASH, DEMO_DISK_FLASH_OFFSET=MFLASH_FILE_BASEADDR, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, SAMPLE_PACKET_COUNT=20, DATA_SECTION_IS_CACHEABLE=1, MCUXPRESSO_SDK, LX_THREAD_SAFE_ENABLE, MFLASH_FILE_BASEADDR=5767168, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE, FSL_RTOS_THREADX
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1021xxxxx_flexspi_nor.scf
  link misc: ../../../../../rtos/azure-rtos/binary/filex/cortex_m7/mdk/libfilex.lib ../../../../../rtos/azure-rtos/binary/threadx/cortex_m7/mdk/libthreadx.lib --remove --entry=Reset_Handler --diag_suppress 6314 --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
target filex_levelx_mflash release (ARM-ADS)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: filex_levelx_mflash.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, __CLANG_ARM, CPU_MIMXRT1021DAG5A, LX_USE_MFLASH, DEMO_DISK_FLASH_OFFSET=MFLASH_FILE_BASEADDR, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, SAMPLE_PACKET_COUNT=20, DATA_SECTION_IS_CACHEABLE=1, MCUXPRESSO_SDK, LX_THREAD_SAFE_ENABLE, MFLASH_FILE_BASEADDR=5767168, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE, FSL_RTOS_THREADX
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1021xxxxx_ram.scf
  link misc: as above
target filex_levelx_mflash flexspi_nor_release (ARM-ADS)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: filex_levelx_mflash.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, __CLANG_ARM, CPU_MIMXRT1021DAG5A, LX_USE_MFLASH, DEMO_DISK_FLASH_OFFSET=MFLASH_FILE_BASEADDR, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, SAMPLE_PACKET_COUNT=20, DATA_SECTION_IS_CACHEABLE=1, MCUXPRESSO_SDK, LX_THREAD_SAFE_ENABLE, MFLASH_FILE_BASEADDR=5767168, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE, FSL_RTOS_THREADX
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1021xxxxx_flexspi_nor.scf
  link misc: as above
