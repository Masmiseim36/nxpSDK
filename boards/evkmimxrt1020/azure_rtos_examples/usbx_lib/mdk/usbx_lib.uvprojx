# Keil uVision project usbx_lib.uvprojx, settings and files
target usbx_lib Debug (ARM-ADS)
  device: MIMXRT1021DAG5A NXP
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: libusbx.lib (library)
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: DEBUG, CPU_MIMXRT1021DAG5A, MIMXRT, UX_OTG_SUPPORT, TX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, UX_INCLUDE_USER_DEFINE_FILE
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../rtos/azure-rtos/binary/threadx;../../../../../rtos/azure-rtos/binary/filex;../../../../../rtos/azure-rtos/binary/usbx;../../../../../rtos/azure-rtos/threadx/common/inc;../../../../../rtos/azure-rtos/filex/common/inc;../../../../../rtos/azure-rtos/netxduo/addons/auto_ip;../../../../../rtos/azure-rtos/netxduo/addons/BSD;../../../../../rtos/azure-rtos/netxduo/addons/dhcp;../../../../../rtos/azure-rtos/netxduo/addons/dns;../../../../../rtos/azure-rtos/netxduo/addons/ftp;../../../../../rtos/azure-rtos/netxduo/addons/http;../../../../../rtos/azure-rtos/netxduo/addons/mdns;../../../../../rtos/azure-rtos/netxduo/addons/mqtt;../../../../../rtos/azure-rtos/netxduo/addons/nat;../../../../../rtos/azure-rtos/netxduo/addons/pop3;../../../../../rtos/azure-rtos/netxduo/addons/ppp;../../../../../rtos/azure-rtos/netxduo/addons/pppoe;../../../../../rtos/azure-rtos/netxduo/addons/smtp;../../../../../rtos/azure-rtos/netxduo/addons/snmp;../../../../../rtos/azure-rtos/netxduo/addons/sntp;../../../../../rtos/azure-rtos/netxduo/addons/telnet;../../../../../rtos/azure-rtos/netxduo/addons/tftp;../../../../../rtos/azure-rtos/netxduo/addons/web;../../../../../rtos/azure-rtos/netxduo/common/inc;../../../../../rtos/azure-rtos/netxduo/crypto_libraries/inc;../../../../../rtos/azure-rtos/netxduo/nx_secure/inc;../../../../../rtos/azure-rtos/netxduo/nx_secure/ports;../../../../../rtos/azure-rtos/usbx/common/core/inc;../../../../../rtos/azure-rtos/usbx/common/usbx_device_classes/inc;../../../../../rtos/azure-rtos/usbx/common/usbx_host_classes/inc;../../../../../rtos/azure-rtos/usbx/common/usbx_host_controllers/inc;../../../../../rtos/azure-rtos/usbx/common/usbx_network/inc;../../../../../rtos/azure-rtos/usbx/common/usbx_pictbridge/inc;../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc;../../../../../rtos/azure-rtos/filex/ports/cortex_m7/ac6/inc;../../../../../rtos/azure-rtos/netxduo/ports/cortex_m7/ac6/inc;../../../../../rtos/azure-rtos/usbx/ports/cortex_m7/ac6/inc
  asm define: DEBUG, DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group doc
    ../: readme.txt
  group azure-rtos/user
    ../../../../../rtos/azure-rtos/binary/threadx/: tx_user.h
    ../../../../../rtos/azure-rtos/binary/filex/: fx_user.h
    ../../../../../rtos/azure-rtos/binary/usbx/: ux_user.h
  group azure-rtos/threadx/common/inc
    ../../../../../rtos/azure-rtos/threadx/common/inc/: tx_byte_pool.h tx_event_flags.h tx_timer.h tx_queue.h tx_thread.h tx_mutex.h tx_trace.h tx_initialize.h tx_api.h tx_user_sample.h tx_block_pool.h tx_semaphore.h
  group azure-rtos/filex/common/inc
    ../../../../../rtos/azure-rtos/filex/common/inc/: fx_media.h fx_unicode.h fx_api.h fx_directory_exFAT.h fx_utility.h fx_file.h fx_system.h fx_directory.h fx_user_sample.h fx_fault_tolerant.h
  group azure-rtos/netxduo/addons/auto_ip
    ../../../../../rtos/azure-rtos/netxduo/addons/auto_ip/: nx_auto_ip.h
  group azure-rtos/netxduo/addons/BSD
    ../../../../../rtos/azure-rtos/netxduo/addons/BSD/: nxd_bsd.h
  group azure-rtos/netxduo/addons/dhcp
    ../../../../../rtos/azure-rtos/netxduo/addons/dhcp/: nxd_dhcp_server.h nxd_dhcpv6_server.h nxd_dhcpv6_client.h nxd_dhcp_client.h
  group azure-rtos/netxduo/addons/dns
    ../../../../../rtos/azure-rtos/netxduo/addons/dns/: nxd_dns.h
  group azure-rtos/netxduo/addons/ftp
    ../../../../../rtos/azure-rtos/netxduo/addons/ftp/: nxd_ftp_client.h nxd_ftp_server.h
  group azure-rtos/netxduo/addons/http
    ../../../../../rtos/azure-rtos/netxduo/addons/http/: nxd_http_server.h nxd_http_client.h
  group azure-rtos/netxduo/addons/mdns
    ../../../../../rtos/azure-rtos/netxduo/addons/mdns/: nxd_mdns.h
  group azure-rtos/netxduo/addons/mqtt
    ../../../../../rtos/azure-rtos/netxduo/addons/mqtt/: nxd_mqtt_client.h
  group azure-rtos/netxduo/addons/nat
    ../../../../../rtos/azure-rtos/netxduo/addons/nat/: nx_nat.h
  group azure-rtos/netxduo/addons/pop3
    ../../../../../rtos/azure-rtos/netxduo/addons/pop3/: nxd_pop3_client.h
  group azure-rtos/netxduo/addons/ppp
    ../../../../../rtos/azure-rtos/netxduo/addons/ppp/: nx_ppp.h
  group azure-rtos/netxduo/addons/pppoe
    ../../../../../rtos/azure-rtos/netxduo/addons/pppoe/: nx_pppoe_server.h nx_pppoe_client.h
  group azure-rtos/netxduo/addons/smtp
    ../../../../../rtos/azure-rtos/netxduo/addons/smtp/: nxd_smtp_client.h
  group azure-rtos/netxduo/addons/snmp
    ../../../../../rtos/azure-rtos/netxduo/addons/snmp/: nxd_snmp.h nx_des.h nx_sha1.h
  group azure-rtos/netxduo/addons/sntp
    ../../../../../rtos/azure-rtos/netxduo/addons/sntp/: nxd_sntp_client.h
  group azure-rtos/netxduo/addons/telnet
    ../../../../../rtos/azure-rtos/netxduo/addons/telnet/: nxd_telnet_server.h nxd_telnet_client.h
  group azure-rtos/netxduo/addons/tftp
    ../../../../../rtos/azure-rtos/netxduo/addons/tftp/: nxd_tftp_server.h nxd_tftp_client.h
  group azure-rtos/netxduo/addons/web
    ../../../../../rtos/azure-rtos/netxduo/addons/web/: nx_web_http_server.h nx_tcpserver.h nx_web_http_common.h nx_web_http_client.h
  group azure-rtos/netxduo/common/inc
    ../../../../../rtos/azure-rtos/netxduo/common/inc/: nx_igmp.h nx_ipv4.h nx_packet.h nx_nd_cache.h nx_md5.h nx_icmpv6.h nx_icmp.h nx_user_sample.h nx_tcp.h nx_icmpv4.h nx_arp.h nx_ipv6.h nx_system.h nx_api.h nx_rarp.h nx_mld.h nx_ip.h nx_udp.h
  group azure-rtos/netxduo/crypto_libraries/inc
    ../../../../../rtos/azure-rtos/netxduo/crypto_libraries/inc/: nx_crypto_sha1.h nx_crypto_hmac_md5.h nx_crypto_xcbc_mac.h nx_crypto_hmac.h nx_crypto_ccm.h nx_crypto_dh.h nx_crypto_tls_prf_1.h nx_crypto_const.h nx_crypto_cbc.h nx_crypto_ec.h nx_crypto_md5.h nx_crypto_tls_prf_sha384.h nx_crypto.h nx_crypto_sha5.h nx_crypto_rsa.h nx_crypto_ecdh.h nx_crypto_ecdsa.h nx_crypto_hmac_sha2.h nx_crypto_3des.h nx_crypto_null.h nx_crypto_drbg.h nx_crypto_phash.h nx_crypto_hmac_sha1.h nx_crypto_gcm.h nx_crypto_tls_prf_sha256.h nx_crypto_sha2.h nx_crypto_pkcs1_v1.5.h nx_crypto_tls_prf_sha512.h nx_crypto_huge_number.h nx_crypto_hmac_sha5.h nx_crypto_ecjpake.h nx_crypto_des.h nx_crypto_ctr.h nx_crypto_aes.h nx_crypto_method_self_test.h nx_crypto_hkdf.h
  group azure-rtos/netxduo/nx_secure/inc
    ../../../../../rtos/azure-rtos/netxduo/nx_secure/inc/: nx_secure_tls_api.h nx_secure_dtls_api.h nx_secure_user_sample.h nx_secure_x509.h nx_secure_dtls.h nx_secure_crypto_table_self_test.h nx_secure_tls.h
  group azure-rtos/netxduo/nx_secure/ports
    ../../../../../rtos/azure-rtos/netxduo/nx_secure/ports/: nx_secure_port.h
  group azure-rtos/source
    ../../../../../rtos/azure-rtos/usbx/common/core/inc/: ux_host_class_dpump.h ux_device_class_dpump.h ux_utility.h ux_hcd_sim_host.h ux_dcd_sim_slave.h ux_device_stack.h ux_host_stack.h ux_system.h ux_api.h ux_user_sample.h
    ../../../../../rtos/azure-rtos/usbx/common/core/src/: ux_source.c
  group azure-rtos/usbx_device_classes
    ../../../../../rtos/azure-rtos/usbx/common/usbx_device_classes/inc/: ux_device_class_rndis.h ux_device_class_storage.h ux_device_class_audio.h ux_device_class_cdc_ecm.h ux_device_class_pima.h ux_device_class_cdc_acm.h ux_device_class_audio20.h ux_device_class_audio10.h ux_device_class_hid.h ux_device_class_dfu.h
    ../../../../../rtos/azure-rtos/usbx/common/usbx_device_classes/src/: ux_device_class_rndis_initialize.c ux_device_class_hid_activate.c ux_device_class_cdc_ecm_entry.c ux_device_class_pima_deactivate.c ux_device_class_audio_sample_read32.c ux_device_class_storage_read.c ux_device_class_audio20_control_process.c ux_device_class_rndis_bulkin_thread.c ux_device_class_cdc_ecm_control_request.c ux_device_class_dfu_control_request.c ux_device_class_storage_get_performance.c ux_device_class_audio_unitialize.c ux_device_class_storage_report_key.c ux_device_class_audio_sample_read8.c ux_device_class_dfu_entry.c ux_device_class_storage_entry.c ux_device_class_storage_initialize.c ux_device_class_audio_deactivate.c ux_device_class_pima_object_handles_send.c ux_device_class_pima_device_prop_value_set.c ux_device_class_rndis_control_request.c ux_device_class_storage_read_dvd_structure.c ux_device_class_audio_sample_read24.c ux_device_class_audio_entry.c ux_device_class_cdc_acm_deactivate.c ux_device_class_storage_prevent_allow_media_removal.c ux_device_class_pima_object_info_send.c ux_device_class_pima_objects_number_send.c ux_device_class_pima_thread.c ux_device_class_cdc_ecm_bulkin_thread.c ux_device_class_storage_mode_select.c ux_device_class_pima_object_references_set.c ux_device_class_dfu_deactivate.c ux_device_class_pima_partial_object_data_get.c ux_device_class_storage_csw_send.c ux_device_class_audio_write_thread_entry.c ux_device_class_pima_event_set.c ux_device_class_storage_thread.c ux_device_class_pima_object_data_send.c ux_device_class_cdc_ecm_change.c ux_device_class_audio_stream_get.c ux_device_class_hid_event_set.c ux_device_class_storage_read_capacity.c ux_device_class_pima_interrupt_thread.c ux_device_class_cdc_acm_write.c ux_device_class_pima_device_prop_value_get.c ux_device_class_cdc_acm_bulkin_thread.c ux_device_class_pima_data.c ux_device_class_storage_control_request.c ux_device_class_cdc_ecm_activate.c ux_device_class_storage_format.c ux_device_class_audio_ioctl.c ux_device_class_audio_read_thread_entry.c ux_device_class_hid_control_request.c ux_device_class_pima_object_prop_desc_get.c ux_device_class_cdc_ecm_initialize.c ux_device_class_rndis_msg_set.c ux_device_class_storage_deactivate.c ux_device_class_cdc_acm_ioctl.c ux_device_class_pima_control_request.c ux_device_class_storage_uninitialize.c ux_device_class_cdc_ecm_bulkout_thread.c ux_device_class_pima_object_references_get.c ux_device_class_cdc_acm_activate.c ux_device_class_pima_object_props_supported_get.c ux_device_class_cdc_ecm_write.c ux_device_class_rndis_write.c ux_device_class_storage_get_status_notification.c ux_device_class_pima_device_info_send.c ux_device_class_hid_report_get.c ux_device_class_pima_activate.c ux_device_class_storage_read_format_capacity.c ux_device_class_storage_read_toc.c ux_device_class_rndis_bulkout_thread.c ux_device_class_rndis_msg_initialize.c ux_device_class_pima_device_prop_desc_get.c ux_device_class_audio_read_frame_get.c ux_device_class_cdc_acm_initialize.c ux_device_class_pima_device_reset.c ux_device_class_pima_initialize.c ux_device_class_hid_uninitialize.c ux_device_class_pima_event_get.c ux_device_class_pima_object_delete.c ux_device_class_cdc_acm_control_request.c ux_device_class_storage_start_stop.c ux_device_class_cdc_ecm_uninitialize.c ux_device_class_cdc_acm_write_with_callback.c ux_device_class_storage_request_sense.c ux_device_class_pima_object_info_get.c ux_device_class_cdc_acm_entry.c ux_device_class_hid_entry.c ux_device_class_rndis_activate.c ux_device_class_storage_mode_sense.c ux_device_class_audio_transmission_start.c ux_device_class_audio_control_request.c ux_device_class_cdc_ecm_interrupt_thread.c ux_device_class_cdc_acm_unitialize.c ux_device_class_dfu_thread.c ux_device_class_pima_object_add.c ux_device_class_pima_object_prop_value_get.c ux_device_class_cdc_ecm_deactivate.c ux_device_class_audio_activate.c ux_device_class_audio10_control_process.c ux_device_class_storage_synchronize_cache.c ux_device_class_dfu_activate.c ux_device_class_pima_storage_format.c ux_device_class_storage_inquiry.c ux_device_class_storage_read_disk_information.c ux_device_class_storage_verify.c ux_device_class_hid_interrupt_thread.c ux_device_class_rndis_msg_keep_alive.c ux_device_class_pima_storage_info_get.c ux_device_class_cdc_acm_read.c ux_device_class_pima_entry.c ux_device_class_rndis_msg_query.c ux_device_class_dfu_initialize.c ux_device_class_cdc_acm_bulkout_thread.c ux_device_class_pima_response_send.c ux_device_class_rndis_entry.c ux_device_class_audio_read_frame_free.c ux_device_class_hid_initialize.c ux_device_class_audio_reception_start.c ux_device_class_rndis_msg_reset.c ux_device_class_storage_activate.c ux_device_class_storage_test_ready.c ux_device_class_storage_get_configuration.c ux_device_class_audio_change.c ux_device_class_audio_write_frame_get.c ux_device_class_audio_initialize.c ux_device_class_rndis_deactivate.c ux_device_class_storage_write.c ux_device_class_hid_descriptor_send.c ux_device_class_audio_write_frame_commit.c ux_device_class_pima_object_data_get.c ux_device_class_rndis_interrupt_thread.c ux_device_class_hid_event_get.c ux_device_class_audio_sample_read16.c ux_device_class_hid_deactivate.c ux_device_class_pima_storage_id_send.c ux_device_class_hid_report_set.c ux_device_class_audio_frame_write.c ux_device_class_pima_object_prop_value_set.c
  group azure-rtos/usbx_host_classes
    ../../../../../rtos/azure-rtos/usbx/common/usbx_host_classes/inc/: ux_host_class_pima.h ux_host_class_cdc_acm.h ux_host_class_hub.h ux_host_class_cdc_ecm.h ux_host_class_hid_keyboard.h ux_host_class_audio.h ux_host_class_hid.h ux_host_class_hid_mouse.h ux_host_class_printer.h ux_host_class_swar.h ux_host_class_asix.h ux_host_class_video.h ux_host_class_prolific.h ux_host_class_gser.h ux_host_class_storage.h ux_host_class_hid_remote_control.h
    ../../../../../rtos/azure-rtos/usbx/common/usbx_host_classes/src/: ux_host_class_cdc_acm_reception_start.c ux_host_class_cdc_acm_reception_stop.c ux_host_class_cdc_acm_transfer_request_completed.c ux_host_class_cdc_acm_write.c ux_host_class_cdc_ecm_activate.c ux_host_class_cdc_ecm_deactivate.c ux_host_class_cdc_ecm_endpoints_get.c ux_host_class_cdc_ecm_entry.c ux_host_class_cdc_ecm_interrupt_notification.c ux_host_class_cdc_ecm_mac_address_get.c ux_host_class_cdc_ecm_thread.c ux_host_class_cdc_ecm_transmission_callback.c ux_host_class_cdc_ecm_transmit_queue_clean.c ux_host_class_cdc_ecm_write.c ux_host_class_gser_activate.c ux_host_class_gser_command.c ux_host_class_gser_configure.c ux_host_class_gser_deactivate.c ux_host_class_gser_endpoints_get.c ux_host_class_gser_entry.c ux_host_class_gser_ioctl.c ux_host_class_gser_read.c ux_host_class_gser_reception_callback.c ux_host_class_gser_reception_start.c ux_host_class_gser_reception_stop.c ux_host_class_gser_write.c ux_host_class_hid_activate.c ux_host_class_hid_client_register.c ux_host_class_hid_client_search.c ux_host_class_hid_configure.c ux_host_class_hid_deactivate.c ux_host_class_hid_descriptor_parse.c ux_host_class_hid_entry.c ux_host_class_hid_field_decompress.c ux_host_class_hid_global_item_parse.c ux_host_class_hid_idle_get.c ux_host_class_hid_idle_set.c ux_host_class_hid_instance_clean.c ux_host_class_hid_interrupt_endpoint_search.c ux_host_class_hid_item_data_get.c ux_host_class_hid_keyboard_activate.c ux_host_class_hid_keyboard_callback.c ux_host_class_hid_keyboard_deactivate.c ux_host_class_hid_keyboard_entry.c ux_host_class_hid_keyboard_ioctl.c ux_host_class_hid_keyboard_key_get.c ux_host_class_hid_keyboard_thread.c ux_host_class_hid_local_item_parse.c ux_host_class_hid_main_item_parse.c ux_host_class_hid_mouse_activate.c ux_host_class_hid_mouse_buttons_get.c ux_host_class_hid_mouse_callback.c ux_host_class_hid_mouse_deactivate.c ux_host_class_hid_mouse_entry.c ux_host_class_hid_mouse_position_get.c ux_host_class_hid_mouse_wheel_get.c ux_host_class_hid_periodic_report_start.c ux_host_class_hid_periodic_report_stop.c ux_host_class_hid_remote_control_activate.c ux_host_class_hid_remote_control_callback.c ux_host_class_hid_remote_control_deactivate.c ux_host_class_hid_remote_control_entry.c ux_host_class_hid_remote_control_usage_get.c ux_host_class_hid_report_add.c ux_host_class_hid_report_callback_register.c ux_host_class_hid_report_compress.c ux_host_class_hid_report_decompress.c ux_host_class_hid_report_descriptor_get.c ux_host_class_hid_report_get.c ux_host_class_hid_report_id_get.c ux_host_class_hid_report_item_analyse.c ux_host_class_hid_report_set.c ux_host_class_hid_resources_free.c ux_host_class_hid_transfer_request_completed.c ux_host_class_hub_activate.c ux_host_class_hub_change_detect.c ux_host_class_hub_change_process.c ux_host_class_hub_configure.c ux_host_class_hub_deactivate.c ux_host_class_hub_descriptor_get.c ux_host_class_hub_entry.c ux_host_class_hub_feature.c ux_host_class_hub_hub_change_process.c ux_host_class_hub_interrupt_endpoint_start.c ux_host_class_hub_port_change_connection_process.c ux_host_class_hub_port_change_enable_process.c ux_host_class_hub_port_change_over_current_process.c ux_host_class_hub_port_change_process.c ux_host_class_hub_port_change_reset_process.c ux_host_class_hub_port_change_suspend_process.c ux_host_class_hub_port_reset.c ux_host_class_hub_ports_power.c ux_host_class_hub_status_get.c ux_host_class_hub_transfer_request_completed.c ux_host_class_pima_activate.c ux_host_class_pima_command.c ux_host_class_pima_configure.c ux_host_class_pima_deactivate.c ux_host_class_pima_device_info_get.c ux_host_class_pima_device_reset.c ux_host_class_pima_endpoints_get.c ux_host_class_pima_entry.c ux_host_class_pima_notification.c ux_host_class_pima_num_objects_get.c ux_host_class_pima_object_close.c ux_host_class_pima_object_copy.c ux_host_class_pima_object_delete.c ux_host_class_pima_object_get.c ux_host_class_pima_object_handles_get.c ux_host_class_pima_object_info_get.c ux_host_class_pima_object_info_send.c ux_host_class_pima_object_move.c ux_host_class_pima_object_open.c ux_host_class_pima_object_send.c ux_host_class_pima_object_transfer_abort.c ux_host_class_pima_read.c ux_host_class_pima_request_cancel.c ux_host_class_pima_session_close.c ux_host_class_pima_session_open.c ux_host_class_pima_storage_ids_get.c ux_host_class_pima_storage_info_get.c ux_host_class_pima_thumb_get.c ux_host_class_pima_write.c ux_host_class_printer_activate.c ux_host_class_printer_configure.c ux_host_class_printer_deactivate.c ux_host_class_printer_endpoints_get.c ux_host_class_printer_entry.c ux_host_class_printer_name_get.c ux_host_class_printer_read.c ux_host_class_printer_soft_reset.c ux_host_class_printer_status_get.c ux_host_class_printer_write.c ux_host_class_prolific_activate.c ux_host_class_prolific_command.c ux_host_class_prolific_configure.c ux_host_class_prolific_deactivate.c ux_host_class_prolific_endpoints_get.c ux_host_class_prolific_entry.c ux_host_class_prolific_ioctl.c ux_host_class_prolific_read.c ux_host_class_prolific_reception_callback.c ux_host_class_prolific_reception_start.c ux_host_class_prolific_reception_stop.c ux_host_class_prolific_setup.c ux_host_class_prolific_transfer_request_completed.c ux_host_class_prolific_write.c ux_host_class_storage_activate.c ux_host_class_storage_cbw_initialize.c ux_host_class_storage_configure.c ux_host_class_storage_deactivate.c ux_host_class_storage_device_initialize.c ux_host_class_storage_device_reset.c ux_host_class_storage_device_support_check.c ux_host_class_storage_driver_entry.c ux_host_class_storage_endpoints_get.c ux_host_class_storage_entry.c ux_host_class_storage_max_lun_get.c ux_host_class_storage_media_capacity_get.c ux_host_class_storage_media_characteristics_get.c ux_host_class_storage_media_format_capacity_get.c ux_host_class_storage_media_mount.c ux_host_class_storage_media_open.c ux_host_class_storage_media_protection_check.c ux_host_class_storage_media_read.c ux_host_class_storage_media_recovery_sense_get.c ux_host_class_storage_media_write.c ux_host_class_storage_partition_read.c ux_host_class_storage_request_sense.c ux_host_class_storage_sense_code_translate.c ux_host_class_storage_start_stop.c ux_host_class_storage_thread_entry.c ux_host_class_storage_transport_bo.c ux_host_class_storage_transport.c ux_host_class_storage_transport_cb.c ux_host_class_storage_transport_cbi.c ux_host_class_storage_unit_ready_test.c ux_host_class_storage_media_get.c ux_host_class_storage_media_lock.c ux_host_class_video_control_request.c ux_host_class_video_entities_parse.c
  group azure-rtos/usbx_host_controllers
    ../../../../../rtos/azure-rtos/usbx/common/usbx_host_controllers/inc/: ux_hcd_ehci.h
    ../../../../../rtos/azure-rtos/usbx/common/usbx_host_controllers/src/: ux_hcd_ehci_asynchronous_endpoint_create.c ux_hcd_ehci_asynchronous_endpoint_destroy.c ux_hcd_ehci_asynch_td_process.c ux_hcd_ehci_controller_disable.c ux_hcd_ehci_done_queue_process.c ux_hcd_ehci_door_bell_wait.c ux_hcd_ehci_ed_clean.c ux_hcd_ehci_ed_obtain.c ux_hcd_ehci_endpoint_reset.c ux_hcd_ehci_entry.c ux_hcd_ehci_frame_number_get.c ux_hcd_ehci_frame_number_set.c ux_hcd_ehci_fsisochronous_td_obtain.c ux_hcd_ehci_fsisochronous_tds_process.c ux_hcd_ehci_hsisochronous_td_obtain.c ux_hcd_ehci_hsisochronous_tds_process.c ux_hcd_ehci_initialize.c ux_hcd_ehci_interrupt_endpoint_create.c ux_hcd_ehci_interrupt_endpoint_destroy.c ux_hcd_ehci_interrupt_handler.c ux_hcd_ehci_isochronous_endpoint_create.c ux_hcd_ehci_isochronous_endpoint_destroy.c ux_hcd_ehci_least_traffic_list_get.c ux_hcd_ehci_next_td_clean.c ux_hcd_ehci_periodic_descriptor_link.c ux_hcd_ehci_periodic_tree_create.c ux_hcd_ehci_poll_rate_entry_get.c ux_hcd_ehci_port_disable.c ux_hcd_ehci_port_reset.c ux_hcd_ehci_port_resume.c ux_hcd_ehci_port_status_get.c ux_hcd_ehci_port_suspend.c ux_hcd_ehci_power_down_port.c ux_hcd_ehci_power_on_port.c ux_hcd_ehci_power_root_hubs.c ux_hcd_ehci_register_read.c ux_hcd_ehci_register_write.c ux_hcd_ehci_regular_td_obtain.c ux_hcd_ehci_request_bulk_transfer.c ux_hcd_ehci_request_control_transfer.c ux_hcd_ehci_request_interrupt_transfer.c ux_hcd_ehci_request_isochronous_transfer.c ux_hcd_ehci_request_transfer_add.c ux_hcd_ehci_request_transfer.c ux_hcd_ehci_transfer_abort.c ux_hcd_ehci_transfer_request_process.c
  group azure-rtos/usbx_network
    ../../../../../rtos/azure-rtos/usbx/common/usbx_network/inc/: ux_network_driver.h
    ../../../../../rtos/azure-rtos/usbx/common/usbx_network/src/: ux_network_driver.c
  group azure-rtos/threadx/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc/: tx_port.h
  group azure-rtos/filex/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/filex/ports/cortex_m7/ac6/inc/: fx_port.h
  group azure-rtos/netxduo/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/netxduo/ports/cortex_m7/ac6/inc/: nx_port.h
  group azure-rtos/usbx/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/usbx/ports/cortex_m7/ac6/inc/: ux_port.h
target usbx_lib Release (ARM-ADS)
  device: MIMXRT1021DAG5A NXP
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: libusbx.lib (library)
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1021DAG5A, MIMXRT, UX_OTG_SUPPORT, TX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, UX_INCLUDE_USER_DEFINE_FILE
  c misc: as above
  c include: as above
  asm define: NDEBUG, NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
