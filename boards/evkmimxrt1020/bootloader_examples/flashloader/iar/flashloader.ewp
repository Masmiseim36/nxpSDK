# IAR project flashloader.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: MIMXRT1021xxx5A NXP MIMXRT1021xxx5A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1021DAG5A; CPU_IS_ARM_CORTEX_M7=1; BL_TARGET_RAM; MIMXRT1021; USB_STACK_BM
  ICCARM.CCDiagSuppress: Pa082,Pe177,Pe186,Ms014,Pa182
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../middleware/mcu-boot/src; ../../../../../middleware/mcu-boot/src/bootloader; ../../../../../middleware/mcu-boot/src/bm_usb; ../../../../../middleware/mcu-boot/src/include; ../../../../../middleware/mcu-boot/src/startup; ../../../../../middleware/mcu-boot/src/utilities; ../../../../../middleware/mcu-boot/src/drivers; ../../../../../middleware/mcu-boot/src/drivers/crc; ../../../../../middleware/mcu-boot/src/drivers/microseconds; ../../../../../middleware/mcu-boot/src/drivers/smc; ../../../../../middleware/mcu-boot/targets/MIMXRT1021/src; ../../../../../middleware/mcu-boot/src/autobaud; ../../../../../middleware/mcu-boot/src/drivers/sdmmc/inc; ../../../../../middleware/mcu-boot/src/drivers/lpuart; ../../../../../devices/MIMXRT1021; ../../../../../middleware/mcu-boot/targets/MIMXRT1021/drivers; ..; ../../../../../devices/MIMXRT1021; ../../../../../middleware/usb/device; ../../../../../middleware/usb/include; ../../../../../middleware/usb/phy; ../../../../../components/osa; ../../../../../devices/MIMXRT1021/drivers; ../../../../../devices/MIMXRT1021/drivers; ../../../../../components/lists
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG
  ILINK.IlinkOutputFile: flashloader.out
  ILINK.IlinkIcfFile: MIMXRT1021_ram_flashloader.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group device
    ../../../../../devices/MIMXRT1021/: MIMXRT1021.h MIMXRT1021_features.h fsl_device_registers.h system_MIMXRT1021.h
    ../../../../../middleware/mcu-boot/targets/MIMXRT1021/src/startup/: system_MIMXRT1021.c
  group startup
    ../../../../../middleware/mcu-boot/targets/MIMXRT1021/src/startup/iar/: startup_MIMXRT1021.s
    ../../../../../middleware/mcu-boot/src/startup/: ar_asm_macros.h startup.c
  group source/usb/bm_composite
    ../../../../../middleware/mcu-boot/src/bm_usb/: bootloader_hid_report_ids.h composite.c composite.h fat_directory_entry.h hid_bootloader.c hid_bootloader.h msc_disk.c msc_disk.h usb_descriptor.c usb_descriptor.h
    ../../../../../middleware/mcu-boot/targets/MIMXRT1021/src/: usb_device_config.h
  group source/autobaud
    ../../../../../middleware/mcu-boot/src/autobaud/: autobaud.h
    ../../../../../middleware/mcu-boot/src/autobaud/src/: autobaud_irq.c
  group source/bootloader
    ../../../../../middleware/mcu-boot/src/bootloader/: bl_app_crc_check.h bl_command.h bl_context.h bl_irq_common.h bl_peripheral.h bl_peripheral_interface.h bl_shutdown_cleanup.h bl_user_entry.h bl_version.h bootloader.h bl_keyblob.h bl_nor_encrypt.h
  group source/bootloader/src
    ../../../../../middleware/mcu-boot/src/bootloader/src/: bl_app_crc_check.c bl_command.c bl_context.c bl_exception_handler.c bl_main.c bl_misc.c bl_shutdown_cleanup.c bl_tree_root.c bl_user_entry.c bl_keyblob.c bl_keyblob_dcp.c bl_nor_encrypt_bee.c lpuart_peripheral_interface.c usb_hid_msc_peripheral_interface.c
  group source/crc
    ../../../../../middleware/mcu-boot/src/crc/: crc16.h crc32.h
    ../../../../../middleware/mcu-boot/src/crc/src/: crc16.c crc32.c
  group source/include
    ../../../../../middleware/mcu-boot/src/include/: bootloader_common.h bootloader_core.h
  group source/memory
    ../../../../../middleware/mcu-boot/src/memory/: memory.h
  group source/memory/src
    ../../../../../middleware/mcu-boot/src/memory/src/: device_memory.c device_memory.h memory.c normal_memory.c normal_memory.h pattern_fill.h pattern_fill.s sram_init.h flexspi_nor_memory.c flexspi_nor_memory.h spinand_memory.c spinand_memory.h semc_nor_memory.c semc_nor_memory.h semc_nand_memory.c semc_nand_memory.h mmc_memory.c mmc_memory.h sd_memory.c sd_memory.h spi_nor_eeprom_memory.c spi_nor_eeprom_memory.h
    ../../../../../middleware/mcu-boot/targets/MIMXRT1021/src/: sram_init_MIMXRT1021.c
  group source/packet
    ../../../../../middleware/mcu-boot/src/packet/: command_packet.h serial_packet.h
  group source/packet/src
    ../../../../../middleware/mcu-boot/src/packet/src/: serial_packet.c
  group source/property
    ../../../../../middleware/mcu-boot/src/property/: property.h
  group source/property/src
    ../../../../../middleware/mcu-boot/src/property/src/: property_imx.c
  group source/sbloader
    ../../../../../middleware/mcu-boot/src/sbloader/: sb_file_format.h sbloader.h
  group source/sbloader/src
    ../../../../../middleware/mcu-boot/src/sbloader/src/: sbloader.c
  group source/utilities
    ../../../../../middleware/mcu-boot/src/utilities/: fsl_assert.h fsl_rtos_abstraction.h vector_table_info.h
  group source/utilities/src
    ../../../../../middleware/mcu-boot/src/utilities/src/: debug_util.c fsl_assert.c fsl_rtos_abstraction.c
  group source/drivers
    ../../../../../middleware/mcu-boot/src/drivers/smc/: smc.h
  group source/drivers/dcp
    ../../../../../middleware/mcu-boot/src/drivers/dcp/: fsl_dcp.c fsl_dcp.h
  group source/drivers/igpio
    ../../../../../middleware/mcu-boot/src/drivers/igpio/: fsl_gpio.c fsl_gpio.h
  group source/drivers/lpuart
    ../../../../../middleware/mcu-boot/src/drivers/lpuart/: fsl_lpuart.c fsl_lpuart.h
  group source/drivers/port
    ../../../../../middleware/mcu-boot/src/drivers/port/: fsl_port.h
  group source/drivers/trng
    ../../../../../middleware/mcu-boot/src/drivers/trng/: fsl_trng.c fsl_trng.h
  group source/drivers/microseconds
    ../../../../../middleware/mcu-boot/src/drivers/microseconds/: microseconds.h
    ../../../../../middleware/mcu-boot/src/drivers/microseconds/src/: microseconds_pit.c
  group source/drivers/flexspi
    ../../../../../middleware/mcu-boot/src/drivers/flexspi/: fsl_flexspi.c fsl_flexspi.h fsl_flexspi.c fsl_flexspi.h
  group source/drivers/flexspi_nand
    ../../../../../middleware/mcu-boot/src/drivers/flexspi_nand/: flexspi_nand_flash.c flexspi_nand_flash.h
  group source/drivers/ocotp
    ../../../../../middleware/mcu-boot/src/drivers/ocotp/: fsl_ocotp.c fsl_ocotp.h
  group source/drivers/flexspi_nor
    ../../../../../middleware/mcu-boot/src/drivers/flexspi_nor/: flexspi_nor_flash.c flexspi_nor_flash.h
  group source/drivers/semc
    ../../../../../middleware/mcu-boot/src/drivers/semc/: fsl_semc.c fsl_semc.h fsl_semc.c fsl_semc.h
  group source/drivers/semc_nor
    ../../../../../middleware/mcu-boot/src/drivers/semc_nor/: semc_nor_flash.c semc_nor_flash.h
  group source/drivers/nand_ecc
    ../../../../../middleware/mcu-boot/src/drivers/nand_ecc/: nand_ecc.c nand_ecc.h
  group source/drivers/semc_nand
    ../../../../../middleware/mcu-boot/src/drivers/semc_nand/: semc_nand_flash.c semc_nand_flash.h
  group source/drivers/gpio
    ../../../../../middleware/mcu-boot/src/drivers/gpio/: fsl_gpio.h
  group source/drivers/sdmmc
    ../../../../../middleware/mcu-boot/src/drivers/sdmmc/inc/: fsl_card.h fsl_host.h fsl_sdmmc.h fsl_specification.h
    ../../../../../middleware/mcu-boot/src/drivers/sdmmc/port/usdhc/polling/: fsl_host.c
    ../../../../../middleware/mcu-boot/src/drivers/sdmmc/src/: fsl_mmc.c fsl_sd.c fsl_sdmmc.c
  group source/drivers/usdhc
    ../../../../../middleware/mcu-boot/src/drivers/usdhc/: fsl_usdhc.c fsl_usdhc.h
  group source/drivers/lpspi
    ../../../../../middleware/mcu-boot/src/drivers/lpspi/: fsl_lpspi.c fsl_lpspi.h
  group source/drivers/serial_nor_eeprom
    ../../../../../middleware/mcu-boot/src/drivers/serial_nor_eeprom/: serial_nor_eeprom.c serial_nor_eeprom.h
  group MIMXRT1021
    ../../../../../middleware/mcu-boot/targets/MIMXRT1021/drivers/: fsl_iomuxc.h
    ../../../../../middleware/mcu-boot/targets/MIMXRT1021/src/: bl_api.c bl_api.h bl_lpuart_irq_config_MIMXRT1021.c bootloader_config.h clock_config_MIMXRT1021.c external_memory_property_map_MIMXRT1021.c flexspi_nand_config_MIMXRT1021.c flexspi_nor_config_MIMXRT1021.c fusemap.h hardware_init_MIMXRT1021.c memory_map_MIMXRT1021.c peripherals_MIMXRT1021.c peripherals_pinmux.h sdmmc_config_MIMXRT1021.c sdmmc_init.h semc_nand_config_MIMXRT1021.c semc_nor_config_MIMXRT1021.c target_config.h
    ../../../../../middleware/mcu-boot/targets/common/src/: pinmux_utility_imxrt_series.c
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/ehci
    ../../../../../middleware/usb/device/: usb_device_ehci.c usb_device_ehci.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/hid
    ../: usb_device_hid.c usb_device_hid.h
  group usb/device/class/msc
    ../: usb_device_msc.c usb_device_msc.h usb_device_msc_ufi.c usb_device_msc_ufi.h
  group usb/device/include
    ../../../../../middleware/usb/device/: usb_device.h
  group usb/include
    ../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group usb/phy
    ../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group drivers
    ../../../../../devices/MIMXRT1021/drivers/: fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h
