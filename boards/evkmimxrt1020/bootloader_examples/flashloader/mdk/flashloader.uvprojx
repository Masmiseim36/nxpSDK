# Keil uVision project flashloader.uvprojx, settings and files
target flashloader release (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MIMXRT1021DAG5A NXP
  pack: ARM.CMSIS.5.1.0
  cpu: CPUTYPE("Cortex-M7") FPU2
  output: flashloader.out +hex
  AfterMake: fromelf --bincombined -o "$L@L.bin" "#L"
  AfterMake: fromelf --m32combined -o "$L@L.srec" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MIMXRT1021DAG5A, CPU_IS_ARM_CORTEX_M7=1, BL_TARGET_RAM, MIMXRT1021, USB_STACK_BM
  c misc: --library_interface=armcc 
--diag_suppress=66,1296,186,1295,177,61,111 
--library_type=standardlib  --gnu
  c include: ../../../../../CMSIS/Include;../../../../../middleware/mcu-boot/src;../../../../../middleware/mcu-boot/src/bootloader;../../../../../middleware/mcu-boot/src/bm_usb;../../../../../middleware/mcu-boot/src/include;../../../../../middleware/mcu-boot/src/startup;../../../../../middleware/mcu-boot/src/utilities;../../../../../middleware/mcu-boot/src/drivers;../../../../../middleware/mcu-boot/src/drivers/crc;../../../../../middleware/mcu-boot/src/drivers/microseconds;../../../../../middleware/mcu-boot/src/drivers/smc;../../../../../middleware/mcu-boot/targets/MIMXRT1021/src;../../../../../middleware/mcu-boot/src/autobaud;../../../../../middleware/mcu-boot/src/drivers/sdmmc/inc;../../../../../middleware/mcu-boot/src/drivers/lpuart;../../../../../devices/MIMXRT1021;../../../../../middleware/mcu-boot/targets/MIMXRT1021/drivers;..;../../../../../middleware/usb/device;../../../../../middleware/usb/include;../../../../../middleware/usb/osa;../../../../../middleware/usb/phy
  asm define: BL_HAS_BOOTLOADER_CONFIG=0
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1021_ram_flashloader.scf
  link misc: --remove 
--datacompressor 
off 
--feedback_type=unused,noiw 
--predefine="-D__ram_vector_table__=1"
  group device
    ../../../../../devices/MIMXRT1021/: system_MIMXRT1021.h fsl_device_registers.h MIMXRT1021.h MIMXRT1021_features.h
    ../../../../../middleware/mcu-boot/targets/MIMXRT1021/src/startup/: system_MIMXRT1021.c
  group startup
    ../../../../../middleware/mcu-boot/targets/MIMXRT1021/src/startup/arm/: startup_MIMXRT1021.s
    ../../../../../middleware/mcu-boot/src/startup/: ar_asm_macros.h startup.c
  group source-usb-bm_composite
    ../../../../../middleware/mcu-boot/src/bm_usb/: bootloader_hid_report_ids.h fat_directory_entry.h composite.h composite.c hid_bootloader.h hid_bootloader.c msc_disk.h msc_disk.c usb_descriptor.h usb_descriptor.c
    ../../../../../middleware/mcu-boot/targets/MIMXRT1021/src/: usb_device_config.h
  group source-autobaud
    ../../../../../middleware/mcu-boot/src/autobaud/: autobaud.h
    ../../../../../middleware/mcu-boot/src/autobaud/src/: autobaud_irq.c
  group source-bootloader
    ../../../../../middleware/mcu-boot/src/bootloader/: bl_peripheral_interface.h bl_user_entry.h bl_version.h bootloader.h bl_command.h bl_context.h bl_peripheral.h bl_shutdown_cleanup.h bl_irq_common.h bl_app_crc_check.h bl_nor_encrypt.h bl_keyblob.h
  group source-bootloader-src
    ../../../../../middleware/mcu-boot/src/bootloader/src/: bl_user_entry.c bl_main.c bl_context.c bl_exception_handler.c bl_tree_root.c bl_command.c bl_shutdown_cleanup.c bl_app_crc_check.c bl_misc.c lpuart_peripheral_interface.c usb_hid_msc_peripheral_interface.c bl_nor_encrypt_bee.c bl_keyblob.c bl_keyblob_dcp.c
  group source-crc
    ../../../../../middleware/mcu-boot/src/crc/: crc16.h crc32.h
    ../../../../../middleware/mcu-boot/src/crc/src/: crc16.c crc32.c
  group source-include
    ../../../../../middleware/mcu-boot/src/include/: bootloader_common.h bootloader_core.h
  group source-memory
    ../../../../../middleware/mcu-boot/src/memory/: memory.h
  group source-memory-src
    ../../../../../middleware/mcu-boot/src/memory/src/: sram_init.h memory.c device_memory.h device_memory.c normal_memory.h normal_memory.c pattern_fill.s pattern_fill.h spinand_memory.c spinand_memory.h flexspi_nor_memory.c flexspi_nor_memory.h semc_nand_memory.c semc_nand_memory.h semc_nor_memory.c semc_nor_memory.h spi_nor_eeprom_memory.c spi_nor_eeprom_memory.h sd_memory.c sd_memory.h mmc_memory.c mmc_memory.h
    ../../../../../middleware/mcu-boot/targets/MIMXRT1021/src/: sram_init_MIMXRT1021.c
  group source-packet
    ../../../../../middleware/mcu-boot/src/packet/: command_packet.h serial_packet.h
  group source-packet-src
    ../../../../../middleware/mcu-boot/src/packet/src/: serial_packet.c
  group source-property
    ../../../../../middleware/mcu-boot/src/property/: property.h
  group source-sbloader
    ../../../../../middleware/mcu-boot/src/sbloader/: sbloader.h sb_file_format.h
  group source-sbloader-src
    ../../../../../middleware/mcu-boot/src/sbloader/src/: sbloader.c
  group source-utilities
    ../../../../../middleware/mcu-boot/src/utilities/: fsl_rtos_abstraction.h fsl_assert.h vector_table_info.h
  group source-utilities-src
    ../../../../../middleware/mcu-boot/src/utilities/src/: fsl_assert.c fsl_rtos_abstraction.c
  group source-drivers-port
    ../../../../../middleware/mcu-boot/src/drivers/port/: fsl_port.h
  group source-drivers
    ../../../../../middleware/mcu-boot/src/drivers/smc/: smc.h
  group source-drivers-igpio
    ../../../../../middleware/mcu-boot/src/drivers/igpio/: fsl_gpio.c fsl_gpio.h
  group source-drivers-lpuart
    ../../../../../middleware/mcu-boot/src/drivers/lpuart/: fsl_lpuart.c fsl_lpuart.h
  group source-drivers-dcp
    ../../../../../middleware/mcu-boot/src/drivers/dcp/: fsl_dcp.c fsl_dcp.h
  group source-drivers-trng
    ../../../../../middleware/mcu-boot/src/drivers/trng/: fsl_trng.c fsl_trng.h
  group source-property-src
    ../../../../../middleware/mcu-boot/src/property/src/: property_imx.c
  group drivers
    ../../../../../middleware/mcu-boot/targets/MIMXRT1021/drivers/: fsl_common.h fsl_common.c
    ../../../../../middleware/mcu-boot/targets/MIMXRT1021/src/: fsl_clock.h fsl_clock.c
  group MIMXRT1021
    ../../../../../middleware/mcu-boot/targets/MIMXRT1021/src/: bootloader_config.h clock_config_MIMXRT1021.c hardware_init_MIMXRT1021.c memory_map_MIMXRT1021.c external_memory_property_map_MIMXRT1021.c flexspi_nand_config_MIMXRT1021.c flexspi_nor_config_MIMXRT1021.c semc_nand_config_MIMXRT1021.c semc_nor_config_MIMXRT1021.c peripherals_MIMXRT1021.c peripherals_pinmux.h target_config.h fusemap.h bl_lpuart_irq_config_MIMXRT1021.c sdmmc_init.h sdmmc_config_MIMXRT1021.c
    ../../../../../middleware/mcu-boot/targets/common/src/: pinmux_utility_imxrt_series.c
  group usb-device-source-ehci
    ../../../../../middleware/usb/device/: usb_device_ehci.c usb_device_ehci.h
  group usb-include
    ../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group osa
    ../../../../../middleware/usb/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group usb-device-class-hid
    ../: usb_device_hid.c usb_device_hid.h
  group usb-device-class-msc
    ../: usb_device_msc.c usb_device_msc.h usb_device_msc_ufi.c usb_device_msc_ufi.h
  group usb-device-source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
  group usb-device-class
    ../: usb_device_class.c usb_device_class.h
  group usb-device-include
    ../../../../../middleware/usb/device/: usb_device.h
  group source-drivers-microseconds
    ../../../../../middleware/mcu-boot/src/drivers/microseconds/: microseconds.h
    ../../../../../middleware/mcu-boot/src/drivers/microseconds/src/: microseconds_pit.c
  group source-drivers-flexspi
    ../../../../../middleware/mcu-boot/src/drivers/flexspi/: fsl_flexspi.c fsl_flexspi.h fsl_flexspi.c fsl_flexspi.h
  group source-drivers-flexspi_nor
    ../../../../../middleware/mcu-boot/src/drivers/flexspi_nor/: flexspi_nor_flash.c flexspi_nor_flash.h
  group source-drivers-flexspi_nand
    ../../../../../middleware/mcu-boot/src/drivers/flexspi_nand/: flexspi_nand_flash.c flexspi_nand_flash.h
  group source-drivers-semc
    ../../../../../middleware/mcu-boot/src/drivers/semc/: fsl_semc.c fsl_semc.h fsl_semc.c fsl_semc.h
  group source-drivers-semc_nor
    ../../../../../middleware/mcu-boot/src/drivers/semc_nor/: semc_nor_flash.c semc_nor_flash.h
  group source-drivers-semc_nand
    ../../../../../middleware/mcu-boot/src/drivers/semc_nand/: semc_nand_flash.c semc_nand_flash.h
  group source-drivers-nand_ecc
    ../../../../../middleware/mcu-boot/src/drivers/nand_ecc/: nand_ecc.c nand_ecc.h
  group source-drivers-gpio
    ../../../../../middleware/mcu-boot/src/drivers/gpio/: fsl_gpio.h
  group source-drivers-usdhc
    ../../../../../middleware/mcu-boot/src/drivers/usdhc/: fsl_usdhc.c fsl_usdhc.h
  group source-drivers-sdmmc
    ../../../../../middleware/mcu-boot/src/drivers/sdmmc/inc/: fsl_card.h fsl_host.h fsl_sdmmc.h fsl_specification.h
    ../../../../../middleware/mcu-boot/src/drivers/sdmmc/port/usdhc/polling/: fsl_host.c
    ../../../../../middleware/mcu-boot/src/drivers/sdmmc/src/: fsl_sd.c fsl_mmc.c fsl_sdmmc.c
  group source-drivers-lpspi
    ../../../../../middleware/mcu-boot/src/drivers/lpspi/: fsl_lpspi.c fsl_lpspi.h
  group source-drivers-serial_nor_eeprom
    ../../../../../middleware/mcu-boot/src/drivers/serial_nor_eeprom/: serial_nor_eeprom.c serial_nor_eeprom.h
  group source-drivers-ocotp
    ../../../../../middleware/mcu-boot/src/drivers/ocotp/: fsl_ocotp.c fsl_ocotp.h
  group usb-phy
    ../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
