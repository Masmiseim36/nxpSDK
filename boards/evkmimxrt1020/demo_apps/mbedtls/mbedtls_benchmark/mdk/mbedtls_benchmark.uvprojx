# Keil uVision project mbedtls_benchmark.uvprojx, settings and files
target mbedtls_benchmark flexspi_nor_debug (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: mbedtls_benchmark.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, CPU_MIMXRT1021DAG5A, PRINTF_ADVANCED_ENABLE=1, PRINTF_FLOAT_ENABLE=1, FREESCALE_KSDK_BM, MBEDTLS_CONFIG_FILE='\"ksdk_mbedtls_config.h\"'
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186 
--diag_suppress=177
  c include: ../../../../../../CMSIS/Include;../../../../../../devices;..;../../../..;../../../../../../middleware/mbedtls/include;../../../../../../middleware/mbedtls/port/ksdk;../../../../../../devices/MIMXRT1021/drivers;../../../../../../devices/MIMXRT1021;../../../../../../devices/MIMXRT1021/utilities/io;../../../../../../devices/MIMXRT1021/utilities/str;../../../../../../devices/MIMXRT1021/utilities/log;../../../../../../devices/MIMXRT1021/utilities;../../../../../../devices/MIMXRT1021/xip
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1021xxxxx_flexspi_nor.scf
  link misc: --remove 
--keep=*(.boot_hdr.ivt) 
--keep=*(.boot_hdr.boot_data) 
--keep=*(.boot_hdr.dcd_data) 
--keep=*(.boot_hdr.conf) 
--predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group source
    ../: benchmark.c
  group board
    ../: pin_mux.c pin_mux.h
  group board-src
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MIMXRT1021/drivers/: fsl_dcp.c fsl_dcp.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_trng.c fsl_trng.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group startup
    ../../../../../../devices/MIMXRT1021/: system_MIMXRT1021.c system_MIMXRT1021.h
    ../../../../../../devices/MIMXRT1021/arm/: startup_MIMXRT1021.s
  group utilities
    ../../../../../../devices/MIMXRT1021/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../devices/MIMXRT1021/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../devices/MIMXRT1021/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1021/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group xip
    ../../../../../../devices/MIMXRT1021/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c evkmimxrt1020_flexspi_nor_config.c evkmimxrt1020_flexspi_nor_config.h evkmimxrt1020_sdram_ini_dcd.c evkmimxrt1020_sdram_ini_dcd.h
  group mbedTLS-mbedTLS_include
    ../../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h ripemd160.h rsa.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedTLS-mbedTLS_source
    ../../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c pkcs11.c
  group mbedTLS-mbedTLS_port
    ../../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c
target mbedtls_benchmark flexspi_nor_release (ARM-ADS)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: mbedtls_benchmark.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1021xxxxx_flexspi_nor.scf
  link misc: as above
