# Keil uVision project safety_iec60730b.uvprojx, settings and files
target safety_iec60730b debug (ARM-ADS)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: safety_iec60730b.out +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT1021DAG5A, XIP_BOOT_HEADER_DCD_ENABLE=1, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, SKIP_SYSCLK_INIT, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  --debug
  c include: ../../../../../middleware/safety_iec60730b/boards/evkmimxrt1020;../../..;../../../../../CMSIS/Include;../../../../../devices;linker;..;../../../../../middleware/safety_iec60730b/dev/evkmimxrt1020;../../../../../middleware/safety_iec60730b/boards/evkmimxrt1020/xip;../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/register;../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/ram;../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/flash;../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/stack;../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/programCounter;../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7;../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/compiler;../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/compiler/mdk;../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/watchdog;../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/dio;../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/clock;../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/aio;../../../../../middleware/safety_iec60730b/boards/common/cm4_cm7/startup/cm7;../../../../../devices/MIMXRT1021;../../../../../devices/MIMXRT1021/arm;../../../../../devices/MIMXRT1021/drivers;../../../../../devices/MIMXRT1021/utilities/str;../../../../../devices/MIMXRT1021/utilities/debug_console;../../../../../middleware/freemaster/src/common;../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial;../../../../../middleware/freemaster/src/drivers/mcuxsdk/can;../../../../../middleware/freemaster/src/platforms/gen32le;../../../../../components/serial_manager;../../../../../components/lists;../../../../../components/uart;../../../../../devices/MIMXRT1021/utilities
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7;../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/register;../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/ram;../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/flash;../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/stack;../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/programCounter;../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/compiler;../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/compiler/mdk;../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/watchdog;../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/dio;../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/clock;../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/aio
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: linker/evkmimxrt1020_safety_flash.sct
  link misc: ../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/IEC60730_Kinetis_CM4_CM7_Class_B_KEIL_v3_0.lib --remove
  group source
    ../: freemaster_cfg.h main_imxrt.c safety_test_items.h safety_test_items.c isr.h safety_config.h project_setup_evkmimxrt1020.h project_setup_evkmimxrt1020.c safety_cm7_imxrt.c safety_cm7_imxrt.h
  group doc
    ../: readme.txt
  group board
    ../: pin_mux.c pin_mux.h clock_config.c clock_config.h board.c board.h
  group tools/srec
    ../: srecord-1.64.zip srec_cat.exe
  group linker
    linker/: evkmimxrt1020_safety_flash.sct linker_config.h
  group device
    ../../../../../middleware/safety_iec60730b/boards/evkmimxrt1020/xip/: evkmimxrt1020_flexspi_nor_config.c evkmimxrt1020_flexspi_nor_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h evkmimxrt1020_sdram_ini_dcd.c evkmimxrt1020_sdram_ini_dcd.h
    ../../../../../devices/MIMXRT1021/: system_MIMXRT1021.c system_MIMXRT1021.h MIMXRT1021.h MIMXRT1021_features.h fsl_device_registers.h
  group GUI
    ../GUI/: safety_flash.pmp
  group cpu
    ../../../../../middleware/safety_iec60730b/boards/common/cm4_cm7/startup/cm7/: start.c startup_mdk.c vectors_mdk.c vectors_mdk.h
  group IEC60730_Class_B
    ../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/: IEC60730_B_CM4_CM7.h
  group IEC60730_Class_B/aio
    ../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/aio/: IEC60730_B_CM4_CM7_aio.h
  group IEC60730_Class_B/clock
    ../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/clock/: IEC60730_B_CM4_CM7_clock.h
  group IEC60730_Class_B/compiler
    ../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/compiler/: asm_mac_common.h
  group IEC60730_Class_B/dio
    ../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/dio/: IEC60730_B_CM4_CM7_dio.h IEC60730_B_CM4_CM7_dio_ext.h
  group IEC60730_Class_B/flash
    ../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/flash/: IEC60730_B_CM4_CM7_flash.h
  group IEC60730_Class_B/programCounter
    ../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/programCounter/: IEC60730_B_CM4_CM7_pc.h IEC60730_B_CM4_CM7_pc_object.S
  group IEC60730_Class_B/ram
    ../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/ram/: IEC60730_B_CM4_CM7_ram.h
  group IEC60730_Class_B/register
    ../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/register/: IEC60730_B_CM4_CM7_reg.h
  group IEC60730_Class_B/stack
    ../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/stack/: IEC60730_B_CM4_CM7_stack.h
  group IEC60730_Class_B/watchdog
    ../../../../../middleware/safety_iec60730b/safety/v3_0/cm4_cm7/watchdog/: IEC60730_B_CM4_CM7_wdg.c IEC60730_B_CM4_CM7_wdg.h
  group drivers
    ../../../../../devices/MIMXRT1021/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h
  group utilities
    ../../../../../devices/MIMXRT1021/utilities/: fsl_assert.c
    ../../../../../devices/MIMXRT1021/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1021/utilities/str/: fsl_str.c fsl_str.h
  group freemaster
    ../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_can.c freemaster_can.h freemaster_defcfg.h freemaster_pdbdm.c freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_serial.c freemaster_serial.h freemaster_sha.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h
  group freemaster/drivers/mcuxsdk/can
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mcan.c freemaster_mcan.h freemaster_mscan.c freemaster_mscan.h
  group freemaster/drivers/mcuxsdk/serial
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_usb.c freemaster_serial_usb.h
  group freemaster/platforms
    ../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group component-uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
