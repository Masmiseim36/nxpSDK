# IAR project sdcard_fatfs_freertos.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1021xxx5A NXP MIMXRT1021xxx5A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1021DAG5A; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM4F; ..; ../../..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../rtos/amazon-freertos/lib/include; ../../../../../rtos/amazon-freertos/lib/include/private; ../../../../../devices/MIMXRT1021/drivers; ../../../../../middleware/sdmmc/port; ../../../../../devices/MIMXRT1021/drivers; ../../../../../middleware/sdmmc/port; ../../../../../middleware/fatfs/source/fsl_sd_disk; ../../../../../devices/MIMXRT1021/drivers; ../../../../../devices/MIMXRT1021/drivers; ../../../../../devices/MIMXRT1021; ../../../../../devices/MIMXRT1021/utilities/str; ../../../../../devices/MIMXRT1021/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/serial_manager; ../../../../../devices/MIMXRT1021/drivers; ../../../../../components/lists; ../../../../../devices/MIMXRT1021/drivers; ../../../../../devices/MIMXRT1021/drivers; ../../../../../devices/MIMXRT1021/xip; ../../../xip; ../../../../../middleware/sdmmc/inc; ../../../../../middleware/sdmmc/src; ../../../../../middleware/fatfs/source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../../..
  ILINK.IlinkOutputFile: sdcard_fatfs_freertos.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x1000
  ILINK.IlinkIcfFile: MIMXRT1021xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1021DAG5A; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1021xxxxx_flexspi_nor.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; DEBUG; CPU_MIMXRT1021DAG5A; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1021xxxxx_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1021DAG5A; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1021DAG5A; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1021xxxxx_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SKIP_SYSCLK_INIT; CPU_MIMXRT1021DAG5A; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1021xxxxx_sdram.icf
  group source
    ../: sdcard_fatfs_freertos.c ffconf.h FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1021/drivers/: fsl_usdhc.c fsl_usdhc.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h fsl_gpio.c fsl_gpio.h
  group sdmmc/port
    ../../../../../middleware/sdmmc/port/: fsl_sdmmc_event.h
    ../../../../../middleware/sdmmc/port/usdhc/freertos/: fsl_sdmmc_event.c fsl_sdmmc_host.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc/inc/: fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
  group sdmmc/src
    ../../../../../middleware/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group fatfs/fatfs_source
    ../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c
    ../../../../../middleware/fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group fatfs/fatfs_include
    ../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.h
    ../../../../../middleware/fatfs/source/: diskio.h ff.h integer.h
  group amazon-freertos/freertos
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos/freertos/portable
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
  group amazon-freertos/include
    ../../../../../rtos/amazon-freertos/lib/include/: FreeRTOS.h event_groups.h freertos_tasks_c_additions.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
    ../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h stack_macros.h threading_alt.h
  group device
    ../../../../../devices/MIMXRT1021/: MIMXRT1021.h MIMXRT1021_features.h fsl_device_registers.h system_MIMXRT1021.c system_MIMXRT1021.h
  group utilities
    ../../../../../devices/MIMXRT1021/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1021/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1021/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MIMXRT1021/iar/: startup_MIMXRT1021.s
  group xip
    ../../../../../devices/MIMXRT1021/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../xip/: evkmimxrt1020_flexspi_nor_config.c evkmimxrt1020_flexspi_nor_config.h evkmimxrt1020_sdram_ini_dcd.c evkmimxrt1020_sdram_ini_dcd.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h
