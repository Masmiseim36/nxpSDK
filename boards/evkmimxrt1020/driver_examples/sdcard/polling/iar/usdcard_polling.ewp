# IAR project usdcard_polling.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1021xxx5A NXP MIMXRT1021xxx5A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1021DAG5A
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../devices; ..; ../../../..; ../../../../../../devices/MIMXRT1021/drivers; ../../../../../../devices/MIMXRT1021; ../../../../../../devices/MIMXRT1021/utilities/io; ../../../../../../devices/MIMXRT1021/utilities/str; ../../../../../../devices/MIMXRT1021/utilities/log; ../../../../../../devices/MIMXRT1021/utilities; ../../../../../../devices/MIMXRT1021/xip; ../../../../../../middleware/sdmmc/src; ../../../../../../middleware/sdmmc/inc; ../../../../../../middleware/sdmmc/port
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: usdcard_polling.out
  ILINK.IlinkIcfFile: MIMXRT1021xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; CPU_MIMXRT1021DAG5A
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1021xxxxx_flexspi_nor.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SKIP_SYSCLK_INIT; DEBUG; CPU_MIMXRT1021DAG5A
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1021xxxxx_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1021DAG5A
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; CPU_MIMXRT1021DAG5A
  ICCARM.CCOptLevel: 2
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1021xxxxx_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; NDEBUG; SKIP_SYSCLK_INIT; CPU_MIMXRT1021DAG5A
  ICCARM.CCOptLevel: 2
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1021xxxxx_sdram.icf
  group source
    ../: sdcard_polling.c
  group sdmmc/port
    ../: fsl_sdmmc_host.c
    ../../interrupt/: fsl_sdmmc_event.c fsl_sdmmc_event.h
  group sdmmc/src
    ../../../../../../middleware/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../../middleware/sdmmc/inc/: fsl_sd.h fsl_sdmmc_host.h fsl_sdmmc_common.h fsl_sdmmc_spec.h
  group board
    ../: pin_mux.c pin_mux.h
  group board/src
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MIMXRT1021/drivers/: fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_usdhc.c fsl_usdhc.h
  group startup
    ../../../../../../devices/MIMXRT1021/: system_MIMXRT1021.c system_MIMXRT1021.h
    ../../../../../../devices/MIMXRT1021/iar/: startup_MIMXRT1021.s
  group utilities
    ../../../../../../devices/MIMXRT1021/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../devices/MIMXRT1021/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../devices/MIMXRT1021/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1021/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group xip
    ../../../../../../devices/MIMXRT1021/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c evkmimxrt1020_flexspi_nor_config.c evkmimxrt1020_flexspi_nor_config.h evkmimxrt1020_sdram_ini_dcd.c evkmimxrt1020_sdram_ini_dcd.h
