# Keil uVision project fatfs_usdcard.uvprojx, settings and files
target fatfs_usdcard debug (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: fatfs_usdcard.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_MIMXRT1021DAG5A
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;..;../../..;../../../../../devices/MIMXRT1021/drivers;../../../../../devices/MIMXRT1021;../../../../../devices/MIMXRT1021/utilities/io;../../../../../devices/MIMXRT1021/utilities/str;../../../../../devices/MIMXRT1021/utilities/log;../../../../../devices/MIMXRT1021/utilities;../../../../../devices/MIMXRT1021/xip;../../../../../middleware/fatfs/source/fsl_sd_disk;../../../../../middleware/fatfs/source;../../../../../middleware/sdmmc/src;../../../../../middleware/sdmmc/inc;../../../../../middleware/sdmmc/port
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1021xxxxx_ram.scf
  link misc: --remove
  group source
    ../: fatfs_sdcard.c ffconf.h
  group sdmmc-port
    ../: fsl_sdmmc_host.c fsl_sdmmc_event.c fsl_sdmmc_event.h
  group board
    ../: pin_mux.c pin_mux.h
  group board-src
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1021/drivers/: fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_usdhc.c fsl_usdhc.h
  group startup
    ../../../../../devices/MIMXRT1021/: system_MIMXRT1021.c system_MIMXRT1021.h
    ../../../../../devices/MIMXRT1021/arm/: startup_MIMXRT1021.s
  group utilities
    ../../../../../devices/MIMXRT1021/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MIMXRT1021/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MIMXRT1021/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1021/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group xip
    ../../../../../devices/MIMXRT1021/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c evkmimxrt1020_flexspi_nor_config.c evkmimxrt1020_flexspi_nor_config.h evkmimxrt1020_sdram_ini_dcd.c evkmimxrt1020_sdram_ini_dcd.h
  group fatfs-fatfs_include
    ../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.h
    ../../../../../middleware/fatfs/source/: diskio.h ff.h integer.h
  group fatfs-fatfs_source
    ../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c
    ../../../../../middleware/fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group sdmmc-src
    ../../../../../middleware/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group sdmmc-inc
    ../../../../../middleware/sdmmc/inc/: fsl_sd.h fsl_sdmmc_host.h fsl_sdmmc_common.h fsl_sdmmc_spec.h
target fatfs_usdcard flexspi_nor_debug (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: fatfs_usdcard.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, CPU_MIMXRT1021DAG5A
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1021xxxxx_flexspi_nor.scf
  link misc: --remove 
--keep=*(.boot_hdr.ivt) 
--keep=*(.boot_hdr.boot_data) 
--keep=*(.boot_hdr.dcd_data) 
--keep=*(.boot_hdr.conf) 
--predefine="-DXIP_BOOT_HEADER_ENABLE=1"
target fatfs_usdcard sdram_debug (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: fatfs_usdcard.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SKIP_SYSCLK_INIT, CPU_MIMXRT1021DAG5A
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1021xxxxx_sdram.scf
  link misc: --remove
target fatfs_usdcard release (ARM-ADS)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: fatfs_usdcard.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG, CPU_MIMXRT1021DAG5A
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1021xxxxx_ram.scf
  link misc: --remove
target fatfs_usdcard flexspi_nor_release (ARM-ADS)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: fatfs_usdcard.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1021xxxxx_flexspi_nor.scf
  link misc: as above
target fatfs_usdcard sdram_release (ARM-ADS)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: fatfs_usdcard.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1021xxxxx_sdram.scf
  link misc: --remove
