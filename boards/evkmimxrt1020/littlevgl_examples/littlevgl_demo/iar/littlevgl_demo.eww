<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>littlevgl_demo</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
      <member>
        <project>littlevgl_demo</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_debug</name>
      <member>
        <project>littlevgl_demo</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_release</name>
      <member>
        <project>littlevgl_demo</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/littlevgl_demo.ewp</path>
  </project>
</workspace>
