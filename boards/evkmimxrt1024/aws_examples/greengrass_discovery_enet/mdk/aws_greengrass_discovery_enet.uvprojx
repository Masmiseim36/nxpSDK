# Keil uVision project aws_greengrass_discovery_enet.uvprojx, settings and files
target aws_greengrass_discovery_enet flexspi_nor_sdram_debug (ARM-ADS)
  device: MIMXRT1024DAG5A NXP
  pack: NXP.MIMXRT1024_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: aws_greengrass_discovery_enet.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, DEBUG, CPU_MIMXRT1024DAG5A, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=0, USE_RTOS=1, MBEDTLS_CONFIG_FILE='\"aws_mbedtls_config.h\"', FSL_RTOS_FREE_RTOS, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM4F;../../..;..;../../../../src/aws_examples/common;../../../../src/aws_examples/common/lwipopts_enet;../config_files;../../../../../CMSIS/Include;../../../../../devices;../../../../../rtos/freertos/libraries/freertos_plus/aws/greengrass/include;../../../../../rtos/freertos/libraries/freertos_plus/aws/greengrass/src;../../../../../rtos/freertos/demos/include;../../../../../rtos/freertos/demos/network_manager;../../../../../rtos/freertos/demos/dev_mode_key_provisioning/include;../../../../../rtos/freertos/freertos_kernel/include;../../../../../rtos/freertos/libraries/abstractions/platform/freertos/include;../../../../../rtos/freertos/libraries/abstractions/platform/include;../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/include;../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/src;../../../../../rtos/freertos/libraries/c_sdk/standard/common/include;../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/private;../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/include;../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/src;../../../../../rtos/freertos/libraries/c_sdk/standard/serializer/include;../../../../../rtos/freertos/libraries/abstractions/secure_sockets/include;../../../../../rtos/freertos/libraries/freertos_plus/standard/crypto/include;../../../../../rtos/freertos/libraries/freertos_plus/standard/pkcs11/include;../../../../../rtos/freertos/libraries/freertos_plus/standard/utils/include;../../../../../rtos/freertos/libraries/freertos_plus/standard/tls/include;../../../../../rtos/freertos/libraries/abstractions/pkcs11/include;../../../../../rtos/freertos/libraries/abstractions/pkcs11/mbedtls;../../../../../rtos/freertos/libraries/3rdparty/pkcs11;../../../../../rtos/freertos/libraries/3rdparty/jsmn;../../../../../middleware/mbedtls/include;../../../../../middleware/mbedtls/port/ksdk;../../../../../components/phy/mdio/enet;../../../../../components/phy/device/phyksz8081;../../../../../devices/MIMXRT1024/drivers;../../../../../middleware/lwip/port;../../../../../middleware/lwip/src;../../../../../middleware/lwip/src/include;../../../../../devices/MIMXRT1024/utilities/str;../../../../../devices/MIMXRT1024/utilities/debug_console;../../../../../components/flash/mflash/mimxrt1024;../../../../../devices/MIMXRT1024;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../devices/MIMXRT1024/xip;../../../xip;../../../../../components/phy;../../../../../devices/MIMXRT1024/utilities
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../../..;..;../config_files
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1024xxxxx_flexspi_nor_sdram.scf
  link misc: --remove --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-D__stack_size__=0x200" --predefine="-D__heap_size__=0x200"
  group freertos-config_files
    ../config_files/: aws_iot_network_config.h aws_ggd_config.h aws_wifi_config.h FreeRTOSConfig.h aws_demo_config.h aws_mqtt_config.h aws_secure_sockets_config.h aws_shadow_config.h FreeRTOSIPConfig.h iot_config.h iot_mqtt_agent_config.h iot_pkcs11_config.h
  group source
    ../: main_enet.c lwipopts.h
    ../config_files/: aws_mbedtls_config.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group freertos:config_files
    ../config_files/: aws_bufferpool_config.h
  group doc
    ../: readme.txt
  group mdio
    ../../../../../components/phy/mdio/enet/: fsl_enet_mdio.h fsl_enet_mdio.c
    ../../../../../components/phy/: fsl_mdio.h
  group phy
    ../../../../../components/phy/device/phyksz8081/: fsl_phyksz8081.h fsl_phyksz8081.c
    ../../../../../components/phy/: fsl_phy.h
  group drivers
    ../../../../../devices/MIMXRT1024/drivers/: fsl_trng.c fsl_trng.h fsl_dcp.c fsl_dcp.h fsl_cache.c fsl_cache.h fsl_flexspi.c fsl_flexspi.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_enet.h fsl_enet.c
  group lwip-port
    ../../../../../middleware/lwip/port/: sys_arch.c enet_ethernetif.c enet_ethernetif.h enet_ethernetif_priv.h enet_ethernetif_kinetis.c
  group lwip-port-arch
    ../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip-src-api
    ../../../../../middleware/lwip/src/api/: api_lib.c netdb.c tcpip.c api_msg.c err.c netifapi.c sockets.c if_api.c netbuf.c
  group lwip-src-core
    ../../../../../middleware/lwip/src/core/: dns.c memp.c sys.c tcp.c raw.c init.c altcp_alloc.c udp.c timeouts.c tcp_in.c altcp.c pbuf.c stats.c ip.c inet_chksum.c altcp_tcp.c netif.c def.c mem.c tcp_out.c
  group lwip-src-core-ipv4
    ../../../../../middleware/lwip/src/core/ipv4/: ip4_addr.c etharp.c dhcp.c ip4_frag.c ip4.c acd.c icmp.c autoip.c igmp.c
  group lwip-src-core-ipv6
    ../../../../../middleware/lwip/src/core/ipv6/: ip6_addr.c nd6.c ethip6.c ip6_frag.c inet6.c ip6.c dhcp6.c mld6.c icmp6.c
  group lwip-src-include-compat-stdc
    ../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip-src-include-compat-posix
    ../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip-src-include-compat-posix-net
    ../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip-src-include-compat-posix-arpa
    ../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip-src-include-compat-posix-sys
    ../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip-src-include-lwip
    ../../../../../middleware/lwip/src/include/lwip/: tcpbase.h altcp.h udp.h ip4_frag.h netifapi.h ip6_frag.h altcp_tcp.h stats.h ethip6.h netbuf.h pbuf.h err.h errno.h ip.h netdb.h dhcp6.h netif.h ip6_zone.h icmp6.h sys.h acd.h ip4_addr.h icmp.h sio.h ip6.h snmp.h arch.h tcpip.h ip_addr.h altcp_tls.h igmp.h raw.h init.h ip6_addr.h if_api.h api.h sockets.h ip4.h mld6.h inet_chksum.h dhcp.h nd6.h mem.h memp.h autoip.h def.h etharp.h debug.h opt.h dns.h timeouts.h tcp.h inet.h
  group lwip-src-include-lwip-priv
    ../../../../../middleware/lwip/src/include/lwip/priv/: raw_priv.h memp_priv.h altcp_priv.h mem_priv.h memp_std.h nd6_priv.h tcp_priv.h sockets_priv.h tcpip_priv.h api_msg.h
  group lwip-src-include-lwip-prot
    ../../../../../middleware/lwip/src/include/lwip/prot/: udp.h ieee.h ip.h dhcp6.h icmp6.h acd.h icmp.h ip6.h igmp.h ip4.h mld6.h dhcp.h nd6.h autoip.h etharp.h iana.h dns.h ethernet.h tcp.h
  group lwip-src-include-netif
    ../../../../../middleware/lwip/src/include/netif/: slipif.h lowpan6_ble.h lowpan6_common.h bridgeif_opts.h lowpan6.h ieee802154.h bridgeif.h etharp.h zepif.h ethernet.h lowpan6_opts.h
  group lwip-src-include-netif-ppp
    ../../../../../middleware/lwip/src/include/netif/ppp/: upap.h pppol2tp.h ppp.h pppdebug.h ipv6cp.h chap-new.h ppp_impl.h ppp_opts.h eap.h ipcp.h chap_ms.h pppcrypt.h mppe.h pppoe.h pppapi.h ccp.h vj.h lcp.h eui64.h magic.h fsm.h ecp.h pppos.h chap-md5.h
  group lwip-src-include-netif-ppp-polarssl
    ../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: sha1.h md4.h arc4.h des.h md5.h
  group lwip-src-netif
    ../../../../../middleware/lwip/src/netif/: slipif.c bridgeif_fdb.c ethernet.c lowpan6_common.c bridgeif.c lowpan6_ble.c lowpan6.c zepif.c
  group lwip-src-netif-ppp
    ../../../../../middleware/lwip/src/netif/ppp/: lcp.c pppos.c mppe.c magic.c vj.c chap-new.c ccp.c lwip_ecp.c ipv6cp.c eap.c pppapi.c ppp.c chap-md5.c ipcp.c pppol2tp.c multilink.c pppcrypt.c demand.c pppoe.c utils.c chap_ms.c upap.c auth.c fsm.c eui64.c
  group utilities
    ../../../../../devices/MIMXRT1024/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1024/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1024/utilities/: fsl_assert.c
  group flash-mflash-mimxrt1024
    ../../../../../components/flash/mflash/mimxrt1024/: mflash_drv.h mflash_drv.c mflash_file.h mflash_file.c
  group freertos-vendors-nxp-secure_sockets-lwip
    ../../../../../rtos/freertos/vendors/nxp/secure_sockets/lwip/: iot_secure_sockets.c
  group freertos-libraries-freertos_plus-aws-greengrass-include
    ../../../../../rtos/freertos/libraries/freertos_plus/aws/greengrass/include/: aws_ggd_config_defaults.h aws_greengrass_discovery.h
  group freertos-libraries-freertos_plus-aws-greengrass-src
    ../../../../../rtos/freertos/libraries/freertos_plus/aws/greengrass/src/: aws_greengrass_discovery.c aws_helper_secure_connect.c aws_helper_secure_connect.h
  group freertos-demos-demo_runner
    ../../../../../rtos/freertos/demos/demo_runner/: aws_demo.c iot_demo_freertos.c
  group freertos-demos-include
    ../../../../../rtos/freertos/demos/include/: aws_clientcredential.h aws_clientcredential_keys.h aws_demo.h aws_iot_demo_network.h aws_ota_codesigner_certificate.h aws_wifi_connect_task.h iot_ble_numericComparison.h iot_config_common.h iot_demo_logging.h iot_demo_runner.h
  group freertos-demos-network_manager
    ../../../../../rtos/freertos/demos/network_manager/: aws_iot_demo_network.c aws_iot_network_manager.c iot_network_manager_private.h
  group freertos-demos-greengrass_connectivity
    ../../../../../rtos/freertos/demos/greengrass_connectivity/: aws_greengrass_discovery_demo.c
  group freertos-demos-dev_mode_key_provisioning-include
    ../../../../../rtos/freertos/demos/dev_mode_key_provisioning/include/: aws_dev_mode_key_provisioning.h
  group freertos-demos-dev_mode_key_provisioning-src
    ../../../../../rtos/freertos/demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c
  group freertos-libraries-3rdparty-mbedtls-utils
    ../../../../../rtos/freertos/libraries/3rdparty/mbedtls/utils/: mbedtls_utils.c
  group freertos-freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos-freertos_kernel-include
    ../../../../../rtos/freertos/freertos_kernel/include/: croutine.h StackMacros.h atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos-freertos_kernel-portable-GCC-ARM_CM4F
    ../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos-freertos_kernel-portable-MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos-freertos_kernel-portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos-libraries-abstractions-platform-freertos-include-platform
    ../../../../../rtos/freertos/libraries/abstractions/platform/freertos/include/platform/: iot_network_ble.h iot_network_freertos.h iot_platform_types_freertos.h
  group freertos-libraries-abstractions-platform-freertos
    ../../../../../rtos/freertos/libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_metrics.c iot_network_freertos.c iot_threads_freertos.c
  group freertos-libraries-abstractions-platform-include-platform
    ../../../../../rtos/freertos/libraries/abstractions/platform/include/platform/: iot_clock.h iot_metrics.h iot_network.h iot_threads.h
  group freertos-libraries-abstractions-platform-include-types
    ../../../../../rtos/freertos/libraries/abstractions/platform/include/types/: iot_platform_types.h
  group freertos-libraries-c_sdk-aws-shadow-include
    ../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/include/: aws_iot_shadow.h aws_shadow.h
  group freertos-libraries-c_sdk-aws-shadow-include-types
    ../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/include/types/: aws_iot_shadow_types.h
  group freertos-libraries-c_sdk-aws-shadow-src
    ../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/src/: aws_iot_shadow_api.c aws_iot_shadow_operation.c aws_iot_shadow_parser.c aws_iot_shadow_static_memory.c aws_iot_shadow_subscription.c aws_shadow.c aws_shadow_config_defaults.h
  group freertos-libraries-c_sdk-aws-shadow-src-private
    ../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/src/private/: aws_iot_shadow_internal.h
  group freertos-libraries-c_sdk-standard-common-include
    ../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/: iot_appversion32.h iot_atomic.h iot_init.h iot_linear_containers.h iot_logging_setup.h iot_logging_task.h iot_taskpool.h
  group freertos-libraries-c_sdk-standard-common-include-private
    ../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/private/: iot_default_root_certificates.h iot_doubly_linked_list.h iot_error.h iot_lib_init.h iot_logging.h iot_static_memory.h iot_taskpool_internal.h
  group freertos-libraries-c_sdk-standard-common-include-types
    ../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/types/: iot_network_types.h iot_taskpool_types.h
  group freertos-libraries-c_sdk-standard-common
    ../../../../../rtos/freertos/libraries/c_sdk/standard/common/: iot_device_metrics.c iot_init.c iot_static_memory_common.c
  group freertos-libraries-c_sdk-standard-common-logging
    ../../../../../rtos/freertos/libraries/c_sdk/standard/common/logging/: iot_logging.c iot_logging_task_dynamic_buffers.c
  group freertos-libraries-c_sdk-standard-common-taskpool
    ../../../../../rtos/freertos/libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group freertos-libraries-c_sdk-standard-mqtt-include
    ../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/include/: iot_mqtt.h iot_mqtt_agent.h iot_mqtt_agent_config_defaults.h iot_mqtt_config_defaults.h iot_mqtt_lib.h
  group freertos-libraries-c_sdk-standard-mqtt-include-types
    ../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/include/types/: iot_mqtt_types.h
  group freertos-libraries-c_sdk-standard-mqtt-src
    ../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/src/: iot_mqtt_agent.c iot_mqtt_api.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_serialize.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_validate.c
  group freertos-libraries-c_sdk-standard-mqtt-src-private
    ../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/src/private/: iot_mqtt_internal.h
  group freertos-libraries-c_sdk-standard-serializer-include
    ../../../../../rtos/freertos/libraries/c_sdk/standard/serializer/include/: iot_json_utils.h iot_serializer.h
  group freertos-libraries-c_sdk-standard-serializer-src
    ../../../../../rtos/freertos/libraries/c_sdk/standard/serializer/src/: iot_json_utils.c iot_serializer_static_memory.c
  group freertos-libraries-c_sdk-standard-serializer-src-json
    ../../../../../rtos/freertos/libraries/c_sdk/standard/serializer/src/json/: iot_serializer_json_decoder.c iot_serializer_json_encoder.c
  group freertos-libraries-abstractions-secure_sockets-include
    ../../../../../rtos/freertos/libraries/abstractions/secure_sockets/include/: iot_secure_sockets.h iot_secure_sockets_config_defaults.h iot_secure_sockets_wrapper_metrics.h
  group freertos-libraries-freertos_plus-standard-crypto-include
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/crypto/include/: iot_crypto.h
  group freertos-libraries-freertos_plus-standard-crypto-src
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group freertos-libraries-freertos_plus-standard-pkcs11-include
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/pkcs11/include/: iot_pkcs11.h
  group freertos-libraries-freertos_plus-standard-pkcs11-src
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/pkcs11/src/: iot_pkcs11.c
  group freertos-libraries-freertos_plus-standard-utils-include
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/utils/include/: iot_pki_utils.h iot_system_init.h
  group freertos-libraries-freertos_plus-standard-utils-src
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/utils/src/: iot_pki_utils.c iot_system_init.c
  group freertos-libraries-freertos_plus-standard-tls-include
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/tls/include/: iot_tls.h
  group freertos-libraries-freertos_plus-standard-tls-src
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group freertos-libraries-abstractions-pkcs11-include
    ../../../../../rtos/freertos/libraries/abstractions/pkcs11/include/: iot_pkcs11_pal.h
  group freertos-libraries-abstractions-pkcs11-mbedtls
    ../../../../../rtos/freertos/libraries/abstractions/pkcs11/mbedtls/: iot_pkcs11_mbedtls.c threading_alt.h
  group freertos-libraries-3rdparty-pkcs11
    ../../../../../rtos/freertos/libraries/3rdparty/pkcs11/: pkcs11.h pkcs11f.h pkcs11t.h CONTRIBUTING.md LICENSE.md README.md
  group freertos-libraries-3rdparty-jsmn
    ../../../../../rtos/freertos/libraries/3rdparty/jsmn/: jsmn.c jsmn.h
  group freertos-vendors-nxp-pkcs11-common
    ../../../../../rtos/freertos/vendors/nxp/pkcs11/common/: iot_pkcs11_pal.c
  group mbedtls-include-mbedtls
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls-library
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c chacha20.c chachapoly.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls-port-ksdk
    ../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c ecp_alt.h ecp_alt.c ecp_curves_alt.c ecp_alt_ksdk.c
  group device
    ../../../../../devices/MIMXRT1024/: fsl_device_registers.h MIMXRT1024.h MIMXRT1024_features.h system_MIMXRT1024.c system_MIMXRT1024.h
  group component-uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component-serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component-lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1024/arm/: startup_MIMXRT1024.S
  group xip
    ../../../../../devices/MIMXRT1024/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1024_flexspi_nor_config.c evkmimxrt1024_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
target aws_greengrass_discovery_enet flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1024DAG5A NXP
  pack: NXP.MIMXRT1024_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: aws_greengrass_discovery_enet.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, CPU_MIMXRT1024DAG5A, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=0, USE_RTOS=1, MBEDTLS_CONFIG_FILE='\"aws_mbedtls_config.h\"', FSL_RTOS_FREE_RTOS, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../../..;..;../config_files
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1024xxxxx_flexspi_nor_sdram.scf
  link misc: as above
