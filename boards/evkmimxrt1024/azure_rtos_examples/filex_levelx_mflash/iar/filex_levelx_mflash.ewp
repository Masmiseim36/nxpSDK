# IAR project filex_levelx_mflash.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1024xxx5A NXP MIMXRT1024xxx5A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1024DAG5A; LX_USE_MFLASH; DEMO_DISK_FLASH_OFFSET=MFLASH_FILE_BASEADDR; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; SAMPLE_PACKET_COUNT=20; DATA_SECTION_IS_CACHEABLE=1; MCUXPRESSO_SDK; LX_THREAD_SAFE_ENABLE; MFLASH_FILE_BASEADDR=1572864; FX_INCLUDE_USER_DEFINE_FILE; TX_INCLUDE_USER_DEFINE_FILE; FSL_RTOS_THREADX
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../rtos/azure-rtos/levelx/common/inc; ../../../../../components/flash/mflash/mimxrt1024; ../../../../../devices/MIMXRT1024/drivers; ../../../../../devices/MIMXRT1024; ../../../../../devices/MIMXRT1024/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../devices/MIMXRT1024/utilities; ../../../../../devices/MIMXRT1024/xip; ../../../xip; ../../../../../rtos/azure-rtos/filex/common/inc; ../../../../../rtos/azure-rtos/filex/ports/generic/inc; ../../../../../rtos/azure-rtos/threadx/common/inc; ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/iar/inc; ../../../../../components/flash/mflash; ../../../../../CMSIS/Core/Include; ../../../../../devices/MIMXRT1024/utilities/str
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: filex_levelx_mflash.out
  ILINK.IlinkIcfFile: MIMXRT1024xxxxx_ram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../rtos/azure-rtos/binary/filex/cortex_m7/iar/libfilex.a; ../../../../../rtos/azure-rtos/binary/threadx/cortex_m7/iar/libthreadx.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1024DAG5A; LX_USE_MFLASH; DEMO_DISK_FLASH_OFFSET=MFLASH_FILE_BASEADDR; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; SAMPLE_PACKET_COUNT=20; DATA_SECTION_IS_CACHEABLE=1; MCUXPRESSO_SDK; LX_THREAD_SAFE_ENABLE; MFLASH_FILE_BASEADDR=1572864; FX_INCLUDE_USER_DEFINE_FILE; TX_INCLUDE_USER_DEFINE_FILE; FSL_RTOS_THREADX
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1024xxxxx_flexspi_nor.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1024DAG5A; LX_USE_MFLASH; DEMO_DISK_FLASH_OFFSET=MFLASH_FILE_BASEADDR; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; SAMPLE_PACKET_COUNT=20; DATA_SECTION_IS_CACHEABLE=1; MCUXPRESSO_SDK; LX_THREAD_SAFE_ENABLE; MFLASH_FILE_BASEADDR=1572864; FX_INCLUDE_USER_DEFINE_FILE; TX_INCLUDE_USER_DEFINE_FILE; FSL_RTOS_THREADX
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1024DAG5A; LX_USE_MFLASH; DEMO_DISK_FLASH_OFFSET=MFLASH_FILE_BASEADDR; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; SAMPLE_PACKET_COUNT=20; DATA_SECTION_IS_CACHEABLE=1; MCUXPRESSO_SDK; LX_THREAD_SAFE_ENABLE; MFLASH_FILE_BASEADDR=1572864; FX_INCLUDE_USER_DEFINE_FILE; TX_INCLUDE_USER_DEFINE_FILE; FSL_RTOS_THREADX
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1024xxxxx_flexspi_nor.icf
  group board
    ../: pin_mux.c pin_mux.h board_setup.c board_setup.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group source
    ../: filex_levelx_mflash.c lx_mflash_driver.c fx_levelx_driver.c fx_levelx_driver.h
  group azure-rtos/config
    ../: tx_user.h fx_user.h
  group azure-rtos/levelx/common/inc
    ../../../../../rtos/azure-rtos/levelx/common/inc/: lx_api.h lx_user_sample.h
  group azure-rtos/levelx/common/src
    ../../../../../rtos/azure-rtos/levelx/common/src/: fx_nand_flash_simulated_driver.c fx_nor_flash_simulator_driver.c lx_nand_flash_256byte_ecc_check.c lx_nand_flash_256byte_ecc_compute.c lx_nand_flash_block_allocate.c lx_nand_flash_block_data_move.c lx_nand_flash_block_find.c lx_nand_flash_block_mapping_set.c lx_nand_flash_block_status_set.c lx_nand_flash_close.c lx_nand_flash_data_page_copy.c lx_nand_flash_defragment.c lx_nand_flash_driver_block_erase.c lx_nand_flash_driver_block_erased_verify.c lx_nand_flash_driver_block_status_get.c lx_nand_flash_driver_block_status_set.c lx_nand_flash_driver_page_erased_verify.c lx_nand_flash_erase_count_set.c lx_nand_flash_extended_cache_enable.c lx_nand_flash_format.c lx_nand_flash_free_block_list_add.c lx_nand_flash_initialize.c lx_nand_flash_mapped_block_list_add.c lx_nand_flash_mapped_block_list_get.c lx_nand_flash_mapped_block_list_remove.c lx_nand_flash_memory_initialize.c lx_nand_flash_metadata_allocate.c lx_nand_flash_metadata_build.c lx_nand_flash_metadata_write.c lx_nand_flash_open.c lx_nand_flash_page_ecc_check.c lx_nand_flash_page_ecc_compute.c lx_nand_flash_partial_defragment.c lx_nand_flash_sector_read.c lx_nand_flash_sector_release.c lx_nand_flash_sector_write.c lx_nand_flash_sectors_read.c lx_nand_flash_sectors_release.c lx_nand_flash_sectors_write.c lx_nand_flash_simulator.c lx_nand_flash_system_error.c lx_nor_flash_block_reclaim.c lx_nor_flash_close.c lx_nor_flash_defragment.c lx_nor_flash_driver_block_erase.c lx_nor_flash_driver_read.c lx_nor_flash_driver_write.c lx_nor_flash_extended_cache_enable.c lx_nor_flash_initialize.c lx_nor_flash_logical_sector_find.c lx_nor_flash_next_block_to_erase_find.c lx_nor_flash_open.c lx_nor_flash_partial_defragment.c lx_nor_flash_physical_sector_allocate.c lx_nor_flash_sector_mapping_cache_invalidate.c lx_nor_flash_sector_read.c lx_nor_flash_sector_release.c lx_nor_flash_sector_write.c lx_nor_flash_simulator.c lx_nor_flash_system_error.c
  group azure-rtos/filex/common/inc
    ../../../../../rtos/azure-rtos/filex/common/inc/: fx_api.h fx_directory.h fx_fault_tolerant.h fx_file.h fx_media.h fx_system.h fx_unicode.h fx_user_sample.h fx_utility.h
  group azure-rtos/filex/ports/generic/inc
    ../../../../../rtos/azure-rtos/filex/ports/generic/inc/: fx_port.h
  group azure-rtos/threadx/common/inc
    ../../../../../rtos/azure-rtos/threadx/common/inc/: tx_api.h tx_block_pool.h tx_byte_pool.h tx_event_flags.h tx_initialize.h tx_mutex.h tx_queue.h tx_semaphore.h tx_thread.h tx_timer.h tx_trace.h tx_user_sample.h
  group azure-rtos/threadx/ports/cortex_m7/iar/inc
    ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/iar/inc/: tx_port.h
  group azure-rtos/threadx/ports/cortex_m7/iar/src
    ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/iar/src/: tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_schedule.s tx_thread_stack_build.s tx_thread_system_return.s tx_timer_interrupt.s
  group azure-rtos/threadx/ports/common
    ../../../../../rtos/azure-rtos/threadx/ports/common/: tx_initialize_low_level.c
  group doc
    ../: readme.md
  group flash/mflash
    ../../../../../components/flash/mflash/: mflash_common.h
  group flash/mflash/mimxrt1024
    ../../../../../components/flash/mflash/mimxrt1024/: mflash_drv.h mflash_drv.c
  group drivers
    ../../../../../devices/MIMXRT1024/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h
  group device
    ../../../../../devices/MIMXRT1024/: fsl_device_registers.h MIMXRT1024.h MIMXRT1024_features.h system_MIMXRT1024.c system_MIMXRT1024.h
  group utilities
    ../../../../../devices/MIMXRT1024/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1024/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../devices/MIMXRT1024/utilities/str/: fsl_str.c fsl_str.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1024/iar/: startup_MIMXRT1024.s
  group xip
    ../../../../../devices/MIMXRT1024/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1024_flexspi_nor_config.c evkmimxrt1024_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
