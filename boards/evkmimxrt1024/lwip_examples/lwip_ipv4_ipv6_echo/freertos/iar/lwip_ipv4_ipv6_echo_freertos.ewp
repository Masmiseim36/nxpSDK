# IAR project lwip_ipv4_ipv6_echo_freertos.ewp, settings and files
configuration flexspi_nor_sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1024xxx5A NXP MIMXRT1024xxx5A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; DEBUG; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; XIP_EXTERNAL_FLASH=1; USE_SDRAM=1; SKIP_SYSCLK_INIT=1; DATA_SECTION_IS_CACHEABLE=1; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; SHELL_TASK_STACK_SIZE=2048; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1024DAG5A; MIMXRT1024_SERIES; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; OSA_USED; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../xip; ../../../../../../devices/MIMXRT1024/drivers; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT1024; ../../../../../../devices/MIMXRT1024/periph; ../../../../../../devices/MIMXRT1024/xip; ../../../../../../devices/MIMXRT1024/utilities/debug_console; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1024/utilities/str; ../../../../../../components/silicon_id; ../../../../../../components/silicon_id/socs; ../../../../../../devices/MIMXRT1024/utilities/shell; ../../../../../../components/serial_manager; ../../../../../../components/gpio; ../../../../../../components/uart; ../../../../../../components/osa; ../../../../../../components/phy; ../../../../../../components/phy/device/phyksz8081; ../../../../../../middleware/lwip/port; ../../../../../../middleware/lwip/src/include; ../../../../../../middleware/lwip/port/sys_arch/dynamic; ../../../../../../middleware/lwip/contrib/apps/tcpecho; ../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F; ../../../../../../rtos/freertos/freertos-kernel/template
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT1024DAG5A; MIMXRT1024_SERIES; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; OSA_USED
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: lwip_ipv4_ipv6_echo_freertos.out
  ILINK.IlinkConfigDefines: __stack_size__=2048; __heap_size__=35840
  ILINK.IlinkIcfFile: MIMXRT1024xxxxx_flexspi_nor_sdram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; NDEBUG; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; XIP_EXTERNAL_FLASH=1; USE_SDRAM=1; SKIP_SYSCLK_INIT=1; DATA_SECTION_IS_CACHEABLE=1; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; SHELL_TASK_STACK_SIZE=2048; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1024DAG5A; MIMXRT1024_SERIES; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; OSA_USED; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  group source
    ../: shell_task.c shell_task.h shell_task_mode.h socket_task.c socket_task.h lwip_ipv4_ipv6_echo_freertos.c lwipopts.h FreeRTOSConfig_Gen.h fsl_debug_console_conf.h fsl_os_abstraction_config.h lwipopts_gen.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group xip
    ../../../../xip/: evkmimxrt1024_flexspi_nor_config.c evkmimxrt1024_flexspi_nor_config.h
    ../../../../: dcd.c dcd.h
    ../../../../../../devices/MIMXRT1024/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group drivers
    ../../../../../../devices/MIMXRT1024/drivers/: fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_enet.h fsl_enet.c fsl_gpc.c fsl_gpc.h fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_pmu.h fsl_pmu.c fsl_src.c fsl_src.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv7m_cachel1.h armv7m_mpu.h
  group device
    ../../../../../../devices/MIMXRT1024/: fsl_device_registers.h MIMXRT1024.h MIMXRT1024_features.h MIMXRT1024_COMMON.h system_MIMXRT1024.c system_MIMXRT1024.h
  group device/periph
    ../../../../../../devices/MIMXRT1024/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_AIPSTZ.h PERI_AOI.h PERI_BEE.h PERI_CAN.h PERI_CCM.h PERI_CCM_ANALOG.h PERI_CM7_MCM.h PERI_CMP.h PERI_CSU.h PERI_DCDC.h PERI_DCP.h PERI_DMA.h PERI_DMAMUX.h PERI_ENC.h PERI_ENET.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_KPP.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_OCOTP.h PERI_PGC.h PERI_PIT.h PERI_PMU.h PERI_PWM.h PERI_RTWDOG.h PERI_SEMC.h PERI_SNVS.h PERI_SPDIF.h PERI_SRC.h PERI_TEMPMON.h PERI_TMR.h PERI_TRNG.h PERI_USB.h PERI_USBNC.h PERI_USBPHY.h PERI_USB_ANALOG.h PERI_USDHC.h PERI_WDOG.h PERI_XBARA.h PERI_XBARB.h PERI_XTALOSC24M.h
  group startup/iar
    ../../../../../../devices/MIMXRT1024/iar/: startup_MIMXRT1024.s
  group utilities
    ../../../../../../devices/MIMXRT1024/utilities/debug_console/: fsl_assert.h fsl_assert.c
    ../../../../../../devices/MIMXRT1024/utilities/shell/: fsl_shell.h fsl_shell.c
  group utilities/str
    ../../../../../../devices/MIMXRT1024/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console
    ../../../../../../devices/MIMXRT1024/utilities/debug_console/: fsl_debug_console.h fsl_debug_console.c
  group component
    ../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/silicon_id
    ../../../../../../components/silicon_id/: fsl_silicon_id.h fsl_silicon_id.c
    ../../../../../../components/silicon_id/socs/rt10xx/: fsl_silicon_id_soc.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/gpio
    ../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h
  group component/phy
    ../../../../../../components/phy/: fsl_phy.h
    ../../../../../../components/phy/device/phyksz8081/: fsl_phyksz8081.c fsl_phyksz8081.h
  group lwip/port
    ../../../../../../middleware/lwip/port/: enet_ethernetif.c ethernetif.c ethernetif.h ethernetif_mmac.c ethernetif_mmac.h ethernetif_priv.h kinetis_configchecks.h enet_ethernetif_kinetis.c
  group lwip/port/arch
    ../../../../../../middleware/lwip/port/arch/: cc.h perf.h
  group lwip/port/sys_arch/dynamic
    ../../../../../../middleware/lwip/port/sys_arch/dynamic/: sys_arch.c
  group lwip/port/sys_arch/dynamic/arch
    ../../../../../../middleware/lwip/port/sys_arch/dynamic/arch/: sys_arch.h
  group lwip/src/api
    ../../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/core
    ../../../../../../middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/src/core/ipv4
    ../../../../../../middleware/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/src/core/ipv6
    ../../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip/src/include/compat/posix
    ../../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/compat/posix/net
    ../../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/sys
    ../../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/stdc
    ../../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/lwip
    ../../../../../../middleware/lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/priv
    ../../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h memp_priv.h memp_std.h mem_priv.h nd6_priv.h raw_priv.h sockets_priv.h tcpip_priv.h tcp_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../../middleware/lwip/src/include/lwip/prot/: acd.h autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip/src/include/netif
    ../../../../../../middleware/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lwip/src/include/netif/ppp
    ../../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h ppp_impl.h ppp_opts.h upap.h vj.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip/src/netif
    ../../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lwip/src/netif/ppp/polarssl
    ../../../../../../middleware/lwip/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
  group lwip/contrib/apps/tcpecho
    ../../../../../../middleware/lwip/contrib/apps/tcpecho/: tcpecho.c tcpecho.h
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_3.c
  group freertos/freertos-kernel/portable/IAR/ARM_CM4F
    ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos-kernel/template
    ../../../../../../rtos/freertos/freertos-kernel/template/: FreeRTOSConfig.h
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
