# IAR project lwip_udpecho_freertos.ewp, settings and files
configuration flexspi_nor_sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1024xxx5A NXP MIMXRT1024xxx5A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1024DAG5A; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F; ..; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../rtos/freertos/freertos_kernel/include; ../../../../../../components/phy/mdio/enet; ../../../../../../components/phy/device/phyksz8081; ../../../../../../devices/MIMXRT1024/drivers; ../../../../../../middleware/lwip/contrib/apps/udpecho; ../../../../../../middleware/lwip/port; ../../../../../../middleware/lwip/src; ../../../../../../middleware/lwip/src/include; ../../../../../../devices/MIMXRT1024/utilities/str; ../../../../../../devices/MIMXRT1024/utilities/debug_console; ../../../../../../devices/MIMXRT1024; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1024/xip; ../../../../xip; ../../../../../../components/phy; ../../../../../../devices/MIMXRT1024/utilities
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../../../..
  ILINK.IlinkOutputFile: lwip_udpecho_freertos.out
  ILINK.IlinkConfigDefines: __stack_size__=2048; __heap_size__=25600
  ILINK.IlinkIcfFile: MIMXRT1024xxxxx_flexspi_nor_sdram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1024DAG5A; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: lwip_udpecho_freertos.c lwipopts.h FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.txt
  group mdio
    ../../../../../../components/phy/mdio/enet/: fsl_enet_mdio.h fsl_enet_mdio.c
    ../../../../../../components/phy/: fsl_mdio.h
  group phy
    ../../../../../../components/phy/device/phyksz8081/: fsl_phyksz8081.h fsl_phyksz8081.c
    ../../../../../../components/phy/: fsl_phy.h
  group drivers
    ../../../../../../devices/MIMXRT1024/drivers/: fsl_cache.c fsl_cache.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_enet.h fsl_enet.c
  group lwip/contrib/apps/udpecho
    ../../../../../../middleware/lwip/contrib/apps/udpecho/: udpecho.c udpecho.h
  group lwip/port
    ../../../../../../middleware/lwip/port/: sys_arch.c enet_ethernetif.c enet_ethernetif.h enet_ethernetif_priv.h enet_ethernetif_kinetis.c
  group lwip/port/arch
    ../../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src/api
    ../../../../../../middleware/lwip/src/api/: api_lib.c netdb.c tcpip.c api_msg.c err.c netifapi.c sockets.c if_api.c netbuf.c
  group lwip/src/core
    ../../../../../../middleware/lwip/src/core/: dns.c memp.c sys.c tcp.c raw.c init.c altcp_alloc.c udp.c timeouts.c tcp_in.c altcp.c pbuf.c stats.c ip.c inet_chksum.c altcp_tcp.c netif.c def.c mem.c tcp_out.c
  group lwip/src/core/ipv4
    ../../../../../../middleware/lwip/src/core/ipv4/: ip4_addr.c etharp.c dhcp.c ip4_frag.c ip4.c acd.c icmp.c autoip.c igmp.c
  group lwip/src/core/ipv6
    ../../../../../../middleware/lwip/src/core/ipv6/: ip6_addr.c nd6.c ethip6.c ip6_frag.c inet6.c ip6.c dhcp6.c mld6.c icmp6.c
  group lwip/src/include/compat/stdc
    ../../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/compat/posix
    ../../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/net
    ../../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/compat/posix/sys
    ../../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/lwip
    ../../../../../../middleware/lwip/src/include/lwip/: tcpbase.h altcp.h udp.h ip4_frag.h netifapi.h ip6_frag.h altcp_tcp.h stats.h ethip6.h netbuf.h pbuf.h err.h errno.h ip.h netdb.h dhcp6.h netif.h ip6_zone.h icmp6.h sys.h acd.h ip4_addr.h icmp.h sio.h ip6.h snmp.h arch.h tcpip.h ip_addr.h altcp_tls.h igmp.h raw.h init.h ip6_addr.h if_api.h api.h sockets.h ip4.h mld6.h inet_chksum.h dhcp.h nd6.h mem.h memp.h autoip.h def.h etharp.h debug.h opt.h dns.h timeouts.h tcp.h inet.h
  group lwip/src/include/lwip/priv
    ../../../../../../middleware/lwip/src/include/lwip/priv/: raw_priv.h memp_priv.h altcp_priv.h mem_priv.h memp_std.h nd6_priv.h tcp_priv.h sockets_priv.h tcpip_priv.h api_msg.h
  group lwip/src/include/lwip/prot
    ../../../../../../middleware/lwip/src/include/lwip/prot/: udp.h ieee.h ip.h dhcp6.h icmp6.h acd.h icmp.h ip6.h igmp.h ip4.h mld6.h dhcp.h nd6.h autoip.h etharp.h iana.h dns.h ethernet.h tcp.h
  group lwip/src/include/netif
    ../../../../../../middleware/lwip/src/include/netif/: slipif.h lowpan6_ble.h lowpan6_common.h bridgeif_opts.h lowpan6.h ieee802154.h bridgeif.h etharp.h zepif.h ethernet.h lowpan6_opts.h
  group lwip/src/include/netif/ppp
    ../../../../../../middleware/lwip/src/include/netif/ppp/: upap.h pppol2tp.h ppp.h pppdebug.h ipv6cp.h chap-new.h ppp_impl.h ppp_opts.h eap.h ipcp.h chap_ms.h pppcrypt.h mppe.h pppoe.h pppapi.h ccp.h vj.h lcp.h eui64.h magic.h fsm.h ecp.h pppos.h chap-md5.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: sha1.h md4.h arc4.h des.h md5.h
  group lwip/src/netif
    ../../../../../../middleware/lwip/src/netif/: slipif.c bridgeif_fdb.c ethernet.c lowpan6_common.c bridgeif.c lowpan6_ble.c lowpan6.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../../middleware/lwip/src/netif/ppp/: lcp.c pppos.c mppe.c magic.c vj.c chap-new.c ccp.c lwip_ecp.c ipv6cp.c eap.c pppapi.c ppp.c chap-md5.c ipcp.c pppol2tp.c multilink.c pppcrypt.c demand.c pppoe.c utils.c chap_ms.c upap.c auth.c fsm.c eui64.c
  group utilities
    ../../../../../../devices/MIMXRT1024/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1024/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1024/utilities/: fsl_assert.c
  group freertos/freertos_kernel
    ../../../../../../rtos/freertos/freertos_kernel/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_3.c ReadMe.url
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/include
    ../../../../../../rtos/freertos/freertos_kernel/include/: croutine.h StackMacros.h atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group device
    ../../../../../../devices/MIMXRT1024/: fsl_device_registers.h MIMXRT1024.h MIMXRT1024_features.h system_MIMXRT1024.c system_MIMXRT1024.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMXRT1024/iar/: startup_MIMXRT1024.s
  group xip
    ../../../../../../devices/MIMXRT1024/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1024_flexspi_nor_config.c evkmimxrt1024_flexspi_nor_config.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
