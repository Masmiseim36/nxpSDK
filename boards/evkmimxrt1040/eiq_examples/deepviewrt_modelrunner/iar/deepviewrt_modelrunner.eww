<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>deepviewrt_modelrunner</project>
        <configuration>flexspi_nor_sdram_release</configuration>
      </member>
      <member>
        <project>deepviewrt_modelrunner</project>
        <configuration>flexspi_nor_sdram_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_sdram_release</name>
      <member>
        <project>deepviewrt_modelrunner</project>
        <configuration>flexspi_nor_sdram_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_sdram_debug</name>
      <member>
        <project>deepviewrt_modelrunner</project>
        <configuration>flexspi_nor_sdram_debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/deepviewrt_modelrunner.ewp</path>
  </project>
</workspace>
