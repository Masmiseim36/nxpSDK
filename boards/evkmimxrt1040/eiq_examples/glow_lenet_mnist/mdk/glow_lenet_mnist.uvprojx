# Keil uVision project glow_lenet_mnist.uvprojx, settings and files
target glow_lenet_mnist flexspi_nor_sdram_debug (ARM-ADS)
  device: MIMXRT1042XJM5B NXP
  pack: NXP.MIMXRT1042_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: glow_lenet_mnist.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, DEBUG, CPU_MIMXRT1042XJM5B, ARM_MATH_CM7, __FPU_PRESENT=1, PRINTF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SDK_DEBUGCONSOLE=1, FSL_RTOS_BM, SDK_OS_BAREMETAL, CPU_MIMXRT1042XJM5B_cm7, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../source;..;../../../../../devices/MIMXRT1042/utilities/str;../../../../../devices/MIMXRT1042/utilities/debug_console_lite;../../../../../middleware/eiq/glow/bundle_utils;../../../../../components/lists;../../../../../components/uart;../../../../../devices/MIMXRT1042/drivers;../../../../../devices/MIMXRT1042;../../../../../devices/MIMXRT1042/xip;../../../xip;../../../../../CMSIS/Core/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ../../../../../devices/MIMXRT1042/arm/MIMXRT1042xxxxx_flexspi_nor_sdram.scf
  link misc: --remove --entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group source
    ../source/: lenet_mnist.h lenet_mnist.o lenet_mnist.weights.bin lenet_mnist.weights.txt input_image.inc main.c timer.c timer.h
  group doc
    ../doc/: readme.txt
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h peripherals.h peripherals.c dcd.c dcd.h
    ./: retarget.c
  group scripts
    ../scripts/: glow_process_image.py glow_process_sound.py glow_show_detections.py glow_show_segmentation.py
  group utilities
    ../../../../../devices/MIMXRT1042/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1042/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group eiq/glow/bundle_utils
    ../../../../../middleware/eiq/glow/bundle_utils/: glow_bundle_utils.h glow_bundle_utils.c
  group eiq/glow
    ../../../../../middleware/eiq/glow/: readme.txt LICENSE.txt
  group eiq/glow/examples/common
    ../../../../../middleware/eiq/glow/examples/common/: glow_process_image.py
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group drivers
    ../../../../../devices/MIMXRT1042/drivers/: fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_iomuxc.h
  group device
    ../../../../../devices/MIMXRT1042/: fsl_device_registers.h MIMXRT1042.h MIMXRT1042_features.h system_MIMXRT1042.c system_MIMXRT1042.h
  group startup
    ../../../../../devices/MIMXRT1042/arm/: startup_MIMXRT1042.S
  group xip
    ../../../../../devices/MIMXRT1042/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1040_flexspi_nor_config.c evkmimxrt1040_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
target glow_lenet_mnist flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1042XJM5B NXP
  pack: NXP.MIMXRT1042_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: glow_lenet_mnist.out
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, CPU_MIMXRT1042XJM5B, ARM_MATH_CM7, __FPU_PRESENT=1, PRINTF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SDK_DEBUGCONSOLE=1, FSL_RTOS_BM, SDK_OS_BAREMETAL, CPU_MIMXRT1042XJM5B_cm7, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: as above
  link misc: as above
