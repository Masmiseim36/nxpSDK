# Keil uVision project wifi_cert.uvprojx, settings and files
target wifi_cert flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1042XJM5B NXP
  pack: NXP.MIMXRT1042_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: wifi_cert.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1042XJM5B, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, MCUXPRESSO_SDK, SDIO_ENABLED, SDK_OS_FREE_RTOS, SO_REUSE=1, SERIAL_PORT_TYPE_UART=1, LWIP_DNS=1, LWIP_NETIF_HOSTNAME=1, LWIP_NETIF_STATUS_CALLBACK=1, LWIP_IGMP=1
  c misc: -include ../app_config.h -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../common;../../..;../../../../../devices/MIMXRT1042/drivers;../../../../../middleware/wifi_nxp/incl;../../../../../middleware/wifi_nxp/incl/wlcmgr;../../../../../middleware/wifi_nxp/wifidriver;../../../../../middleware/wifi_nxp/wifidriver/incl;../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if;../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if/incl;../../../../../middleware/wifi_nxp/certs;../../../../../middleware/wifi_nxp/firmware_dnld;../../../../../middleware/wifi_nxp/sdio_nxp_abs;../../../../../middleware/wifi_nxp/sdio_nxp_abs/incl;../../../../../middleware/sdmmc/host/usdhc;../../../../../middleware/sdmmc/sdio;../../../../../components/gpio;../../../../../rtos/freertos/freertos-kernel/include;../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F;../../../../../middleware/wifi_nxp/dhcpd;../../../../../middleware/wifi_nxp/incl/port/lwip;../../../../../middleware/wifi_nxp/port/lwip;../../../../../middleware/wifi_nxp/incl/port/lwip/hooks;../../../../../middleware/lwip/port;../../../../../middleware/lwip/src;../../../../../middleware/lwip/src/include;../../../../../middleware/lwip/src/include/lwip/apps;../../../../../middleware/wifi_nxp/cli;../../../../../devices/MIMXRT1042;../../../../../devices/MIMXRT1042/utilities/str;../../../../../devices/MIMXRT1042/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../devices/MIMXRT1042/utilities;../../../../../devices/MIMXRT1042/xip;../../../xip;../../../../../middleware/wifi_nxp/incl/wifidriver;../../../../../middleware/wifi_nxp/incl/port/os;../../../../../middleware/wifi_nxp/wifi_bt_firmware;../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits;../../../../../components/wifi_bt_module/Murata/tx_pwr_limits;../../../../../components/wifi_bt_module/u-blox/tx_pwr_limits;../../../../../components/wifi_bt_module/incl;../../../../../middleware/wifi_nxp/wifi_bt_firmware/8801;../../../../../middleware/wifi_nxp/wifi_bt_firmware/IW416;../../../../../middleware/wifi_nxp/wifi_bt_firmware/8987;../../../../../middleware/wifi_nxp/wifi_bt_firmware/nw61x;../../../../../middleware/wifi_nxp/fwdnld_intf_abs;../../../../../middleware/sdmmc/common;../../../../../middleware/sdmmc/osa;../../../../../components/osa;../../../../../CMSIS/Core/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../..;../../common
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: linker/MIMXRT1042xxxxx_flexspi_nor.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314 --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-D__stack_size__=0x400" --predefine="-D__heap_size__=0x400"
  group source
    ../: main.c lwipopts.h lwippools.h FreeRTOSConfig.h wifi_config.h app_config.h
  group board
    ../: pin_mux.c pin_mux.h sdmmc_config.c sdmmc_config.h wifi_bt_config.c wifi_bt_config.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.md
  group drivers
    ../../../../../devices/MIMXRT1042/drivers/: fsl_cache.c fsl_cache.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_usdhc.c fsl_usdhc.h
  group wifi/wifidriver
    ../../../../../middleware/wifi_nxp/wifidriver/: wifi-sdio.c mlan_11ac.c mlan_11ax.c mlan_11d.c mlan_11h.c mlan_11n.c mlan_11n_aggr.c mlan_11n_rxreorder.c mlan_11v.c mlan_action.c mlan_11k.c mlan_mbo.c mlan_api.c mlan_cfp.c mlan_cmdevt.c mlan_glue.c mlan_init.c mlan_join.c mlan_misc.c mlan_scan.c mlan_shim.c mlan_sta_cmd.c mlan_sta_cmdresp.c mlan_sta_event.c mlan_sta_ioctl.c mlan_sta_rx.c mlan_txrx.c mlan_uap_cmdevent.c mlan_uap_ioctl.c mlan_wmm.c wifi-debug.c wifi-debug.h wifi-internal.h wifi-mem.c wifi-uap.c wifi.c wifi_common.h wifi_pwrmgr.c wifi-wps.c wifi-sdio.h sdio.c sdio.h
  group wifi/incl
    ../../../../../middleware/wifi_nxp/incl/: dhcp-server.h wmstats.h cli.h cli_utils.h iperf.h wifi_ping.h wifi_cal_data_ext.h wm_utils.h wmerrno.h wmlog.h wmtypes.h WIFI_IW416_BOARD_AW_AM457_CAL_DATA_EXT.h
  group wifi/incl/wlcmgr
    ../../../../../middleware/wifi_nxp/incl/wlcmgr/: wlan.h wlan_11d.h wlan_tests.h
  group wifi/incl/wifidriver
    ../../../../../middleware/wifi_nxp/incl/wifidriver/: wifi_nxp.h wifi-decl.h wifi.h wifi_events.h
  group wifi/wifidriver/incl
    ../../../../../middleware/wifi_nxp/wifidriver/incl/: mlan.h mlan_11ac.h mlan_11ax.h mlan_11h.h mlan_11n.h mlan_11n_aggr.h mlan_11n_rxreorder.h mlan_11v.h mlan_action.h mlan_11k.h mlan_mbo.h mlan_api.h mlan_fw.h mlan_ieee.h mlan_init.h mlan_join.h mlan_main.h mlan_meas.h mlan_remap_mem_operations.h mlan_uap.h mlan_util.h mlan_wmm.h type_decls.h mlan_decl.h mlan_ioctl.h mlan_main_defs.h
  group wifi/wifidriver/wpa_supp_if/incl
    ../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if/incl/: rtos_wpa_supp_if.h wifi_nxp_internal.h
  group wifi/wifidriver/wpa_supp_if
    ../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if/: wifi_nxp.c rtos_wpa_supp_if.c wifi_nxp_internal.c
  group wifi/certs
    ../../../../../middleware/wifi_nxp/certs/: ca-cert.h client-cert.h client-key.h server-cert.h server-key.h dh-param.h
  group sdmmc/host
    ../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt ChangeLogKSDK.txt
    ../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group sdmmc/src
    ../../../../../middleware/sdmmc/sdio/: fsl_sdio.c
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc/sdio/: fsl_sdio.h
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sdio
    ../../../../../middleware/sdmmc/sdio/: ChangeLogKSDK.txt
  group component/gpio
    ../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group freertos/freertos-kernel
    ../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable/GCC/ARM_CM4F
    ../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable
    ../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group wifi/dhcpd
    ../../../../../middleware/wifi_nxp/dhcpd/: dhcp-bootp.h dhcp-priv.h dhcp-server-main.c dhcp-server.c dns-server.c dns.h dhcp-server-cli.c
  group wifi/incl/port/lwip
    ../../../../../middleware/wifi_nxp/incl/port/lwip/: wm_net.h
  group wifi/port/lwip
    ../../../../../middleware/wifi_nxp/port/lwip/: net.c netif_decl.h wifi_netif.c
  group wifi/wlcmgr
    ../../../../../middleware/wifi_nxp/wlcmgr/: wlan.c wlan_txpwrlimit_cfg.c wlan_basic_cli.c wlan_enhanced_tests.c wlan_tests.c wlan_test_mode_tests.c
  group wifi/incl/port/lwip/hooks
    ../../../../../middleware/wifi_nxp/incl/port/lwip/hooks/: lwip_default_hooks.h
  group wifi/port/lwip/hooks
    ../../../../../middleware/wifi_nxp/port/lwip/hooks/: lwip_default_hooks.c
  group lwip/port
    ../../../../../middleware/lwip/port/: sys_arch.c
  group lwip/port/arch
    ../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src/api
    ../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/core
    ../../../../../middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/src/core/ipv4
    ../../../../../middleware/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/src/core/ipv6
    ../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip/src/include/compat/posix/arpa
    ../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/compat/posix/net
    ../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix
    ../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/sys
    ../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/stdc
    ../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/lwip
    ../../../../../middleware/lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/priv
    ../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../middleware/lwip/src/include/lwip/prot/: acd.h autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip/src/include/netif
    ../../../../../middleware/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lwip/src/include/netif/ppp
    ../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip/src/netif
    ../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lwip/src/apps/lwiperf
    ../../../../../middleware/lwip/src/apps/lwiperf/: lwiperf.c
  group lwip/src/include/lwip/apps
    ../../../../../middleware/lwip/src/include/lwip/apps/: lwiperf.h
  group wifi/cli
    ../../../../../middleware/wifi_nxp/cli/: cli_mem.h cli.c cli_mem_simple.c cli_utils.c
  group wifi/nw_utils
    ../../../../../middleware/wifi_nxp/nw_utils/: wifi_ping.c iperf.c
  group wifi/port/os
    ../../../../../middleware/wifi_nxp/port/os/: os_cli.c os.c
  group device
    ../../../../../devices/MIMXRT1042/: fsl_device_registers.h MIMXRT1042.h MIMXRT1042_features.h system_MIMXRT1042.c system_MIMXRT1042.h
  group utilities
    ../../../../../devices/MIMXRT1042/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1042/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1042/utilities/: fsl_assert.c fsl_assert.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1042/arm/: startup_MIMXRT1042.S
  group xip
    ../../../../../devices/MIMXRT1042/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1040_flexspi_nor_config.c evkmimxrt1040_flexspi_nor_config.h
  group wifi/sdio_nxp_abs
    ../../../../../middleware/wifi_nxp/sdio_nxp_abs/: mlan_sdio.c fwdnld_sdio.c
  group wifi/sdio_nxp_abs/incl
    ../../../../../middleware/wifi_nxp/sdio_nxp_abs/incl/: fwdnld_sdio.h mlan_sdio_defs.h mlan_sdio.h mlan_sdio_api.h
  group wifi/incl/port/os
    ../../../../../middleware/wifi_nxp/incl/port/os/: wm_os.h
  group wifi/wifi_bt_firmware
    ../../../../../middleware/wifi_nxp/wifi_bt_firmware/: wlan_bt_fw.h
  group component/wifi_bt_module/AzureWave/tx_pwr_limits
    ../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits/: wlan_txpwrlimit_cfg_WW.h wlan_txpwrlimit_cfg_WW_rw610.h
  group component/wifi_bt_module/Murata/tx_pwr_limits
    ../../../../../components/wifi_bt_module/Murata/tx_pwr_limits/: wlan_txpwrlimit_cfg_murata_1XK_WW.h wlan_txpwrlimit_cfg_murata_1ZM_WW.h wlan_txpwrlimit_cfg_murata_2DS_WW.h wlan_txpwrlimit_cfg_murata_2EL_WW.h
  group component/wifi_bt_module/u-blox/tx_pwr_limits
    ../../../../../components/wifi_bt_module/u-blox/tx_pwr_limits/: wlan_txpwrlimit_cfg_jody_w5_WW.h
  group component/wifi_bt_module/incl
    ../../../../../components/wifi_bt_module/incl/: wifi_bt_module_config.h
  group wifi/wifi_bt_firmware/8801
    ../../../../../middleware/wifi_nxp/wifi_bt_firmware/8801/: sd8801_wlan.h
  group wifi/wifi_bt_firmware/IW416
    ../../../../../middleware/wifi_nxp/wifi_bt_firmware/IW416/: sduartIW416_wlan_bt.h sdIW416_wlan.h uartIW416_bt.h
  group wifi/wifi_bt_firmware/8987
    ../../../../../middleware/wifi_nxp/wifi_bt_firmware/8987/: sduart8987_wlan_bt.h sd8987_wlan.h uart8987_bt.h
  group wifi/wifi_bt_firmware/nw61x
    ../../../../../middleware/wifi_nxp/wifi_bt_firmware/nw61x/: sduart_nw61x_se.h sd_nw61x_se.h uart_nw61x_se.h
  group wifi/firmware_dnld
    ../../../../../middleware/wifi_nxp/firmware_dnld/: firmware_dnld.c firmware_dnld.h
  group wifi/fwdnld_intf_abs
    ../../../../../middleware/wifi_nxp/fwdnld_intf_abs/: fwdnld_intf_abs.c fwdnld_intf_abs.h
  group sdmmc/osa
    ../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h fsl_os_abstraction_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
target wifi_cert flexspi_nor_release (ARM-ADS)
  device: MIMXRT1042XJM5B NXP
  pack: NXP.MIMXRT1042_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: wifi_cert.out
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1042XJM5B, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, MCUXPRESSO_SDK, SDIO_ENABLED, SDK_OS_FREE_RTOS, SO_REUSE=1, SERIAL_PORT_TYPE_UART=1, LWIP_DNS=1, LWIP_NETIF_HOSTNAME=1, LWIP_NETIF_STATUS_CALLBACK=1, LWIP_IGMP=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../..;../../common
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: linker/MIMXRT1042xxxxx_flexspi_nor.scf
  link misc: as above
