# IAR project usb_pd_freertos.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1042xxx5B NXP MIMXRT1042xxx5B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; _DEBUG=1; CPU_MIMXRT1042XJM5B; DEBUG_CONSOLE_TRANSMIT_BUFFER_LEN=600; NDEBUG; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; SDK_OS_FREE_RTOS; DEBUG_CONSOLE_ASSERT_DISABLE=1; I2C_RETRY_TIMES=40000; USB_STACK_FREERTOS_HEAP_SIZE=8192; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; TIMER_PORT_TYPE_GPT=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../evkmimxrt1040; ../../../../../../components/i2c; ../../../../../../devices/MIMXRT1042/drivers; ../../../../../../middleware/usb/pd/ptn5110; ../../../../../../middleware/usb/pd; ../../../../../../middleware/usb/pd/phy_interface; ../../../../../../components/osa; ../../../../../../components/timer; ../../../../../../components/gpio; ../../../../../../components/lists; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../devices/MIMXRT1042; ../../../../../evkmimxrt1040/xip; ../../../../../../devices/MIMXRT1042/xip; ../../../../../../devices/MIMXRT1042/utilities; ../../../../../../devices/MIMXRT1042/utilities/debug_console; ../../../../../../middleware/usb/include; ../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F; ../../../../../../CMSIS/Core/Include; ../../../../../../devices/MIMXRT1042/utilities/str
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../../../../../evkmimxrt1040; ../../../../../../rtos/freertos/freertos-kernel/include
  ILINK.IlinkOutputFile: usb_pd_freertos.out
  ILINK.IlinkConfigDefines: __stack_size__=0x800; __heap_size__=0x1000
  ILINK.IlinkIcfFile: MIMXRT1042xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1042XJM5B; DEBUG_CONSOLE_TRANSMIT_BUFFER_LEN=600; NDEBUG; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; SDK_OS_FREE_RTOS; DEBUG_CONSOLE_ASSERT_DISABLE=1; I2C_RETRY_TIMES=40000; USB_STACK_FREERTOS_HEAP_SIZE=8192; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; TIMER_PORT_TYPE_GPT=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1042xxxxx_flexspi_nor.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; DEBUG; CPU_MIMXRT1042XJM5B; DEBUG_CONSOLE_TRANSMIT_BUFFER_LEN=600; NDEBUG; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; SDK_OS_FREE_RTOS; DEBUG_CONSOLE_ASSERT_DISABLE=1; I2C_RETRY_TIMES=40000; USB_STACK_FREERTOS_HEAP_SIZE=8192; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; TIMER_PORT_TYPE_GPT=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1042xxxxx_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; _DEBUG=0; CPU_MIMXRT1042XJM5B; DEBUG_CONSOLE_TRANSMIT_BUFFER_LEN=600; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; SDK_OS_FREE_RTOS; DEBUG_CONSOLE_ASSERT_DISABLE=1; I2C_RETRY_TIMES=40000; USB_STACK_FREERTOS_HEAP_SIZE=8192; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; TIMER_PORT_TYPE_GPT=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; _DEBUG=0; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1042XJM5B; DEBUG_CONSOLE_TRANSMIT_BUFFER_LEN=600; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; SDK_OS_FREE_RTOS; DEBUG_CONSOLE_ASSERT_DISABLE=1; I2C_RETRY_TIMES=40000; USB_STACK_FREERTOS_HEAP_SIZE=8192; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; TIMER_PORT_TYPE_GPT=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1042xxxxx_sdram.icf
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; _DEBUG=0; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1042XJM5B; DEBUG_CONSOLE_TRANSMIT_BUFFER_LEN=600; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; SDK_OS_FREE_RTOS; DEBUG_CONSOLE_ASSERT_DISABLE=1; I2C_RETRY_TIMES=40000; USB_STACK_FREERTOS_HEAP_SIZE=8192; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; TIMER_PORT_TYPE_GPT=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1042xxxxx_flexspi_nor.icf
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group source
    ../: FreeRTOSConfig.h pd_board_config.h pd_app_demo.c pd_app.c pd_app.h pd_command_app.c pd_command_interface.c pd_command_interface.h pd_power_app.c pd_power_interface.c pd_power_interface.h usb_pd_config.h pd_power_nx20p3483.c pd_power_nx20p3483.h
  group doc
    ../: readme.txt
  group component/i2c
    ../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h fsl_os_abstraction_config.h
  group component/timer
    ../../../../../../components/timer/: fsl_adapter_timer.h fsl_adapter_gpt.c
  group component/gpio
    ../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group drivers
    ../../../../../../devices/MIMXRT1042/drivers/: fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_gpt.c fsl_gpt.h fsl_gpio.h fsl_gpio.c fsl_lpi2c.c fsl_lpi2c.h fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_lpuart.h fsl_lpuart.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_iomuxc.h
  group usb/ptn5110
    ../../../../../../middleware/usb/pd/ptn5110/: usb_pd_ptn5110.h usb_pd_ptn5110_connect.c usb_pd_ptn5110_hal.c usb_pd_ptn5110_interface.c usb_pd_ptn5110_msg.c usb_pd_ptn5110_register.h
  group usb/pd
    ../../../../../../middleware/usb/pd/: usb_pd.h usb_pd_interface.h usb_pd_phy.h usb_pd_spec.h usb_pd_timer.c usb_pd_timer.h usb_pd.h usb_pd_connect.c usb_pd_interface.h usb_pd_interface.c usb_pd_msg.c usb_pd_phy.h usb_pd_policy.c usb_pd_spec.h usb_pd_timer.c usb_pd_timer.h usb_pd_auto_policy.h
  group usb/phy_interface
    ../../../../../../middleware/usb/pd/phy_interface/: usb_pd_i2c.h usb_pd_i2c.c
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos-kernel/portable/IAR/ARM_CM4F
    ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group device
    ../../../../../../devices/MIMXRT1042/: fsl_device_registers.h MIMXRT1042.h MIMXRT1042_features.h system_MIMXRT1042.c system_MIMXRT1042.h
  group startup
    ../../../../../../devices/MIMXRT1042/iar/: startup_MIMXRT1042.s
  group xip
    ../../../../../evkmimxrt1040/xip/: evkmimxrt1040_flexspi_nor_config.c evkmimxrt1040_flexspi_nor_config.h
    ../../../../../../devices/MIMXRT1042/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
  group utilities
    ../../../../../../devices/MIMXRT1042/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../../devices/MIMXRT1042/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1042/utilities/str/: fsl_str.c fsl_str.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
