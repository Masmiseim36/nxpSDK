# Keil uVision project arm_pelion_enet.uvprojx, settings and files
target arm_pelion_enet flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: arm_pelion_enet.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  AfterMake: python $P../../../../../middleware/arm-pelion/tools/combine_bootloader_with_app.py -b $P../mbed_bootloader.bin -a $P$L@L.bin -o $P$L@L_combined.bin -c 0x10400 -d 0x10000
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, DEBUG, CPU_MIMXRT1062DVL6A, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, SKIP_SYSCLK_INIT, FLASHIAP_APP_ROM_END_ADDR=1614807040, MBED_CONF_STORAGE_STORAGE_TYPE=TDB_INTERNAL, MBED_CONF_STORAGE_TDB_INTERNAL_INTERNAL_BASE_ADDRESS=1618935808, MBED_CONF_STORAGE_TDB_INTERNAL_INTERNAL_SIZE=65536, MBED_CLOUD_CLIENT_UPDATE_STORAGE=ARM_UCP_FLASHIAP, MBED_CONF_UPDATE_CLIENT_STORAGE_ADDRESS=1614807040, MBED_CONF_UPDATE_CLIENT_STORAGE_LOCATIONS=1, MBED_CONF_UPDATE_CLIENT_STORAGE_PAGE=256, MBED_CONF_UPDATE_CLIENT_STORAGE_SIZE=4128768, MBED_CONF_UPDATE_CLIENT_APPLICATION_DETAILS=1610678272, UPDATE_CLIENT_STORAGE_FLASHIAP, PRINTF_ADVANCED_ENABLE=0, PRINTF_FLOAT_ENABLE=0, USE_RTOS=1, __NXP_FREERTOS__, MBED_CLIENT_USER_CONFIG_FILE='\"mbed_cloud_client_user_config.h\"', MBED_CLOUD_CLIENT_USER_CONFIG_FILE='\"mbed_cloud_client_user_config.h\"', PAL_USER_DEFINED_CONFIGURATION='\"pal_config_NXP.h\"', MBEDTLS_CONFIG_FILE='\"mbedTLSConfig_NXP.h\"', MBED_CONF_NS_HAL_PAL_EVENT_LOOP_THREAD_STACK_SIZE=8000, PAL_DTLS_PEER_MIN_TIMEOUT=5000, MBED_CONF_MBED_CLOUD_CLIENT_UPDATE_DOWNLOAD_PROTOCOL=MBED_CLOUD_CLIENT_UPDATE_DOWNLOAD_PROTOCOL_COAP, COMPONENT_FLASHIAP, ARM_UC_PROFILE_MBED_CLOUD_CLIENT=1, ARM_UC_FEATURE_DELTA_PAAL=0, ATOMIC_QUEUE_USE_PAL=1, ARM_UC_FEATURE_PAL_FLASHIAP=1, MBED_CONF_MBED_CLOUD_CLIENT_EXTERNAL_SST_SUPPORT=1, PAL_USE_FILESYSTEM=0, MBED_CONF_MBED_TRACE_ENABLE=0, MBED_TRACE_MAX_LEVEL=TRACE_LEVEL_ERROR, MBED_CONF_APP_DEVELOPER_MODE=1, PLATFORM_ENABLE_BUTTON=1, PLATFORM_ENABLE_LED=1, MBED_CLOUD_APPLICATION_NONSTANDARD_ENTRYPOINT, LWIP_DHCP=1, LWIP_DNS=1, LWIP_IPV6=1, LWIP_NETIF_LINK_CALLBACK=1, LWIP_NETIF_STATUS_CALLBACK=1, LWIP_SO_SNDTIMEO=1, MBED_CLOUD_CLIENT_SUPPORT_UPDATE, PAL_SEMAPHORE_MAX_COUNT=4096, PAL_SKIP_TEST_MODULE_CRYPTO=1, PAL_SKIP_TEST_MODULE_DRBG=1, PAL_SKIP_TEST_MODULE_FILESYSTEM=1, PAL_SKIP_TEST_MODULE_INTERNALFLASH=1, PAL_SKIP_TEST_MODULE_ROT=1, PAL_SKIP_TEST_MODULE_SOTP=1, PAL_SKIP_TEST_MODULE_SST=1, PAL_SKIP_TEST_MODULE_TIME=1, PAL_SKIP_TEST_MODULE_TLS=1, PAL_SKIP_TEST_MODULE_UPDATE=1, __USE_CMSIS, RBP_TESTING, DEVICE_FLASH, SDK_DEBUGCONSOLE_UART, MBED_CONF_NANOSTACK_EVENTLOOP_EXCLUDE_HIGHRES_TIMER, MBED_CONF_NANOSTACK_EVENTLOOP_USE_PLATFORM_TICK_TIMER, MBED_CONF_MBED_CLIENT_SN_COAP_DUPLICATION_MAX_MSGS_COUNT=4, SN_COAP_REDUCE_BLOCKWISE_HEAP_FOOTPRINT=1, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: -fno-c++-static-destructors  -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../middleware/arm-pelion/pdmc-port/pdmc-bsp/target/nxp/mimxrt1060;../app;../app/source;../app/source/include;../app/source/platform/NXP;../app/source/platform/include;..;../../../../../components/phy/mdio/enet;../../../../../components/phy/device/phyksz8081;../../../../../devices/MIMXRT1062/drivers;../../../../../middleware/lwip/port;../../../../../middleware/lwip/src;../../../../../middleware/lwip/src/include;../../../../../components/phy;../../../../../devices/MIMXRT1062/utilities/str;../../../../../devices/MIMXRT1062/utilities/debug_console;../../../../../middleware/mbedtls/port/ksdk;../../../../../middleware/mbedtls/include;../../../../../middleware/mbedtls/library;../../../../../middleware/arm-pelion/pdmc-port/pdmc-bsp/common;../../../../../middleware/arm-pelion/mbed-cloud-client/certificate-enrollment-client/source/include;../../../../../middleware/arm-pelion/mbed-cloud-client/certificate-enrollment-client/certificate-enrollment-client;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/crypto-service/crypto-service;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/crypto-service/source/include;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/factory-configurator-client/factory-configurator-client;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/factory-configurator-client/source/include;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/fcc-bundle-handler/fcc-bundle-handler;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/fcc-bundle-handler/source/include;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/fcc-output-info-handler/fcc-output-info-handler;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/ftcd-comm-base/ftcd-comm-base;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/ftcd-comm-socket/ftcd-comm-socket;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/key-config-manager/key-config-manager;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/logger/logger;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/mbed-client-esfs/source/include;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/mbed-client-esfs/source/sotp;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/mbed-trace-helper/mbed-trace-helper;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/psa-driver/psa-driver;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/storage/storage;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/storage/source/include;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/utils/utils;../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/conf;../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/include;../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/helpers;../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/kv_map;../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/global_api;../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/tdbstore;../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/securestore;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-c/nsdl-c;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-c/source/include;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-classic/mbed-client-classic;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-mbed-tls/mbed-client-mbedtls;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/source/include;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Configs/mbedTLS;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Configs/pal_config/FreeRTOS;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Configs/pal_config/NXP;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Services-API;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Platform-API;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-randlib/mbed-client-randlib;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-randlib/mbed-client-randlib/platform;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-cloud-client;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-coap/mbed-coap;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-coap/source/include;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-trace/mbed-trace;../../../../../middleware/arm-pelion/mbed-cloud-client/nanostack-libservice/mbed-client-libservice;../../../../../middleware/arm-pelion/mbed-cloud-client/nanostack-libservice/mbed-client-libservice/platform;../../../../../middleware/arm-pelion/mbed-cloud-client/ns-hal-pal;../../../../../middleware/arm-pelion/mbed-cloud-client/sal-stack-nanostack-eventloop/nanostack-event-loop;../../../../../middleware/arm-pelion/mbed-cloud-client/sal-stack-nanostack-eventloop/nanostack-event-loop/platform;../../../../../middleware/arm-pelion/mbed-cloud-client/sal-stack-nanostack-eventloop/source;../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/logger/logger;../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/helpers/helpers;../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/mem/mem;../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/sda-bundle-parser/sda-bundle-parser;../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/secure-device-access/secure-device-access;../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/secure-device-access/source/include;../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/sda-cose/sda-cose;../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/cose-c/cose-c;../../../../../middleware/arm-pelion/mbed-cloud-client/source/include;../../../../../middleware/arm-pelion/mbed-cloud-client/tinycbor/src;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/delta-tool-internal/include;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/atomic-queue/atomic-queue;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/atomic-queue/source;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/common/update-client-common;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/control-center/update-client-control-center;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/device-identity/pal4life-device-identity;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/firmware-manager/update-client-firmware-manager;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/lwm2m-mbed/update-client-lwm2m;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/lwm2m-mbed/source;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/manifest-manager/update-client-manifest-manager;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/manifest-manager/source;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/metadata-header/update-client-metadata-header;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/monitor/update-client-monitor;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/paal/update-client-paal;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-blockdevice/update-client-pal-blockdevice;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-flashiap/update-client-pal-flashiap;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/source-manager/update-client-source-manager;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/source/update-client-source;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/source-http/update-client-source-http;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/source;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/update-client-hub;../../../../../middleware/arm-pelion/mbed-cloud-client;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/key-config-manager;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-c;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-classic;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-mbed-tls;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/source;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-randlib;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-coap;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-trace;../../../../../middleware/arm-pelion/mbed-cloud-client/nanostack-libservice;../../../../../middleware/arm-pelion/mbed-cloud-client/sal-stack-nanostack-eventloop;../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/platform/platform;../../../../../middleware/arm-pelion/mbed-cloud-client/source;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/atomic-queue;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/common;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/control-center;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/device-identity;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/firmware-manager;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/lwm2m-mbed;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/manifest-manager;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/metadata-header;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/monitor;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/paal;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-blockdevice;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-flashiap;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-flashiap-mcuboot;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/source-manager;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/source;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/source-http;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub;../../../../../devices/MIMXRT1062;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../devices/MIMXRT1062/xip;../../../xip;../../../../../CMSIS/Include;../../../../../rtos/freertos/freertos_kernel/include;../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM4F
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: --remove --predefine="-DMBED_APP_START=0x60010400" --predefine="-DMBED_APP_SIZE=0x3EFC00" --predefine="-D__heap_size__=0xC0000" --predefine="-D__stack_size__=0x2000"
  group arm-pelion/pdmc-port/pdmc-bsp/common
    ../../../../../middleware/arm-pelion/pdmc-port/pdmc-bsp/common/: flash_api.c FlashIAP.cpp port_storage.h FlashIAP.h flash_api.h
  group arm-pelion/pdmc-port/pdmc-bsp/target/nxp/mimxrt1060
    ../../../../../middleware/arm-pelion/pdmc-port/pdmc-bsp/target/nxp/mimxrt1060/: flexspi_nor_flash_ops.c rt1060_flexspi_storage.c flexspi_nor_flash_ops.h
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/OS_Specific/NXP/Board_Specific/TARGET_RT1060
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/OS_Specific/NXP/Board_Specific/TARGET_RT1060/: pal_plat_RT1060.c
  group source
    ../: rtos_startup.c
    ../app/: main.cpp
  group source/app
    ../app/: mbed_cloud_dev_credentials.c update_ui_example.cpp update_default_resources.c
    ../app/source/: resource.cpp memory_tests.cpp certificate_enrollment_user_cb.cpp blinky.cpp application_init.cpp app_platform_setup.c
  group include
    ../app/: update_ui_example.h
    ../app/source/: resource.h simplem2mclient.h memory_tests.h certificate_enrollment_user_cb.h blinky.h application_init.h
    ../app/source/include/: app_platform_setup.h
    ../app/source/platform/NXP/: mcc_common_serial.h
    ../app/source/platform/include/: mcc_common_button_and_led.h mcc_common_setup.h
  group config
    ../app/: mbed_cloud_client_user_config.h pal_config_NXP.h
    ../app/source/platform/include/: mcc_common_config.h
    ../: lwipopts.h FreeRTOSConfig.h
  group source/app/platform
    ../app/source/platform/NXP/: mcc_common_setup.c mcc_common_button_and_led.c event_platform.c
    ../app/source/platform/: pal_plat_rot_insecure.c
  group arm-pelion/tools
    ../../../../../middleware/arm-pelion/tools/: combine_bootloader_with_app.py
  group evkmimxrt1060/arm_examples/pelion_enet/.
    ../: mbed_bootloader.bin
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.txt
  group mdio
    ../../../../../components/phy/mdio/enet/: fsl_enet_mdio.h fsl_enet_mdio.c
    ../../../../../components/phy/: fsl_mdio.h
  group phy
    ../../../../../components/phy/device/phyksz8081/: fsl_phyksz8081.h fsl_phyksz8081.c
    ../../../../../components/phy/: fsl_phy.h
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_trng.c fsl_trng.h fsl_dcp.c fsl_dcp.h fsl_cache.c fsl_cache.h fsl_flexspi.c fsl_flexspi.h fsl_pit.c fsl_pit.h fsl_enet.h fsl_enet.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group lwip/port
    ../../../../../middleware/lwip/port/: enet_ethernetif.c enet_ethernetif.h enet_ethernetif_priv.h enet_ethernetif_kinetis.c sys_arch.c
  group lwip/port/arch
    ../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src/api
    ../../../../../middleware/lwip/src/api/: api_lib.c tcpip.c netdb.c sockets.c if_api.c netbuf.c netifapi.c api_msg.c err.c
  group lwip/src/core
    ../../../../../middleware/lwip/src/core/: altcp.c sys.c stats.c def.c ip.c netif.c dns.c tcp_out.c pbuf.c timeouts.c init.c tcp_in.c altcp_tcp.c raw.c tcp.c udp.c altcp_alloc.c mem.c inet_chksum.c memp.c
  group lwip/src/core/ipv6
    ../../../../../middleware/lwip/src/core/ipv6/: icmp6.c ethip6.c nd6.c ip6_frag.c inet6.c ip6.c dhcp6.c mld6.c ip6_addr.c
  group lwip/src/core/ipv4
    ../../../../../middleware/lwip/src/core/ipv4/: igmp.c ip4.c dhcp.c etharp.c ip4_frag.c icmp.c autoip.c acd.c ip4_addr.c
  group lwip/src/include/compat/stdc
    ../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/compat/posix
    ../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/sys
    ../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/compat/posix/net
    ../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/lwip
    ../../../../../middleware/lwip/src/include/lwip/: err.h sio.h ip6.h netdb.h altcp_tcp.h arch.h debug.h ip6_addr.h sockets.h if_api.h init.h tcpbase.h tcpip.h def.h inet_chksum.h snmp.h api.h ip4.h inet.h igmp.h altcp_tls.h netif.h opt.h ip.h acd.h tcp.h ip6_frag.h altcp.h ip4_addr.h ip4_frag.h netbuf.h autoip.h dns.h sys.h dhcp.h ip_addr.h icmp6.h mem.h raw.h ip6_zone.h stats.h ethip6.h icmp.h pbuf.h netifapi.h nd6.h etharp.h errno.h mld6.h timeouts.h dhcp6.h udp.h memp.h
  group lwip/src/include/lwip/priv
    ../../../../../middleware/lwip/src/include/lwip/priv/: api_msg.h tcpip_priv.h mem_priv.h altcp_priv.h nd6_priv.h tcp_priv.h memp_std.h sockets_priv.h raw_priv.h memp_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../middleware/lwip/src/include/lwip/prot/: ip6.h ethernet.h ip4.h igmp.h ip.h acd.h tcp.h ieee.h iana.h autoip.h dns.h dhcp.h icmp6.h icmp.h nd6.h etharp.h mld6.h dhcp6.h udp.h
  group lwip/src/include/netif
    ../../../../../middleware/lwip/src/include/netif/: bridgeif_opts.h ethernet.h zepif.h ieee802154.h lowpan6.h lowpan6_common.h lowpan6_ble.h lowpan6_opts.h bridgeif.h slipif.h etharp.h
  group lwip/src/include/netif/ppp
    ../../../../../middleware/lwip/src/include/netif/ppp/: eap.h pppol2tp.h chap-md5.h pppcrypt.h ppp.h upap.h pppapi.h ipv6cp.h pppdebug.h pppoe.h mppe.h pppos.h ppp_opts.h chap-new.h ipcp.h lcp.h ccp.h ppp_impl.h eui64.h vj.h ecp.h magic.h fsm.h chap_ms.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: sha1.h md5.h arc4.h md4.h des.h
  group lwip/src/netif
    ../../../../../middleware/lwip/src/netif/: lowpan6.c lowpan6_ble.c ethernet.c lowpan6_common.c slipif.c bridgeif.c bridgeif_fdb.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../middleware/lwip/src/netif/ppp/: utils.c pppol2tp.c chap_ms.c vj.c pppos.c lwip_ecp.c magic.c eui64.c chap-md5.c auth.c ppp.c ccp.c pppapi.c eap.c mppe.c ipv6cp.c ipcp.c lcp.c pppcrypt.c pppoe.c chap-new.c demand.c upap.c multilink.c fsm.c
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c
  group mbedtls/port/ksdk
    ../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c ecp_alt.h ecp_alt.c ecp_curves_alt.c ecp_alt_ksdk.c
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_3.c ReadMe.url
  group mbedtls/include/mbedtls
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/library
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c chacha20.c chachapoly.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group arm-pelion/mbed-cloud-client
    ../../../../../middleware/arm-pelion/mbed-cloud-client/: README.md LICENSE CHANGELOG.md CONTRIBUTING.md
  group arm-pelion/mbed-cloud-client/mbed-client-pal
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/: LICENSE
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/RTOS
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/RTOS/: pal_rtos.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/DRBG
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/DRBG/: pal_drbg.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/ROT
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/ROT/: pal_rot.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/Networking
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/Networking/: pal_network.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/Entropy
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/Entropy/: pal_entropy.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/Crypto
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/Crypto/: pal_Crypto.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/Time
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/Time/: pal_time.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/TLS
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/TLS/: pal_TLS.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/Storage/Flash
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/Storage/Flash/: pal_internalFlash.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/: pal_init.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/Storage/Flash
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/Storage/Flash/: pal_plat_internalFlash_FlashOverFilesystem.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/DRBG/SOTP
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/DRBG/SOTP/: pal_plat_drbg_sotp.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/DRBG
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/DRBG/: pal_plat_drbg_noise.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/DRBG/PSA
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/DRBG/PSA/: pal_plat_drbg_psa.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/ROT/External
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/ROT/External/: pal_plat_rot_hw.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/ROT/SOTP
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/ROT/SOTP/: pal_plat_rot_sotp.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/ROT/PSA
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/ROT/PSA/: pal_plat_rot_psa.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/Storage/FileSystem
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/Storage/FileSystem/: pal_plat_fileSystem_FsOverRam.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/Entropy/SOTP
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/Entropy/SOTP/: pal_plat_entropy_sotp.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/Entropy/PSA
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/Entropy/PSA/: pal_plat_entropy_psa.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/SST/kvstore_impl
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/SST/kvstore_impl/: pal_plat_sst_impl.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/Time
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/Time/: pal_plat_time.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Lib_Specific/mbedTLS/DRBG
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Lib_Specific/mbedTLS/DRBG/: pal_plat_drbg_w_entropy_sources.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/OS_Specific/NXP/RTOS
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/OS_Specific/NXP/RTOS/: pal_plat_rtos.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/OS_Specific/NXP/Networking/LWIP
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/OS_Specific/NXP/Networking/LWIP/: pal_plat_network.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Lib_Specific/mbedTLS/Crypto
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Lib_Specific/mbedTLS/Crypto/: pal_plat_Crypto.c
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Lib_Specific/mbedTLS/TLS
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Lib_Specific/mbedTLS/TLS/: pal_plat_TLS.c
  group arm-pelion/mbed-cloud-client/mbed-trace
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-trace/: LICENSE
  group arm-pelion/mbed-cloud-client/mbed-trace/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-trace/source/: mbed_trace.c
  group arm-pelion/mbed-cloud-client/factory-configurator-client/crypto-service/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/crypto-service/source/: cs_der_certs.c cs_der_keys_and_csrs.c cs_hash.c cs_utils.c
  group arm-pelion/mbed-cloud-client/factory-configurator-client/mbed-client-esfs/source/sotp
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/mbed-client-esfs/source/sotp/: sotp.c sotp_log.c sotp_no_sotp.c sotp_shared_lock.c sotp_shared_lock.h sotp_log.h sotp_int.h
  group arm-pelion/mbed-cloud-client/factory-configurator-client/mbed-client-esfs/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/mbed-client-esfs/source/: esfs_file_name.c esfs_performance.c
  group arm-pelion/mbed-cloud-client/factory-configurator-client/psa-driver/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/psa-driver/source/: psa_driver_ps.c psa_driver_dispatcher.c psa_driver_common.c psa_driver_crypto.c
  group arm-pelion/mbed-cloud-client/factory-configurator-client/storage/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/storage/source/: key_slot_allocator.c storage_common.c storage_non_psa.c storage_pal_sst.c storage_pelion_sst.c storage_psa.c
  group arm-pelion/mbed-cloud-client/factory-configurator-client/key-config-manager/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/key-config-manager/source/: key_config_manager.c
  group arm-pelion/mbed-cloud-client/factory-configurator-client/factory-configurator-client/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/factory-configurator-client/source/: factory_configurator_client.c fcc_dev_flow.c fcc_utils.c fcc_verification.c
  group arm-pelion/mbed-cloud-client/factory-configurator-client/fcc-bundle-handler/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/fcc-bundle-handler/source/: fcc_bundle_certificate_utils.c fcc_bundle_common_utils.c fcc_bundle_config_params_utils.c fcc_bundle_csr_utils.c fcc_bundle_handler.c fcc_bundle_key_utils.c
  group arm-pelion/mbed-cloud-client/factory-configurator-client/fcc-output-info-handler/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/fcc-output-info-handler/source/: fcc_output_info_handler.c
  group arm-pelion/mbed-cloud-client/factory-configurator-client/ftcd-comm-base/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/ftcd-comm-base/source/: ftcd_comm_base.cpp
  group arm-pelion/mbed-cloud-client/factory-configurator-client/ftcd-comm-socket/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/ftcd-comm-socket/source/: ftcd_comm_socket.cpp
  group arm-pelion/mbed-cloud-client/factory-configurator-client/mbed-trace-helper/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/mbed-trace-helper/source/: mbed-trace-helper.c
  group arm-pelion/mbed-cloud-client/factory-configurator-client/utils/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/utils/source/: common_utils.c fcc_stats.c fcc_time_profiling.c general_utils.c pv_error_handling.c
  group arm-pelion/mbed-cloud-client/certificate-enrollment-client/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/certificate-enrollment-client/source/: CertificateEnrollmentClient.cpp CertificateEnrollmentClientCommon.cpp CertificateRenewalData.cpp ce_safe_renewal_internal.c ce_tlv.c certificate_enrollment.c
  group arm-pelion/mbed-cloud-client/kvstore/helpers
    ../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/helpers/: FlashIAPBlockDevice.cpp BufferedBlockDevice.cpp pal_plat_rot.cpp DeviceKey.cpp FlashSimBlockDevice.cpp SlicingBlockDevice.cpp DeviceKey.h NonCopyable.h ExternalBlockDevice.h BufferedBlockDevice.h SPIFBlockDevice.h SlicingBlockDevice.h FlashIAPBlockDevice.h FlashSimBlockDevice.h BlockDevice.h SingletonPtr.h FlashIAP.h
  group arm-pelion/mbed-cloud-client/kvstore/tdbstore
    ../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/tdbstore/: TDBStore.cpp TDBStore.h
  group arm-pelion/mbed-cloud-client/kvstore/global_api
    ../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/global_api/: kvstore_global_api.cpp kvstore_global_api.h
  group arm-pelion/mbed-cloud-client/kvstore/kv_map
    ../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/kv_map/: KVMap.cpp KVMap.h
  group arm-pelion/mbed-cloud-client/kvstore/conf
    ../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/conf/: kv_config.cpp kv_config.h
  group arm-pelion/mbed-cloud-client/kvstore/securestore
    ../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/securestore/: SecureStore.cpp SecureStore.h
  group arm-pelion/mbed-cloud-client/tinycbor
    ../../../../../middleware/arm-pelion/mbed-cloud-client/tinycbor/: LICENSE
  group arm-pelion/mbed-cloud-client/tinycbor/src
    ../../../../../middleware/arm-pelion/mbed-cloud-client/tinycbor/src/: cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c cborpretty.c cborvalidation.c tinycbor.h cborinternal_p.h utf8_p.h cborjson.h compilersupport_p.h tinycbor-version.h
  group arm-pelion/mbed-cloud-client/secure-device-access-client/helpers/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/helpers/source/: sda_data_token.c
  group arm-pelion/mbed-cloud-client/secure-device-access-client/mem/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/mem/source/: sda_malloc.c
  group arm-pelion/mbed-cloud-client/secure-device-access-client/sda-bundle-parser/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/sda-bundle-parser/source/: sda_bundle_parser.c
  group arm-pelion/mbed-cloud-client/secure-device-access-client/sda-cose/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/sda-cose/source/: sda_cose.c
  group arm-pelion/mbed-cloud-client/secure-device-access-client/secure-device-access/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/secure-device-access/source/: sda_error_translation.c sda_nonce_mgr.c sda_trust_anchor.c sda_verification.c secure_device_access.c
  group arm-pelion/mbed-cloud-client/secure-device-access-client/cose-c
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/cose-c/: LICENSE
  group arm-pelion/mbed-cloud-client/secure-device-access-client/cose-c/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/cose-c/source/: Cose.c Encrypt.c Encrypt0.c MacMessage.c MacMessage0.c Recipient.c Sign.c Sign0.c SignerInfo.c bcrypt.c cbor.c mbedtls.c mbedtls_tiny_cbor.c
  group arm-pelion/mbed-cloud-client/ns-hal-pal
    ../../../../../middleware/arm-pelion/mbed-cloud-client/ns-hal-pal/: arm_hal_interrupt.c arm_hal_random.c arm_hal_timer.cpp ns_event_loop.c ns_hal_init.c ns_event_loop.h arm_hal_interrupt_private.h ns_hal_init.h
  group arm-pelion/mbed-cloud-client/nanostack-libservice
    ../../../../../middleware/arm-pelion/mbed-cloud-client/nanostack-libservice/: apache-2.0.txt LICENSE
  group arm-pelion/mbed-cloud-client/nanostack-libservice/source/libBits
    ../../../../../middleware/arm-pelion/mbed-cloud-client/nanostack-libservice/source/libBits/: common_functions.c
  group arm-pelion/mbed-cloud-client/nanostack-libservice/source/libList
    ../../../../../middleware/arm-pelion/mbed-cloud-client/nanostack-libservice/source/libList/: ns_list.c
  group arm-pelion/mbed-cloud-client/nanostack-libservice/source/libip6string
    ../../../../../middleware/arm-pelion/mbed-cloud-client/nanostack-libservice/source/libip6string/: ip6tos.c
  group arm-pelion/mbed-cloud-client/nanostack-libservice/source/nsdynmemLIB
    ../../../../../middleware/arm-pelion/mbed-cloud-client/nanostack-libservice/source/nsdynmemLIB/: nsdynmemLIB.c
  group arm-pelion/mbed-cloud-client/mbed-client-randlib
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-randlib/: apache-2.0.txt LICENSE
  group arm-pelion/mbed-cloud-client/mbed-client-randlib/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-randlib/source/: randLIB.c
  group arm-pelion/mbed-cloud-client/sal-stack-nanostack-eventloop
    ../../../../../middleware/arm-pelion/mbed-cloud-client/sal-stack-nanostack-eventloop/: apache-2.0.txt LICENSE
  group arm-pelion/mbed-cloud-client/sal-stack-nanostack-eventloop/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/sal-stack-nanostack-eventloop/source/: event.c ns_timeout.c ns_timer.c system_timer.c ns_timer.h event.h timer_sys.h
  group arm-pelion/mbed-cloud-client/mbed-coap
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-coap/: README.txt apache-2.0.txt LICENSE
  group arm-pelion/mbed-cloud-client/mbed-coap/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-coap/source/: sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
  group arm-pelion/mbed-cloud-client/mbed-client
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/: LICENSE
  group arm-pelion/mbed-cloud-client/mbed-client/mbed-client-classic
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-classic/: LICENSE
  group arm-pelion/mbed-cloud-client/mbed-client/mbed-client-classic/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-classic/source/: m2mconnectionhandler.cpp m2mconnectionhandlerpimpl.cpp m2mtimer.cpp m2mtimerpimpl.cpp
  group arm-pelion/mbed-cloud-client/mbed-client/mbed-client-c
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-c/: README.txt apache-2.0.txt LICENSE
  group arm-pelion/mbed-cloud-client/mbed-client/mbed-client-c/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-c/source/: sn_nsdl.c sn_grs.c
  group arm-pelion/mbed-cloud-client/mbed-client/mbed-client-mbed-tls
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-mbed-tls/: apache-2.0.txt LICENSE
  group arm-pelion/mbed-cloud-client/mbed-client/mbed-client-mbed-tls/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-mbed-tls/source/: m2mconnectionsecurity.cpp m2mconnectionsecuritypimpl.cpp
  group arm-pelion/mbed-cloud-client/mbed-client/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/source/: m2mbase.cpp m2mblockmessage.cpp m2mcallbackstorage.cpp m2mendpoint.cpp m2mdevice.cpp m2mfirmware.cpp m2minterfacefactory.cpp m2minterfaceimpl.cpp m2mnotificationhandler.cpp m2mnsdlinterface.cpp m2mobject.cpp m2mobjectinstance.cpp m2mreporthandler.cpp m2mresource.cpp m2mresourcebase.cpp m2mresourceinstance.cpp m2mserver.cpp m2msecurity.cpp m2mstring.cpp m2mstringbufferbase.cpp m2mtlvdeserializer.cpp m2mtlvserializer.cpp nsdlaccesshelper.cpp uriqueryparser.c
  group arm-pelion/mbed-cloud-client/update-client-hub
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/: LICENSE
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/atomic-queue
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/atomic-queue/: LICENSE
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/atomic-queue/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/atomic-queue/source/: atomic-queue.c atomic.c atomic-cm3.c critical-posix.c critical-pal.c critical.c atomic.h aq_critical.h
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/common
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/common/: LICENSE
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/common/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/common/source/: arm_uc_crypto_mbedtls.c arm_uc_crypto_pal.c arm_uc_error.c arm_uc_scheduler.c arm_uc_hw_plat.c arm_uc_test_rot.c arm_uc_utilities.c
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/control-center
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/control-center/: LICENSE
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/control-center/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/control-center/source/: arm_uc_certificate_kcm_api.c arm_uc_certificate.c arm_uc_certificate_raw_api.c arm_uc_control_center.c arm_uc_pre_shared_key.c
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/device-identity
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/device-identity/: LICENSE
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/device-identity/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/device-identity/source/: arm_uc_device_identity.c arm_uc_device_identity_kcm.c arm_uc_device_identity_nvstore.c arm_uc_device_identity_raw.c
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/firmware-manager
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/firmware-manager/: LICENSE
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/firmware-manager/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/firmware-manager/source/: arm_uc_firmware_manager.c
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/lwm2m-mbed
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/lwm2m-mbed/: LICENSE
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/lwm2m-mbed/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/lwm2m-mbed/source/: DeviceMetadataResource.cpp FirmwareUpdateResource.cpp device_metadata.c firmware_update.c lwm2m-control.cpp lwm2m-monitor.cpp lwm2m-source.cpp update-lwm2m-mbed-apis.c update_lwm2m_monitor.c update-lwm2m-mbed-apis.h
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/manifest-manager
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/manifest-manager/: LICENSE
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/manifest-manager/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/manifest-manager/source/: arm_uc_mmCommon.c arm_uc_mmCryptoUtils.c arm_uc_mmDerManifestAccessors.c arm_uc_mmDerManifestParser.c arm_uc_mmGetLatestTimestamp.c arm_uc_mmFetchFirmwareInfo.c arm_uc_mmInit.c arm_uc_mmInsertManifest.c manifest-manager-api.c arm_uc_mmStateSelector.c arm_uc_mmDerManifestParser.h arm_uc_mmFetchFirmwareInfo.h arm_uc_mmDerManifestAccessors.h arm_uc_mmFSMHelper.h arm_uc_mmInit.h arm_uc_mmGetLatestTimestamp.h arm_uc_mmCommon.h arm_uc_mmInsertManifest.h arm_uc_mmStateSelector.h arm_uc_mmConfig.h arm_uc_mmCryptoUtils.h
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/metadata-header/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/metadata-header/source/: arm_uc_buffer_utilities.c arm_uc_metadata_header_v2.c arm_uc_crypto_hmac_mbedtls.c
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/monitor
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/monitor/: LICENSE
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/paal
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/paal/: LICENSE
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/paal/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/paal/source/: arm_uc_paal_update.c
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-blockdevice/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-blockdevice/source/: arm_uc_pal_blockdevice.c arm_uc_pal_blockdevice_implementation.c arm_uc_pal_blockdevice_mbed.cpp
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-flashiap-mcuboot
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-flashiap-mcuboot/: LICENSE
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-flashiap-mcuboot/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-flashiap-mcuboot/source/: arm_uc_pal_flashiap_flash.cpp arm_uc_pal_flashiap_mcuboot_implementation.c arm_uc_pal_flashiap_mcuboot.c
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-flashiap
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-flashiap/: LICENSE
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-flashiap/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-flashiap/source/: arm_uc_pal_flashiap.c arm_uc_pal_flashiap_implementation.c arm_uc_pal_flashiap_mbed.cpp
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/source/: LICENSE
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/source-http
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/source-http/: LICENSE
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/source-manager
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/source-manager/: LICENSE
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/source-manager/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/source-manager/source/: arm_uc_source_manager.c
  group arm-pelion/mbed-cloud-client/update-client-hub/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/source/: update_client_hub.c update_client_hub_error_handler.c update_client_hub_event_handlers.c update_client_hub_state_machine.c update_client_hub_state_machine.h update_client_hub_error_handler.h update_client_hub_event_handlers.h
  group arm-pelion/mbed-cloud-client/source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/source/: CloudClientStorage.c EstClient.cpp ConnectorClient.cpp CertificateParser.c MbedCloudClient.cpp ServiceClient.cpp SimpleM2MResource.cpp UpdateClient.cpp
  group arm-pelion/mbed-cloud-client/certificate-enrollment-client/source/include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/certificate-enrollment-client/source/include/: ce_tlv.h ce_internal.h certificate_enrollment.h CertificateRenewalData.h CertificateEnrollmentClientCommon.h
  group arm-pelion/mbed-cloud-client/certificate-enrollment-client/certificate-enrollment-client
    ../../../../../middleware/arm-pelion/mbed-cloud-client/certificate-enrollment-client/certificate-enrollment-client/: ce_status.h CertificateEnrollmentClient.h ce_defs.h
  group arm-pelion/mbed-cloud-client/factory-configurator-client/crypto-service/crypto-service
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/crypto-service/crypto-service/: cs_der_keys_and_csrs.h cs_der_certs.h cs_hash.h
  group arm-pelion/mbed-cloud-client/factory-configurator-client/crypto-service/source/include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/crypto-service/source/include/: cs_utils.h
  group arm-pelion/mbed-cloud-client/factory-configurator-client/factory-configurator-client/factory-configurator-client
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/factory-configurator-client/factory-configurator-client/: factory_configurator_client.h fcc_defs.h fcc_status.h
  group arm-pelion/mbed-cloud-client/factory-configurator-client/factory-configurator-client/source/include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/factory-configurator-client/source/include/: fcc_bundle_fields.h fcc_utils.h fcc_verification.h
  group arm-pelion/mbed-cloud-client/factory-configurator-client/fcc-bundle-handler/fcc-bundle-handler
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/fcc-bundle-handler/fcc-bundle-handler/: fcc_bundle_handler.h
  group arm-pelion/mbed-cloud-client/factory-configurator-client/fcc-bundle-handler/source/include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/fcc-bundle-handler/source/include/: fcc_bundle_utils.h
  group arm-pelion/mbed-cloud-client/factory-configurator-client/fcc-output-info-handler/fcc-output-info-handler
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/fcc-output-info-handler/fcc-output-info-handler/: fcc_output_info_handler.h fcc_output_info_handler_defines.h
  group arm-pelion/mbed-cloud-client/factory-configurator-client/ftcd-comm-base/ftcd-comm-base
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/ftcd-comm-base/ftcd-comm-base/: ftcd_comm_base.h
  group arm-pelion/mbed-cloud-client/factory-configurator-client/ftcd-comm-socket/ftcd-comm-socket
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/ftcd-comm-socket/ftcd-comm-socket/: ftcd_comm_socket.h
  group arm-pelion/mbed-cloud-client/factory-configurator-client/key-config-manager/key-config-manager
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/key-config-manager/key-config-manager/: key_config_manager.h kcm_defs.h kcm_status.h
  group arm-pelion/mbed-cloud-client/factory-configurator-client/logger/logger
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/logger/logger/: pv_log.h
  group arm-pelion/mbed-cloud-client/factory-configurator-client/mbed-client-esfs/source/include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/mbed-client-esfs/source/include/: esfs_file_name.h esfs.h esfs_performance.h sotp.h
  group arm-pelion/mbed-cloud-client/factory-configurator-client/mbed-trace-helper/mbed-trace-helper
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/mbed-trace-helper/mbed-trace-helper/: mbed-trace-helper.h
  group arm-pelion/mbed-cloud-client/factory-configurator-client/psa-driver/psa-driver
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/psa-driver/psa-driver/: psa_driver.h psa_driver_dispatcher.h
  group arm-pelion/mbed-cloud-client/factory-configurator-client/storage/storage
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/storage/storage/: storage_kcm.h
  group arm-pelion/mbed-cloud-client/factory-configurator-client/storage/source/include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/storage/source/include/: se_slot_manager.h se_slot_manager_defs.h storage_pelion_sst.h storage_internal.h key_slot_allocator.h key_slot_allocator_internal.h
  group arm-pelion/mbed-cloud-client/factory-configurator-client/utils/utils
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/utils/utils/: pv_error_handling.h fcc_time_profiling.h fcc_malloc.h pv_macros.h general_utils.h pv_endian.h mbed_stats_helper.h common_utils.h fcc_stats.h
  group arm-pelion/mbed-cloud-client/kvstore/include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/include/: KVStore.h
  group arm-pelion/mbed-cloud-client/mbed-client/mbed-client
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client/: m2minterface.h m2mstringbuffer.h m2mresource.h m2mconnectionobserver.h m2mresourcebase.h m2mbase.h m2mreportobserver.h m2mconnectionhandler.h m2mfirmware.h m2mtimerobserver.h functionpointer.h m2mstring.h m2mstringbufferbase.h m2mobservationhandler.h m2mdevice.h m2minterfaceobserver.h m2mvector.h m2mconnectionsecurity.h m2mobject.h coap_response.h m2mresourceinstance.h m2msecurity.h m2mtimer.h m2mendpoint.h m2mserver.h m2mobjectinstance.h m2mconfig.h m2minterfacefactory.h m2mconstants.h uriqueryparser.h m2mblockmessage.h
  group arm-pelion/mbed-cloud-client/mbed-client/mbed-client-c/nsdl-c
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-c/nsdl-c/: sn_client_config.h sn_nsdl.h sn_nsdl_lib.h
  group arm-pelion/mbed-cloud-client/mbed-client/mbed-client-c/source/include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-c/source/include/: sn_grs.h
  group arm-pelion/mbed-cloud-client/mbed-client/mbed-client-classic/mbed-client-classic
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-classic/mbed-client-classic/: m2mconnectionhandlerpimpl.h m2mtimerpimpl.h
  group arm-pelion/mbed-cloud-client/mbed-client/mbed-client-mbed-tls/mbed-client-mbedtls
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-mbed-tls/mbed-client-mbedtls/: m2mconnectionsecuritypimpl.h
  group arm-pelion/mbed-cloud-client/mbed-client/source/include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/source/include/: m2mtlvdeserializer.h nsdlaccesshelper.h eventdata.h smartpointer.h m2mreporthandler.h nsdllinker.h m2mnsdlobserver.h m2minterfaceimpl.h m2mtlvserializer.h m2mnsdlinterface.h m2mnotificationhandler.h m2mcallbackstorage.h
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Configs/mbedTLS
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Configs/mbedTLS/: mbedTLSConfig_ARIA_mbedOS.h mbedtls_config_RTX.h mbedTLSConfig_mbedOS_SW_TRNG.h mbedTLSConfig_SXOS_SW_TRNG.h mbedTLSConfig_Renesas_EK_RA6M3.h mbedTLSConfig_NXP.h mbedTLSConfig_mbedOS.h mbedTLSConfig_FreeRTOS.h mbedTLSConfig_Linux.h mbedTLSConfig_mbedOS_SW_TRNG_PSA.h
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Configs/pal_config/FreeRTOS
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Configs/pal_config/FreeRTOS/: FreeRTOS_default.h
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Configs/pal_config/NXP
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Configs/pal_config/NXP/: NXP_default.h
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Services-API
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Services-API/: pal.h pal_time.h pal_internalFlash.h pal_rtos.h pal_sst.h pal_TLS.h pal_rot.h pal_fileSystem.h pal_macros.h pal_Crypto.h pal_types.h pal_errors.h pal_drbg.h pal_entropy.h pal_update.h pal_network.h pal_configuration.h
  group arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Platform-API
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Platform-API/: pal_plat_fileSystem.h pal_plat_drbg.h pal_plat_internalFlash.h pal_plat_network.h pal_plat_TLS.h pal_plat_update.h pal_plat_rot.h pal_plat_Crypto.h pal_plat_drbg_noise.h pal_plat_entropy.h pal_plat_rtos.h pal_plat_time.h
  group arm-pelion/mbed-cloud-client/mbed-client-randlib/mbed-client-randlib
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-randlib/mbed-client-randlib/: randLIB.h
  group arm-pelion/mbed-cloud-client/mbed-client-randlib/mbed-client-randlib/platform
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-randlib/mbed-client-randlib/platform/: arm_hal_random.h
  group arm-pelion/mbed-cloud-client/mbed-cloud-client
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-cloud-client/: MbedCloudClientConfig.h est_defs.h SimpleM2MResource.h MbedCloudClient.h MbedCloudClientConfigCheck.h
  group arm-pelion/mbed-cloud-client/mbed-coap/mbed-coap
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-coap/mbed-coap/: sn_coap_protocol.h sn_coap_header.h sn_config.h
  group arm-pelion/mbed-cloud-client/mbed-coap/source/include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-coap/source/include/: sn_coap_protocol_internal.h sn_coap_header_internal.h
  group arm-pelion/mbed-cloud-client/mbed-trace/mbed-trace
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-trace/mbed-trace/: mbed_trace.h
  group arm-pelion/mbed-cloud-client/nanostack-libservice/mbed-client-libservice
    ../../../../../middleware/arm-pelion/mbed-cloud-client/nanostack-libservice/mbed-client-libservice/: ip4string.h ip6string.h ns_trace.h ip_fsc.h common_functions.h ns_nvm_helper.h ns_types.h ns_list.h nsdynmemLIB.h
  group arm-pelion/mbed-cloud-client/nanostack-libservice/mbed-client-libservice/platform
    ../../../../../middleware/arm-pelion/mbed-cloud-client/nanostack-libservice/mbed-client-libservice/platform/: arm_hal_interrupt.h arm_hal_nvm.h
  group arm-pelion/mbed-cloud-client/sal-stack-nanostack-eventloop/nanostack-event-loop
    ../../../../../middleware/arm-pelion/mbed-cloud-client/sal-stack-nanostack-eventloop/nanostack-event-loop/: eventOS_callback_timer.h eventOS_event_timer.h eventOS_scheduler.h eventOS_event.h
  group arm-pelion/mbed-cloud-client/sal-stack-nanostack-eventloop/nanostack-event-loop/platform
    ../../../../../middleware/arm-pelion/mbed-cloud-client/sal-stack-nanostack-eventloop/nanostack-event-loop/platform/: eventloop_config.h arm_hal_timer.h
  group arm-pelion/mbed-cloud-client/secure-device-access-client/logger/logger
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/logger/logger/: sda_error_handling.h sda_log.h
  group arm-pelion/mbed-cloud-client/secure-device-access-client/helpers/helpers
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/helpers/helpers/: sda_data_token.h sda_macros.h sda_endian.h
  group arm-pelion/mbed-cloud-client/secure-device-access-client/mem/mem
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/mem/mem/: sda_malloc.h
  group arm-pelion/mbed-cloud-client/secure-device-access-client/sda-bundle-parser/sda-bundle-parser
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/sda-bundle-parser/sda-bundle-parser/: sda_bundle_parser.h
  group arm-pelion/mbed-cloud-client/secure-device-access-client/secure-device-access/secure-device-access
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/secure-device-access/secure-device-access/: sda_status.h secure_device_access.h
  group arm-pelion/mbed-cloud-client/secure-device-access-client/secure-device-access/source/include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/secure-device-access/source/include/: sda_trust_anchor.h sda_status_internal.h sda_internal_defs.h sda_verification.h sda_nonce_mgr.h sda_error_translation.h
  group arm-pelion/mbed-cloud-client/secure-device-access-client/sda-cose/sda-cose
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/sda-cose/sda-cose/: sda_cose.h
  group arm-pelion/mbed-cloud-client/secure-device-access-client/cose-c/cose-c
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/cose-c/cose-c/: cose.h crypto_cose.h configure.h cose_int.h
  group arm-pelion/mbed-cloud-client/source/include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/source/include/: ServiceClient.h ConnectorClient.h UpdateClient.h CloudClientStorage.h UpdateClientResources.h EstClient.h CertificateParser.h
  group arm-pelion/mbed-cloud-client/update-client-hub/delta-tool-internal/include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/delta-tool-internal/include/: bspatch.h bspatch_private.h varint.h lz4.h
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/atomic-queue/atomic-queue
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/atomic-queue/atomic-queue/: atomic-queue.h
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/common/update-client-common
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/common/update-client-common/: arm_uc_hw_plat.h arm_uc_public.h arm_uc_crypto.h arm_uc_config.h arm_uc_trace.h arm_uc_common.h arm_uc_types.h arm_uc_utilities.h arm_uc_scheduler.h arm_uc_error.h arm_uc_types_internal.h
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/control-center/update-client-control-center
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/control-center/update-client-control-center/: arm_uc_pre_shared_key.h arm_uc_certificate.h arm_uc_control_center.h
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/device-identity/pal4life-device-identity
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/device-identity/pal4life-device-identity/: pal_device_identity.h
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/firmware-manager/update-client-firmware-manager
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/firmware-manager/update-client-firmware-manager/: arm_uc_firmware_manager.h
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/lwm2m-mbed/update-client-lwm2m
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/lwm2m-mbed/update-client-lwm2m/: lwm2m-monitor.h FirmwareUpdateResource.h device_metadata.h DeviceMetadataResource.h update_lwm2m_monitor.h firmware_update.h lwm2m-control.h lwm2m-source.h
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/manifest-manager/update-client-manifest-manager
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/manifest-manager/update-client-manifest-manager/: arm-pal-kv.h update-client-manifest-types.h update-client-manifest-manager.h update-client-manifest-manager-context.h
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/metadata-header/update-client-metadata-header
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/metadata-header/update-client-metadata-header/: arm_uc_buffer_utilities.h arm_uc_metadata_header_v2.h
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/monitor/update-client-monitor
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/monitor/update-client-monitor/: arm_uc_monitor.h
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/paal/update-client-paal
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/paal/update-client-paal/: arm_uc_paal_update.h arm_uc_paal_update_api.h
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-blockdevice/update-client-pal-blockdevice
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-blockdevice/update-client-pal-blockdevice/: arm_uc_pal_blockdevice_platform.h arm_uc_pal_blockdevice_implementation.h arm_uc_pal_blockdevice.h
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-flashiap/update-client-pal-flashiap
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-flashiap/update-client-pal-flashiap/: arm_uc_pal_flashiap.h arm_uc_pal_flashiap_implementation.h arm_uc_pal_flashiap_platform.h
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/source-manager/update-client-source-manager
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/source-manager/update-client-source-manager/: arm_uc_source_manager.h
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/source/update-client-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/source/update-client-source/: arm_uc_source.h
  group arm-pelion/mbed-cloud-client/update-client-hub/modules/source-http/update-client-source-http
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/source-http/update-client-source-http/: arm_uc_source_http_extra.h arm_uc_source_http.h
  group arm-pelion/mbed-cloud-client/update-client-hub/update-client-hub
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/update-client-hub/: update_client_hub.h update_client_public.h update_client_certificate.h
  group arm-pelion
    ../../../../../middleware/arm-pelion/: ChangeLogKSDK.txt
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1062/arm/: startup_MIMXRT1062.S
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group freertos/freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    ../../../../../rtos/freertos/freertos_kernel/include/: croutine.h StackMacros.h atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos_kernel/portable/GCC/ARM_CM4F
    ../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos/freertos_kernel/portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
target arm_pelion_enet flexspi_nor_release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: arm_pelion_enet.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, NDEBUG, CPU_MIMXRT1062DVL6A, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, SKIP_SYSCLK_INIT, FLASHIAP_APP_ROM_END_ADDR=1614807040, MBED_CONF_STORAGE_STORAGE_TYPE=TDB_INTERNAL, MBED_CONF_STORAGE_TDB_INTERNAL_INTERNAL_BASE_ADDRESS=1618935808, MBED_CONF_STORAGE_TDB_INTERNAL_INTERNAL_SIZE=65536, MBED_CLOUD_CLIENT_UPDATE_STORAGE=ARM_UCP_FLASHIAP, MBED_CONF_UPDATE_CLIENT_STORAGE_ADDRESS=1614807040, MBED_CONF_UPDATE_CLIENT_STORAGE_LOCATIONS=1, MBED_CONF_UPDATE_CLIENT_STORAGE_PAGE=256, MBED_CONF_UPDATE_CLIENT_STORAGE_SIZE=4128768, MBED_CONF_UPDATE_CLIENT_APPLICATION_DETAILS=1610678272, UPDATE_CLIENT_STORAGE_FLASHIAP, PRINTF_ADVANCED_ENABLE=0, PRINTF_FLOAT_ENABLE=0, USE_RTOS=1, __NXP_FREERTOS__, MBED_CLIENT_USER_CONFIG_FILE='\"mbed_cloud_client_user_config.h\"', MBED_CLOUD_CLIENT_USER_CONFIG_FILE='\"mbed_cloud_client_user_config.h\"', PAL_USER_DEFINED_CONFIGURATION='\"pal_config_NXP.h\"', MBEDTLS_CONFIG_FILE='\"mbedTLSConfig_NXP.h\"', MBED_CONF_NS_HAL_PAL_EVENT_LOOP_THREAD_STACK_SIZE=8000, PAL_DTLS_PEER_MIN_TIMEOUT=5000, MBED_CONF_MBED_CLOUD_CLIENT_UPDATE_DOWNLOAD_PROTOCOL=MBED_CLOUD_CLIENT_UPDATE_DOWNLOAD_PROTOCOL_COAP, COMPONENT_FLASHIAP, ARM_UC_PROFILE_MBED_CLOUD_CLIENT=1, ARM_UC_FEATURE_DELTA_PAAL=0, ATOMIC_QUEUE_USE_PAL=1, ARM_UC_FEATURE_PAL_FLASHIAP=1, MBED_CONF_MBED_CLOUD_CLIENT_EXTERNAL_SST_SUPPORT=1, PAL_USE_FILESYSTEM=0, MBED_CONF_MBED_TRACE_ENABLE=0, MBED_TRACE_MAX_LEVEL=TRACE_LEVEL_ERROR, MBED_CONF_APP_DEVELOPER_MODE=1, PLATFORM_ENABLE_BUTTON=1, PLATFORM_ENABLE_LED=1, MBED_CLOUD_APPLICATION_NONSTANDARD_ENTRYPOINT, LWIP_DHCP=1, LWIP_DNS=1, LWIP_IPV6=1, LWIP_NETIF_LINK_CALLBACK=1, LWIP_NETIF_STATUS_CALLBACK=1, LWIP_SO_SNDTIMEO=1, MBED_CLOUD_CLIENT_SUPPORT_UPDATE, PAL_SEMAPHORE_MAX_COUNT=4096, PAL_SKIP_TEST_MODULE_CRYPTO=1, PAL_SKIP_TEST_MODULE_DRBG=1, PAL_SKIP_TEST_MODULE_FILESYSTEM=1, PAL_SKIP_TEST_MODULE_INTERNALFLASH=1, PAL_SKIP_TEST_MODULE_ROT=1, PAL_SKIP_TEST_MODULE_SOTP=1, PAL_SKIP_TEST_MODULE_SST=1, PAL_SKIP_TEST_MODULE_TIME=1, PAL_SKIP_TEST_MODULE_TLS=1, PAL_SKIP_TEST_MODULE_UPDATE=1, __USE_CMSIS, RBP_TESTING, DEVICE_FLASH, SDK_DEBUGCONSOLE_UART, MBED_CONF_NANOSTACK_EVENTLOOP_EXCLUDE_HIGHRES_TIMER, MBED_CONF_NANOSTACK_EVENTLOOP_USE_PLATFORM_TICK_TIMER, MBED_CONF_MBED_CLIENT_SN_COAP_DUPLICATION_MAX_MSGS_COUNT=4, SN_COAP_REDUCE_BLOCKWISE_HEAP_FOOTPRINT=1, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: as above
