# IAR project aws_tests_wiced.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0; CPU_MIMXRT1062DVL6A; HIGH_SPEED_SDIO_CLOCK; USE_RTOS=1; MBEDTLS_CONFIG_FILE="aws_mbedtls_config.h"; UNITY_INCLUDE_CONFIG_H; LWIP_NETIF_API=1; MEMP_NUM_NETCONN=4; FSL_RTOS_FREE_RTOS; AMAZON_FREERTOS_ENABLE_UNIT_TESTS=1; WIFI_WICED
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.IExtraOptions: --diag_suppress Pa084
  ICCARM.CCIncludePath2: ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM4F; ../../..; ..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../rtos/amazon-freertos/lib/include; ../../../../../rtos/amazon-freertos/lib/include/private; ../../../../../middleware/mbedtls/include; ../../../../../middleware/mbedtls/port/ksdk; ../config_files; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/drivers; ../../../../../rtos/amazon-freertos/lib/third_party/mcu_vendor/nxp/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/drivers; ../../../../../middleware/lwip/port; ../../../../../middleware/lwip/src; ../../../../../middleware/lwip/src/include; ../../../../../middleware/wiced/43xxx_Wi-Fi/platforms/MURATA_TYPE1DX; ../../../../../devices/MIMXRT1062/drivers; ../../../../../middleware/sdmmc/port; ../../../../../middleware/sdmmc/port; ../../../../../rtos/amazon-freertos/lib/include; ../../../../../rtos/amazon-freertos/lib/include/private; ../../../../../rtos/amazon-freertos/lib/third_party/pkcs11; ../../../../../rtos/amazon-freertos/lib/third_party; ../../../../../rtos/amazon-freertos/lib/third_party/jsmn; ../../../../../rtos/amazon-freertos/lib/include; ../../../../../rtos/amazon-freertos/tests/common/include; ../../../../../rtos/amazon-freertos/lib/third_party/unity/src; ../../../../../rtos/amazon-freertos/lib/third_party/unity/extras/fixture/src; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../devices/MIMXRT1062/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/serial_manager; ../../../../../devices/MIMXRT1062/drivers; ../../../../../components/lists; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/xip; ../../../xip; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/chips/4343W; ../../../../../middleware/wiced/43xxx_Wi-Fi/include; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/network/LwIP/WWD; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/include; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/WWD; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/RTOS/FreeRTOS/WWD; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/network; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/platform; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/RTOS; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/SDIO; ../../../../../middleware/lwip/src/include/lwip; ../../../../../middleware/sdmmc/inc; ../../../../../middleware/sdmmc/src
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ../../..; ../../aws_tests; ../config_files; ..
  ILINK.IlinkOutputFile: aws_tests_wiced.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x2000
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0; CPU_MIMXRT1062DVL6A; HIGH_SPEED_SDIO_CLOCK; USE_RTOS=1; MBEDTLS_CONFIG_FILE="aws_mbedtls_config.h"; UNITY_INCLUDE_CONFIG_H; LWIP_NETIF_API=1; MEMP_NUM_NETCONN=4; FSL_RTOS_FREE_RTOS; AMAZON_FREERTOS_ENABLE_UNIT_TESTS=1; WIFI_WICED
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source
    ../application_code/: main.c
  group configs
    ../config_files/: aws_bufferpool_config.h aws_ggd_config.h aws_mbedtls_config.h aws_mqtt_agent_config.h aws_mqtt_config.h aws_pkcs11_config.h aws_secure_sockets_config.h aws_shadow_config.h aws_test_pkcs11_config.h aws_test_runner_config.h aws_test_tcp_config.h aws_test_wifi_config.h aws_wifi_config.h FreeRTOSConfig.h FreeRTOSIPConfig.h unity_config.h lwipopts.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_trng.c fsl_trng.h fsl_dcp.c fsl_dcp.h fsl_cache.c fsl_cache.h fsl_flexspi.c fsl_flexspi.h fsl_clock.h fsl_clock.c fsl_usdhc.c fsl_usdhc.h fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group amazon-freertos/drivers
    ../../../../../rtos/amazon-freertos/lib/third_party/mcu_vendor/nxp/MIMXRT1062/drivers/: mflash_drv.h mflash_drv.c mflash_file.h mflash_file.c
  group amazon-freertos/FreeRTOS
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos/FreeRTOS/portable
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM4F/: fsl_tickless_systick.c fsl_tickless_generic.h port.c portasm.s portmacro.h
  group amazon-freertos/license
    ../../../../../rtos/amazon-freertos/: LICENSE
  group amazon-freertos/include
    ../../../../../rtos/amazon-freertos/lib/include/: event_groups.h FreeRTOS.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h FreeRTOS.h aws_crypto.h aws_greengrass_discovery.h aws_mqtt_agent.h aws_mqtt_lib.h aws_pkcs11.h aws_secure_sockets.h aws_shadow.h aws_system_init.h aws_tls.h aws_wifi.h event_groups.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
    ../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_wrappers.h mpu_prototypes.h portable.h projdefs.h stack_macros.h threading_alt.h aws_bufferpool.h aws_default_root_certificates.h aws_doubly_linked_list.h aws_ggd_config_defaults.h aws_helper_secure_connect.h aws_lib_init.h aws_mqtt_agent_config_defaults.h aws_mqtt_buffer.h aws_mqtt_config_defaults.h aws_secure_sockets_config_defaults.h aws_shadow_config_defaults.h aws_shadow_json.h deprecated_definitions.h list.h mpu_wrappers.h portable.h projdefs.h stack_macros.h
  group amazon-freertos/mqtt
    ../../../../../rtos/amazon-freertos/lib/mqtt/: aws_mqtt_agent.c aws_mqtt_lib.c
  group amazon-freertos/tls
    ../../../../../rtos/amazon-freertos/lib/tls/: aws_tls.c
  group amazon-freertos/bufferpool
    ../../../../../rtos/amazon-freertos/lib/bufferpool/: aws_bufferpool_static_thread_safe.c
  group amazon-freertos/crypto
    ../../../../../rtos/amazon-freertos/lib/crypto/: aws_crypto.c
  group amazon-freertos/pkcs11
    ../../../../../rtos/amazon-freertos/lib/pkcs11/mbedtls/: aws_pkcs11_mbedtls.c
    ../../../../../rtos/amazon-freertos/lib/pkcs11/portable/nxp/common/: aws_pkcs11_pal.c
  group amazon-freertos/third_party/pkcs11
    ../../../../../rtos/amazon-freertos/lib/third_party/pkcs11/: pkcs11.h pkcs11f.h pkcs11t.h
  group amazon-freertos/third_party/jsmn
    ../../../../../rtos/amazon-freertos/lib/third_party/jsmn/: jsmn.c jsmn.h
  group amazon-freertos/utils
    ../../../../../rtos/amazon-freertos/lib/utils/: aws_system_init.c
  group amazon-freertos/wifi
    ../../../../../rtos/amazon-freertos/lib/wifi/portable/nxp/wiced/: aws_wifi.c
  group amazon-freertos/devmode_key_provisioning
    ../../../../../rtos/amazon-freertos/demos/common/devmode_key_provisioning/: aws_dev_mode_key_provisioning.c
  group amazon-freertos/logging
    ../../../../../rtos/amazon-freertos/demos/common/logging/: aws_logging_task_dynamic_buffers.c
  group amazon-freertos/greengrass
    ../../../../../rtos/amazon-freertos/lib/greengrass/: aws_greengrass_discovery.c aws_helper_secure_connect.c
  group amazon-freertos/secure_sockets
    ../../../../../rtos/amazon-freertos/lib/secure_sockets/portable/nxp/lwip/: aws_secure_sockets.c
  group lwip/port
    ../../../../../middleware/lwip/port/: sys_arch.c
  group lwip/port/arch
    ../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src/api
    ../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/core
    ../../../../../middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/src/core/ipv4
    ../../../../../middleware/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/src/core/ipv6
    ../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip/src/include/compat/posix
    ../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/compat/posix/net
    ../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/sys
    ../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/stdc
    ../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/lwip
    ../../../../../middleware/lwip/src/include/lwip/: altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip_addr.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/priv
    ../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../middleware/lwip/src/include/lwip/prot/: autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip/src/include/netif
    ../../../../../middleware/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lwip/src/include/netif/ppp
    ../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap_ms.h chap-md5.h chap-new.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip/src/netif
    ../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group 43xxx_wifi/platforms/MURATA_TYPE1DX
    ../../../../../middleware/wiced/43xxx_Wi-Fi/platforms/MURATA_TYPE1DX/: wifi_nvram_image.h
  group 43xxx_wifi/WICED
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/: generated_mac_address.txt
  group 43xxx_wifi/WICED/WWD
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/: wwd.h wwd_wiced.h
  group 43xxx_wifi/WICED/WWD/internal
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/: tlv.c tlv.h wwd_ap.h wwd_ap_common.c wwd_ap_common.h wwd_bcmendian.h wwd_clm.c wwd_clm.h wwd_debug.c wwd_eapol.c wwd_internal.c wwd_internal.h wwd_logging.h wwd_management.c wwd_rtos_interface.c wwd_sdpcm.c wwd_sdpcm.h wwd_thread.c wwd_thread.h wwd_thread_internal.c wwd_thread_internal.h wwd_wifi.c wwd_wifi_chip_common.c wwd_wifi_chip_common.h wwd_wifi_sleep.c
  group 43xxx_wifi/WICED/WWD/internal/chips/4343W
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/chips/4343W/: 4343WA1.h 4343WA1_clm.h 4343WA1_mfg.h 4343WA1_clm_mfg.h chip_constants.h resources.c resources.h wwd_ap.c wwd_chip_specific_functions.c
  group 43xxx_wifi/WICED/WWD/internal/bus_protocols
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/: wwd_bus_common.c wwd_bus_protocol_interface.h
  group 43xxx_wifi/WICED/WWD/internal/bus_protocols/SDIO
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/SDIO/: wwd_bus_protocol.c wwd_bus_protocol.h
  group 43xxx_wifi/WICED/WWD/include
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/: wwd_assert.h wwd_constants.h wwd_debug.h wwd_eapol.h wwd_events.h wwd_management.h wwd_poll.h wwd_structures.h wwd_wifi.h wwd_wifi_sleep.h wwd_wlioctl.h
  group 43xxx_wifi/WICED/WWD/include/network
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/network/: wwd_buffer_interface.h wwd_network_constants.h wwd_network_interface.h
  group 43xxx_wifi/WICED/WWD/include/platform
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/platform/: wwd_bus_interface.h wwd_platform_interface.h wwd_resource_interface.h wwd_sdio_interface.h wwd_spi_interface.h
  group 43xxx_wifi/WICED/WWD/include/RTOS
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/RTOS/: wwd_rtos_interface.h
  group 43xxx_wifi/WICED/network/LwIP/WWD
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/network/LwIP/WWD/: wwd_buffer.c wwd_buffer.h wwd_network.c wwd_network.h
  group 43xxx_wifi/WICED/platform
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/: platform_toolchain.h
  group 43xxx_wifi/WICED/platform/include
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/include/: platform_cache_def.h platform_peripheral.h
  group 43xxx_wifi/WICED/platform/MCU
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/: wwd_platform_common.h wwd_platform_separate_mcu.c wwd_resources.c
  group 43xxx_wifi/WICED/platform/MCU/LPC
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/: platform_mcu_peripheral.h
  group 43xxx_wifi/WICED/platform/MCU/LPC/WWD
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/WWD/: wwd_platform.c wwd_SDIO.c
  group 43xxx_wifi/WICED/RTOS/FreeRTOS/WWD
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/RTOS/FreeRTOS/WWD/: wwd_FreeRTOS_systick.h wwd_rtos.c wwd_rtos.h
  group 43xxx_wifi/include
    ../../../../../middleware/wiced/43xxx_Wi-Fi/include/: wiced_resource.h
  group 43xxx_wifi/internal
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/internal/: wifi.c
  group sdmmc/src
    ../../../../../middleware/sdmmc/src/: fsl_sdio.c fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc/inc/: fsl_sdio.h fsl_sdmmc_host.h fsl_sdmmc_common.h fsl_sdmmc_spec.h
  group sdmmc/port
    ../../../../../middleware/sdmmc/port/: fsl_sdmmc_event.h
    ../../../../../middleware/sdmmc/port/usdhc/freertos/: fsl_sdmmc_event.c fsl_sdmmc_host.c
  group mbedtls/mbedtls_source
    ../../../../../middleware/mbedtls/library/: pkcs11.c aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c chacha20.c chachapoly.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/mbedtls_include
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/mbedtls_port
    ../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c ecp_alt.h ecp_alt.c ecp_curves_alt.c ecp_alt_ksdk.c
  group common-tests/crypto
    ../../../../../rtos/amazon-freertos/tests/common/crypto/: aws_test_crypto.c
  group common-tests/framework
    ../../../../../rtos/amazon-freertos/tests/common/framework/: aws_test_framework.c
  group common-tests/greengrass
    ../../../../../rtos/amazon-freertos/tests/common/greengrass/: aws_test_greengrass_discovery.c aws_test_helper_secure_connect.c
  group common-tests/include
    ../../../../../rtos/amazon-freertos/tests/common/include/: aws_application_version.h aws_clientcredential.h aws_clientcredential_keys.h aws_dev_mode_key_provisioning.h aws_greengrass_discovery_test_access_declare.h aws_greengrass_discovery_test_access_define.h aws_logging_task.h aws_mqtt_lib_test_access_declare.h aws_mqtt_lib_test_access_define.h aws_test_framework.h aws_test_runner.h aws_test_tcp.h aws_test_tls.h aws_test_utils.h
    ../../../../../rtos/amazon-freertos/lib/include/: aws_appversion32.h
  group common-tests/memory_leak
    ../../../../../rtos/amazon-freertos/tests/common/memory_leak/: aws_memory_leak.c
  group common-tests/mqtt
    ../../../../../rtos/amazon-freertos/tests/common/mqtt/: aws_test_mqtt_agent.c aws_test_mqtt_lib.c
  group common-tests/pkcs11
    ../../../../../rtos/amazon-freertos/tests/common/pkcs11/: aws_test_pkcs11.c
  group common-tests/secure_sockets
    ../../../../../rtos/amazon-freertos/tests/common/secure_sockets/: aws_test_tcp.c
  group common-tests/shadow
    ../../../../../rtos/amazon-freertos/tests/common/shadow/: aws_test_shadow.c
  group common-tests/test_runner
    ../../../../../rtos/amazon-freertos/tests/common/test_runner/: aws_test_runner.c
  group common-tests/tls
    ../../../../../rtos/amazon-freertos/tests/common/tls/: aws_test_tls.c
  group common-tests/wifi
    ../../../../../rtos/amazon-freertos/tests/common/wifi/: aws_test_wifi.c
  group unity
    ../../../../../rtos/amazon-freertos/lib/third_party/unity/src/: unity.c unity.h unity_internals.h
    ../../../../../rtos/amazon-freertos/lib/third_party/unity/extras/fixture/src/: unity_fixture.c unity_fixture.h unity_fixture_internals.h unity_fixture_malloc_overrides.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: uart.h lpuart_adapter.c
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: generic_list.h generic_list.c
  group startup
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h evkmimxrt1060_sdram_ini_dcd.c evkmimxrt1060_sdram_ini_dcd.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
