# IAR project netxduo_lib.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1062DVL6A; TX_INCLUDE_USER_DEFINE_FILE; FX_INCLUDE_USER_DEFINE_FILE; NX_INCLUDE_USER_DEFINE_FILE
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/azure-rtos/binary/threadx; ../../../../../rtos/azure-rtos/binary/filex; ../../../../../rtos/azure-rtos/binary/netxduo; ../../../../../rtos/azure-rtos/threadx/common/inc; ../../../../../rtos/azure-rtos/filex/common/inc; ../../../../../rtos/azure-rtos/netxduo/common/inc; ../../../../../rtos/azure-rtos/netxduo/addons/cloud; ../../../../../rtos/azure-rtos/netxduo/addons/dhcp; ../../../../../rtos/azure-rtos/netxduo/addons/dns; ../../../../../rtos/azure-rtos/netxduo/addons/http; ../../../../../rtos/azure-rtos/netxduo/addons/mqtt; ../../../../../rtos/azure-rtos/netxduo/addons/sntp; ../../../../../rtos/azure-rtos/netxduo/crypto_libraries/inc; ../../../../../rtos/azure-rtos/netxduo/nx_secure/inc; ../../../../../rtos/azure-rtos/netxduo/nx_secure/ports; ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/iar/inc; ../../../../../rtos/azure-rtos/filex/ports/cortex_m7/iar/inc; ../../../../../rtos/azure-rtos/netxduo/ports/cortex_m7/iar/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: psp_arm.out
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1062DVL6A; TX_INCLUDE_USER_DEFINE_FILE; FX_INCLUDE_USER_DEFINE_FILE; NX_INCLUDE_USER_DEFINE_FILE
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: libgeneric.out
  group doc
    ../: readme.txt
  group azure-rtos/user
    ../../../../../rtos/azure-rtos/binary/threadx/: tx_user.h
    ../../../../../rtos/azure-rtos/binary/filex/: fx_user.h
    ../../../../../rtos/azure-rtos/binary/netxduo/: nx_user.h
  group azure-rtos/threadx/common/inc
    ../../../../../rtos/azure-rtos/threadx/common/inc/: tx_byte_pool.h tx_event_flags.h tx_timer.h tx_queue.h tx_thread.h tx_mutex.h tx_trace.h tx_initialize.h tx_api.h tx_user_sample.h tx_block_pool.h tx_semaphore.h
  group azure-rtos/threadx/ports/cortex_m7/iar/inc
    ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/iar/inc/: tx_port.h
  group azure-rtos/filex/common/inc
    ../../../../../rtos/azure-rtos/filex/common/inc/: fx_media.h fx_unicode.h fx_api.h fx_directory_exFAT.h fx_utility.h fx_file.h fx_system.h fx_directory.h fx_user_sample.h fx_fault_tolerant.h
  group azure-rtos/filex/ports/cortex_m7/iar/inc
    ../../../../../rtos/azure-rtos/filex/ports/cortex_m7/iar/inc/: fx_port.h
  group azure-rtos/source
    ../../../../../rtos/azure-rtos/netxduo/addons/cloud/: nx_cloud.c nx_cloud.h
    ../../../../../rtos/azure-rtos/netxduo/addons/dhcp/: nxd_dhcp_client.c nxd_dhcp_client.h
    ../../../../../rtos/azure-rtos/netxduo/addons/dns/: nxd_dns.c nxd_dns.h
    ../../../../../rtos/azure-rtos/netxduo/addons/http/: nxd_http_server.c nxd_http_server.h
    ../../../../../rtos/azure-rtos/netxduo/addons/mqtt/: nxd_mqtt_client.c nxd_mqtt_client.h
    ../../../../../rtos/azure-rtos/netxduo/addons/sntp/: nxd_sntp_client.c nxd_sntp_client.h
    ../../../../../rtos/azure-rtos/netxduo/common/inc/: nx_igmp.h nx_ipv4.h nx_packet.h nx_nd_cache.h nx_md5.h nx_icmpv6.h nx_icmp.h nx_user_sample.h nx_tcp.h nx_icmpv4.h nx_arp.h nx_ipv6.h nx_system.h nx_api.h nx_rarp.h nx_mld.h nx_ip.h nx_udp.h
    ../../../../../rtos/azure-rtos/netxduo/common/src/: nx_ram_network_driver.c nx_system_initialize.c nx_ip_initialize.c nx_tcp_initialize.c nx_packet_pool_initialize.c nxd_source.c
  group azure-rtos/netxduo/ports/cortex_m7/iar/inc
    ../../../../../rtos/azure-rtos/netxduo/ports/cortex_m7/iar/inc/: nx_port.h
  group azure-rtos/crypto_libraries
    ../../../../../rtos/azure-rtos/netxduo/crypto_libraries/inc/: nx_crypto_sha1.h nx_crypto_hmac_md5.h nx_crypto_xcbc_mac.h nx_crypto_hmac.h nx_crypto_ccm.h nx_crypto_dh.h nx_crypto_tls_prf_1.h nx_crypto_const.h nx_crypto_cbc.h nx_crypto_ec.h nx_crypto_md5.h nx_crypto_tls_prf_sha384.h nx_crypto.h nx_crypto_sha5.h nx_crypto_rsa.h nx_crypto_ecdh.h nx_crypto_ecdsa.h nx_crypto_hmac_sha2.h nx_crypto_3des.h nx_crypto_null.h nx_crypto_drbg.h nx_crypto_phash.h nx_crypto_hmac_sha1.h nx_crypto_gcm.h nx_crypto_tls_prf_sha256.h nx_crypto_sha2.h nx_crypto_pkcs1_v1.5.h nx_crypto_tls_prf_sha512.h nx_crypto_huge_number.h nx_crypto_hmac_sha5.h nx_crypto_ecjpake.h nx_crypto_des.h nx_crypto_ctr.h nx_crypto_aes.h nx_crypto_method_self_test.h nx_crypto_hkdf.h
    ../../../../../rtos/azure-rtos/netxduo/crypto_libraries/src/: nx_crypto_method_self_test_pkcs1.c nx_crypto_hmac.c nx_crypto_ctr.c nx_crypto_ec_secp192r1_fixed_points.c nx_crypto_method_self_test_hmac_sha.c nx_crypto_methods.c nx_crypto_hkdf.c nx_crypto_method_self_test_prf.c nx_crypto_aes.c nx_crypto_method_self_test_rsa.c nx_crypto_phash.c nx_crypto_huge_number.c nx_crypto_ec_secp224r1_fixed_points.c nx_crypto_method_self_test_md5.c nx_crypto_tls_prf_sha384.c nx_crypto_method_self_test_hmac_md5.c nx_crypto_tls_prf_1.c nx_crypto_module_start.c nx_crypto_method_self_test_ecdsa.c nx_crypto_huge_number_extended.c nx_crypto_initialize.c nx_crypto_sha5.c nx_crypto_method_self_test_aes.c nx_crypto_md5.c nx_crypto_ec.c nx_crypto_ec_secp384r1_fixed_points.c nx_crypto_sha2.c nx_crypto_pkcs1_v1.5.c nx_crypto_cbc.c nx_crypto_ccm.c nx_crypto_ecjpake.c nx_crypto_xcbc_mac.c nx_crypto_method_self_test.c nx_crypto_rsa.c nx_crypto_hmac_sha1.c nx_crypto_gcm.c nx_crypto_ec_secp521r1_fixed_points.c nx_crypto_method_self_test_ecdh.c nx_crypto_sha1.c nx_crypto_method_self_test_3des.c nx_crypto_3des.c nx_crypto_hmac_md5.c nx_crypto_ecdsa.c nx_crypto_tls_prf_sha512.c nx_crypto_drbg.c nx_crypto_method_self_test_des.c nx_crypto_hmac_sha2.c nx_crypto_tls_prf_sha256.c nx_crypto_null_cipher.c nx_crypto_des.c nx_crypto_ec_secp256r1_fixed_points.c nx_crypto_hmac_sha5.c nx_crypto_dh.c nx_crypto_generic_ciphersuites.c nx_crypto_method_self_test_drbg.c nx_crypto_method_self_test_sha.c nx_crypto_ecdh.c
  group azure-rtos/nx_secure
    ../../../../../rtos/azure-rtos/netxduo/nx_secure/inc/: nx_secure_tls_api.h nx_secure_dtls_api.h nx_secure_user_sample.h nx_secure_x509.h nx_secure_dtls.h nx_secure_crypto_table_self_test.h nx_secure_tls.h
    ../../../../../rtos/azure-rtos/netxduo/nx_secure/ports/: nx_secure_port.h
    ../../../../../rtos/azure-rtos/netxduo/nx_secure/src/: nx_secure_dtls_server_ecc_initialize.c nxe_secure_x509_extended_key_usage_extension_parse.c nxe_secure_x509_crl_revocation_check.c nx_secure_tls_psk_identity_find.c nxe_secure_tls_session_renegotiate.c nxe_secure_tls_session_receive.c nx_secure_crypto_method_self_test_hmac_md5.c nx_secure_tls_server_certificate_add.c nx_secure_x509_local_certificate_find.c nx_secure_tls_send_changecipherspec.c nx_secure_tls_local_certificate_remove.c nxe_secure_dtls_server_x509_client_verify_configure.c nx_secure_tls_process_clienthello_extensions.c nxe_secure_dtls_ecc_initialize.c nx_secure_x509_store_certificate_remove.c nx_secure_dtls_client_handshake.c nxe_secure_tls_local_certificate_add.c nx_secure_dtls_client_session_start.c nxe_secure_dtls_server_x509_client_verify_disable.c nx_secure_tls_server_handshake.c nxe_secure_dtls_server_session_start.c nx_secure_tls_process_client_key_exchange.c nx_secure_tls_map_error_to_alert.c nx_secure_tls_record_hash_initialize.c nx_secure_tls_session_sni_extension_parse.c nx_secure_dtls_send_record.c nx_secure_tls_shutdown.c nx_secure_tls_send_serverhello_extensions.c nx_secure_tls_client_handshake.c nx_secure_tls_session_reset.c nx_secure_dtls_hash_record.c nxe_secure_dtls_session_client_info_get.c nxe_secure_dtls_server_local_certificate_remove.c nx_secure_x509_local_device_certificate_get.c nxe_secure_dtls_session_delete.c nx_secure_dtls_initialize.c nxe_secure_dtls_server_local_certificate_add.c nx_secure_tls_session_send.c nx_secure_tls_session_alert_value_get.c nxe_secure_dtls_server_stop.c nxe_secure_tls_local_certificate_find.c nxe_secure_tls_session_client_verify_disable.c nxe_secure_dtls_packet_allocate.c nx_secure_tls_process_changecipherspec.c nx_secure_tls_metadata_size_calculate.c nx_secure_crypto_method_self_test_md5.c nxe_secure_dtls_session_local_certificate_remove.c nx_secure_tls_send_serverhello.c nx_secure_crypto_method_self_test_aes.c nx_secure_dtls_server_trusted_certificate_add.c nxe_secure_dtls_server_psk_add.c nx_secure_x509_certificate_initialize.c nx_secure_dtls_server_local_certificate_remove.c nx_secure_dtls_retransmit_queue_flush.c nx_secure_tls_process_encrypted_extensions.c nx_secure_tls_packet_release.c nxe_secure_tls_session_delete.c nx_secure_dtls_process_clienthello.c nx_secure_x509_crl_verify.c nx_secure_tls_process_server_key_exchange.c nx_secure_dtls_process_handshake_header.c nx_secure_dtls_receive_callback.c nxe_secure_x509_common_name_dns_check.c nx_secure_x509_certificate_list_remove.c nx_secure_dtls_session_start.c nx_secure_tls_packet_allocate.c nx_secure_dtls_session_local_certificate_add.c nx_secure_x509_store_certificate_add.c nx_secure_x509_distinguished_name_parse.c nx_secure_tls_key_material_init.c nx_secure_dtls_client_protocol_version_override.c nxe_secure_dtls_server_start.c nx_secure_dtls_verify_mac.c nx_secure_dtls_process_record.c nx_secure_tls_trusted_certificate_add.c nxe_secure_tls_session_server_callback_set.c nx_secure_tls_initialize.c nxe_secure_dtls_session_create.c nx_secure_x509_ec_private_key_parse.c nx_secure_dtls_send_handshake_record.c nx_secure_tls_send_certificate_request.c nx_secure_tls_process_newsessionticket.c nx_secure_dtls_send_clienthello.c nxe_secure_dtls_server_notify_set.c nx_secure_tls_send_encrypted_extensions.c nx_secure_tls_local_certificate_add.c nx_secure_tls_process_clienthello.c nx_secure_tls_session_create_ext.c nxe_secure_dtls_server_ecc_initialize.c nxe_secure_tls_session_time_function_set.c nx_secure_tls_process_finished.c nx_secure_tls_session_start.c nx_secure_x509_certificate_list_add.c nx_secure_x509_dns_name_initialize.c nxe_secure_tls_packet_allocate.c nx_secure_tls_protocol_version_get.c nx_secure_dtls_allocate_handshake_packet.c nxe_secure_dtls_server_trusted_certificate_add.c nx_secure_tls_session_delete.c nxe_secure_tls_client_psk_set.c nx_secure_dtls_server_x509_client_verify_disable.c nx_secure_tls_record_payload_decrypt.c nx_secure_tls_process_record.c nx_secure_dtls_process_helloverifyrequest.c nx_secure_x509_free_certificate_get.c nxe_secure_dtls_session_start.c nxe_secure_dtls_session_receive.c nx_secure_x509_pkcs1_rsa_private_key_parse.c nx_secure_tls_1_3_server_handshake.c nx_secure_tls_process_serverhello_extensions.c nxe_secure_tls_session_packet_buffer_set.c nx_secure_x509_key_usage_extension_parse.c nx_secure_dtls_session_trusted_certificate_remove.c nxe_secure_tls_session_certificate_callback_set.c nx_secure_tls_ecc_generate_keys.c nx_secure_tls_remote_certificate_free_all.c nx_secure_tls_send_alert.c nxe_secure_tls_active_certificate_set.c nx_secure_tls_send_record.c nx_secure_tls_psk_find.c nxe_secure_tls_server_certificate_add.c nx_secure_tls_session_client_verify_disable.c nx_secure_tls_session_protocol_version_override.c nx_secure_tls_session_client_verify_enable.c nx_secure_x509_wildcard_compare.c nx_secure_tls_process_header.c nx_secure_dtls_session_send.c nx_secure_dtls_session_end.c nxe_secure_x509_dns_name_initialize.c nxe_secure_dtls_server_delete.c nx_secure_dtls_session_delete.c nxe_secure_tls_server_certificate_find.c nxe_secure_tls_psk_add.c nx_secure_dtls_send_helloverifyrequest.c nx_secure_tls_session_time_function_set.c nxe_secure_x509_certificate_initialize.c nx_secure_tls_send_handshake_record.c nx_secure_tls_1_3_finished_hash_generate.c nx_secure_tls_remote_certificate_verify.c nxe_secure_dtls_session_send.c nx_secure_dtls_server_session_send.c nx_secure_x509_extended_key_usage_extension_parse.c nxe_secure_tls_session_alert_value_get.c nxe_secure_dtls_session_trusted_certificate_add.c nx_secure_tls_finished_hash_generate.c nxe_secure_dtls_session_local_certificate_add.c nx_secure_tls_ecc_initialize.c nx_secure_x509_remote_endpoint_certificate_get.c nxe_secure_tls_session_send.c nx_secure_tls_send_finished.c nxe_secure_dtls_server_protocol_version_override.c nx_secure_module_hash_compute.c nxe_secure_tls_session_reset.c nx_secure_tls_1_3_generate_keys.c nx_secure_x509_expiration_check.c nx_secure_tls_session_packet_buffer_set.c nx_secure_tls_process_remote_certificate.c nxe_secure_dtls_server_trusted_certificate_remove.c nx_secure_dtls_server_handshake.c nx_secure_crypto_method_self_test_rsa.c nx_secure_tls_record_hash_update.c nx_secure_tls_send_certificate.c nx_secure_tls_remote_certificate_buffer_allocate.c nx_secure_dtls_server_start.c nxe_secure_tls_local_certificate_remove.c nx_secure_dtls_ecc_initialize.c nxe_secure_tls_trusted_certificate_remove.c nxe_secure_tls_session_start.c nx_secure_tls_session_iv_size_get.c nxe_secure_tls_session_create.c nxe_secure_tls_remote_certificate_free_all.c nx_secure_x509_extension_find.c nxe_secure_tls_session_client_callback_set.c nx_secure_dtls_session_reset.c nx_secure_dtls_session_local_certificate_remove.c nx_secure_tls_send_newsessionticket.c nx_secure_tls_newest_supported_version.c nx_secure_tls_1_3_crypto_init.c nx_secure_tls_session_end.c nx_secure_tls_generate_premaster_secret.c nx_secure_tls_remote_certificate_allocate.c nx_secure_dtls_server_notify_set.c nx_secure_x509_pkcs7_decode.c nx_secure_tls_allocate_handshake_packet.c nx_secure_tls_handshake_hash_init.c nx_secure_tls_handshake_process.c nx_secure_dtls_packet_allocate.c nxe_secure_x509_key_usage_extension_parse.c nxe_secure_dtls_session_end.c nx_secure_x509_common_name_dns_check.c nx_secure_tls_psk_binder_generate.c nx_secure_tls_verify_mac.c nx_secure_crypto_rng_self_test.c nx_secure_dtls_server_protocol_version_override.c nx_secure_dtls_server_local_certificate_add.c nxe_secure_tls_remote_certificate_allocate.c nxe_secure_tls_session_client_verify_enable.c nxe_secure_tls_remote_certificate_buffer_allocate.c nx_secure_x509_asn1_tlv_block_parse.c nx_secure_tls_send_clienthello_extensions.c nx_secure_tls_process_certificate_verify.c nx_secure_tls_record_payload_encrypt.c nx_secure_tls_check_protocol_version.c nx_secure_x509_store_certificate_find.c nx_secure_tls_session_x509_client_verify_configure.c nx_secure_tls_send_clienthello.c nx_secure_tls_process_handshake_header.c nx_secure_dtls_server_stop.c nx_secure_x509.c nx_secure_tls_send_certificate_verify.c nx_secure_crypto_method_self_test_hmac_sha.c nx_secure_tls_server_certificate_remove.c nxe_secure_dtls_client_session_start.c nx_secure_tls_session_certificate_callback_set.c nx_secure_tls_find_curve_method.c nx_secure_tls_trusted_certificate_remove.c nx_secure_tls_process_serverhello.c nx_secure_crypto_method_self_test_prf.c nxe_secure_tls_metadata_size_calculate.c nx_secure_tls_send_client_key_exchange.c nx_secure_x509_oid_parse.c nx_secure_tls_server_certificate_find.c nx_secure_tls_1_3_transcript_hash_save.c nx_secure_tls_1_3_client_handshake.c nx_secure_x509_find_certificate_methods.c nx_secure_dtls_session_receive.c nx_secure_dtls_server_session_start.c nxe_secure_dtls_client_protocol_version_override.c nx_secure_tls_1_3_session_keys_set.c nx_secure_tls_record_hash_calculate.c nxe_secure_tls_trusted_certificate_add.c nx_secure_tls_send_hellorequest.c nx_secure_dtls_server_trusted_certificate_remove.c nx_secure_tls_session_keys_set.c nx_secure_crypto_table_self_test.c nx_secure_tls_handshake_hash_update.c nx_secure_dtls_server_psk_add.c nx_secure_x509_certificate_verify.c nx_secure_x509_distinguished_name_compare.c nxe_secure_tls_session_sni_extension_set.c nx_secure_crypto_method_self_test_des.c nx_secure_dtls_server_delete.c nx_secure_dtls_send_serverhello.c nx_secure_tls_send_server_key_exchange.c nxe_secure_x509_extension_find.c nx_secure_tls_local_certificate_find.c nx_secure_tls_session_renegotiate.c nx_secure_dtls_session_client_info_get.c nx_secure_dtls_server_x509_client_verify_configure.c nxe_secure_tls_session_end.c nx_secure_tls_session_client_callback_set.c nx_secure_dtls_process_header.c nx_secure_tls_active_certificate_set.c nx_secure_tls_session_server_callback_set.c nx_secure_tls_hash_record.c nx_secure_x509_certificate_list_find.c nx_secure_tls_session_renegotiate_callback_set.c nx_secure_dtls_psk_add.c nx_secure_dtls_session_create.c nx_secure_dtls_server_create.c nx_secure_x509_certificate_revocation_list_parse.c nx_secure_crypto_method_self_test_sha.c nx_secure_tls_session_create.c nxe_secure_dtls_psk_add.c nxe_secure_tls_server_certificate_remove.c nxe_secure_tls_session_x509_client_verify_configure.c nx_secure_tls_client_psk_set.c nx_secure_tls_session_receive_records.c nxe_secure_dtls_server_session_send.c nx_secure_tls_session_receive.c nx_secure_tls_remote_certificate_free.c nx_secure_dtls_retransmit.c nx_secure_dtls_session_trusted_certificate_add.c nx_secure_x509_certificate_chain_verify.c nx_secure_x509_subject_alt_names_find.c nx_secure_tls_process_certificate_request.c nx_secure_dtls_session_cache.c nxe_secure_tls_session_renegotiate_callback_set.c nx_secure_tls_ciphersuite_lookup.c nx_secure_tls_generate_keys.c nxe_secure_tls_session_protocol_version_override.c nx_secure_x509_crl_revocation_check.c nxe_secure_dtls_session_trusted_certificate_remove.c nx_secure_tls_psk_add.c nxe_secure_dtls_session_reset.c nx_secure_crypto_method_self_test_3des.c nxe_secure_tls_session_sni_extension_parse.c nx_secure_tls_session_sni_extension_set.c nxe_secure_dtls_server_create.c
