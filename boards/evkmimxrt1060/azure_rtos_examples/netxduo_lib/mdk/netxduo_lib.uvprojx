# Keil uVision project netxduo_lib.uvprojx, settings and files
target netxduo_lib Debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: netxduo_lib.out (library)
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: DEBUG, CPU_MIMXRT1062DVL6A, MCUXPRESSO_SDK, TX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, NX_INCLUDE_USER_DEFINE_FILE
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../../rtos/azure-rtos/threadx/common/inc;../../../../../rtos/azure-rtos/filex/common/inc;../../../../../rtos/azure-rtos/netxduo/common/inc;../../../../../rtos/azure-rtos/netxduo/tsn/inc;../../../../../rtos/azure-rtos/netxduo/crypto_libraries/inc;../../../../../rtos/azure-rtos/netxduo/nx_secure/inc;../../../../../rtos/azure-rtos/netxduo/nx_secure/ports;../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc;../../../../../rtos/azure-rtos/filex/ports/generic/inc;../../../../../rtos/azure-rtos/netxduo/ports/cortex_m7/ac6/inc
  asm define: DEBUG, DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group doc
    ../: readme.txt
  group azure-rtos/config
    ../: tx_user.h fx_user.h nx_user.h
  group azure-rtos/netxduo/tsn
    ../../../../../rtos/azure-rtos/netxduo/tsn/: CMakeLists.txt
  group azure-rtos/netxduo/tsn/inc
    ../../../../../rtos/azure-rtos/netxduo/tsn/inc/: nx_mrp.h nx_msrp.h nx_mvrp.h nx_shaper.h nx_srp.h
  group azure-rtos/netxduo/tsn/src
    ../../../../../rtos/azure-rtos/netxduo/tsn/src/: nx_mrp.c nx_msrp.c nx_mvrp.c nx_shaper.c nx_srp.c
  group azure-rtos/netxduo/common
    ../../../../../rtos/azure-rtos/netxduo/common/: netxduo_common_source.c
  group azure-rtos/netxduo/common/src
    ../../../../../rtos/azure-rtos/netxduo/common/src/: nx_ip_initialize.c nx_packet_pool_initialize.c nx_ram_network_driver.c nx_system_initialize.c nx_tcp_initialize.c
  group azure-rtos/netxduo/crypto_libraries/inc
    ../../../../../rtos/azure-rtos/netxduo/crypto_libraries/inc/: nx_crypto.h nx_crypto_3des.h nx_crypto_aes.h nx_crypto_cbc.h nx_crypto_ccm.h nx_crypto_const.h nx_crypto_ctr.h nx_crypto_des.h nx_crypto_dh.h nx_crypto_drbg.h nx_crypto_ec.h nx_crypto_ecdh.h nx_crypto_ecdsa.h nx_crypto_ecjpake.h nx_crypto_gcm.h nx_crypto_hkdf.h nx_crypto_hmac.h nx_crypto_hmac_md5.h nx_crypto_hmac_sha1.h nx_crypto_hmac_sha2.h nx_crypto_hmac_sha5.h nx_crypto_huge_number.h nx_crypto_md5.h nx_crypto_method_self_test.h nx_crypto_null.h nx_crypto_phash.h nx_crypto_pkcs1_v1.5.h nx_crypto_rsa.h nx_crypto_sha1.h nx_crypto_sha2.h nx_crypto_sha5.h nx_crypto_tls_prf_1.h nx_crypto_tls_prf_sha256.h nx_crypto_tls_prf_sha384.h nx_crypto_tls_prf_sha512.h nx_crypto_xcbc_mac.h
  group azure-rtos/netxduo/crypto_libraries/src
    ../../../../../rtos/azure-rtos/netxduo/crypto_libraries/src/: nx_crypto_3des.c nx_crypto_aes.c nx_crypto_cbc.c nx_crypto_ccm.c nx_crypto_ctr.c nx_crypto_des.c nx_crypto_dh.c nx_crypto_drbg.c nx_crypto_ec.c nx_crypto_ec_secp192r1_fixed_points.c nx_crypto_ec_secp224r1_fixed_points.c nx_crypto_ec_secp256r1_fixed_points.c nx_crypto_ec_secp384r1_fixed_points.c nx_crypto_ec_secp521r1_fixed_points.c nx_crypto_ecdh.c nx_crypto_ecdsa.c nx_crypto_ecjpake.c nx_crypto_gcm.c nx_crypto_generic_ciphersuites.c nx_crypto_hkdf.c nx_crypto_hmac.c nx_crypto_hmac_md5.c nx_crypto_hmac_sha1.c nx_crypto_hmac_sha2.c nx_crypto_hmac_sha5.c nx_crypto_huge_number.c nx_crypto_huge_number_extended.c nx_crypto_initialize.c nx_crypto_md5.c nx_crypto_method_self_test.c nx_crypto_method_self_test_3des.c nx_crypto_method_self_test_aes.c nx_crypto_method_self_test_des.c nx_crypto_method_self_test_drbg.c nx_crypto_method_self_test_ecdh.c nx_crypto_method_self_test_ecdsa.c nx_crypto_method_self_test_hmac_md5.c nx_crypto_method_self_test_hmac_sha.c nx_crypto_method_self_test_md5.c nx_crypto_method_self_test_pkcs1.c nx_crypto_method_self_test_prf.c nx_crypto_method_self_test_rsa.c nx_crypto_method_self_test_sha.c nx_crypto_methods.c nx_crypto_null_cipher.c nx_crypto_phash.c nx_crypto_pkcs1_v1.5.c nx_crypto_rsa.c nx_crypto_sha1.c nx_crypto_sha2.c nx_crypto_sha5.c nx_crypto_tls_prf_1.c nx_crypto_tls_prf_sha256.c nx_crypto_tls_prf_sha384.c nx_crypto_tls_prf_sha512.c nx_crypto_xcbc_mac.c
  group azure-rtos/netxduo/nx_secure/inc
    ../../../../../rtos/azure-rtos/netxduo/nx_secure/inc/: nx_secure_crypto_table_self_test.h nx_secure_dtls.h nx_secure_dtls_api.h nx_secure_tls.h nx_secure_tls_api.h nx_secure_user_sample.h nx_secure_x509.h
  group azure-rtos/netxduo/nx_secure/src
    ../../../../../rtos/azure-rtos/netxduo/nx_secure/src/: nx_secure_crypto_method_self_test_3des.c nx_secure_crypto_method_self_test_aes.c nx_secure_crypto_method_self_test_des.c nx_secure_crypto_method_self_test_hmac_md5.c nx_secure_crypto_method_self_test_hmac_sha.c nx_secure_crypto_method_self_test_md5.c nx_secure_crypto_method_self_test_prf.c nx_secure_crypto_method_self_test_rsa.c nx_secure_crypto_method_self_test_sha.c nx_secure_crypto_rng_self_test.c nx_secure_crypto_table_self_test.c nx_secure_dtls_allocate_handshake_packet.c nx_secure_dtls_client_handshake.c nx_secure_dtls_client_protocol_version_override.c nx_secure_dtls_client_session_start.c nx_secure_dtls_ecc_initialize.c nx_secure_dtls_hash_record.c nx_secure_dtls_initialize.c nx_secure_dtls_packet_allocate.c nx_secure_dtls_process_clienthello.c nx_secure_dtls_process_handshake_header.c nx_secure_dtls_process_header.c nx_secure_dtls_process_helloverifyrequest.c nx_secure_dtls_process_record.c nx_secure_dtls_psk_add.c nx_secure_dtls_receive_callback.c nx_secure_dtls_retransmit.c nx_secure_dtls_retransmit_queue_flush.c nx_secure_dtls_send_clienthello.c nx_secure_dtls_send_handshake_record.c nx_secure_dtls_send_helloverifyrequest.c nx_secure_dtls_send_record.c nx_secure_dtls_send_serverhello.c nx_secure_dtls_server_create.c nx_secure_dtls_server_delete.c nx_secure_dtls_server_ecc_initialize.c nx_secure_dtls_server_handshake.c nx_secure_dtls_server_local_certificate_add.c nx_secure_dtls_server_local_certificate_remove.c nx_secure_dtls_server_notify_set.c nx_secure_dtls_server_protocol_version_override.c nx_secure_dtls_server_psk_add.c nx_secure_dtls_server_session_send.c nx_secure_dtls_server_session_start.c nx_secure_dtls_server_start.c nx_secure_dtls_server_stop.c nx_secure_dtls_server_trusted_certificate_add.c nx_secure_dtls_server_trusted_certificate_remove.c nx_secure_dtls_server_x509_client_verify_configure.c nx_secure_dtls_server_x509_client_verify_disable.c nx_secure_dtls_session_cache.c nx_secure_dtls_session_client_info_get.c nx_secure_dtls_session_create.c nx_secure_dtls_session_delete.c nx_secure_dtls_session_end.c nx_secure_dtls_session_local_certificate_add.c nx_secure_dtls_session_local_certificate_remove.c nx_secure_dtls_session_receive.c nx_secure_dtls_session_reset.c nx_secure_dtls_session_send.c nx_secure_dtls_session_sliding_window_check.c nx_secure_dtls_session_sliding_window_update.c nx_secure_dtls_session_start.c nx_secure_dtls_session_trusted_certificate_add.c nx_secure_dtls_session_trusted_certificate_remove.c nx_secure_dtls_verify_mac.c nx_secure_generate_client_key_exchange.c nx_secure_generate_master_secret.c nx_secure_generate_premaster_secret.c nx_secure_generate_server_key_exchange.c nx_secure_generate_session_keys.c nx_secure_module_hash_compute.c nx_secure_process_client_key_exchange.c nx_secure_process_server_key_exchange.c nx_secure_remote_certificate_verify.c nx_secure_session_keys_set.c nx_secure_tls_1_3_client_handshake.c nx_secure_tls_1_3_crypto_init.c nx_secure_tls_1_3_finished_hash_generate.c nx_secure_tls_1_3_generate_keys.c nx_secure_tls_1_3_server_handshake.c nx_secure_tls_1_3_session_keys_set.c nx_secure_tls_1_3_transcript_hash_save.c nx_secure_tls_active_certificate_set.c nx_secure_tls_allocate_handshake_packet.c nx_secure_tls_check_protocol_version.c nx_secure_tls_ciphersuite_lookup.c nx_secure_tls_client_handshake.c nx_secure_tls_client_psk_set.c nx_secure_tls_ecc_generate_keys.c nx_secure_tls_ecc_initialize.c nx_secure_tls_find_curve_method.c nx_secure_tls_finished_hash_generate.c nx_secure_tls_generate_keys.c nx_secure_tls_generate_premaster_secret.c nx_secure_tls_handshake_hash_init.c nx_secure_tls_handshake_hash_update.c nx_secure_tls_handshake_process.c nx_secure_tls_hash_record.c nx_secure_tls_initialize.c nx_secure_tls_key_material_init.c nx_secure_tls_local_certificate_add.c nx_secure_tls_local_certificate_find.c nx_secure_tls_local_certificate_remove.c nx_secure_tls_map_error_to_alert.c nx_secure_tls_metadata_size_calculate.c nx_secure_tls_newest_supported_version.c nx_secure_tls_packet_allocate.c nx_secure_tls_packet_release.c nx_secure_tls_process_certificate_request.c nx_secure_tls_process_certificate_verify.c nx_secure_tls_process_changecipherspec.c nx_secure_tls_process_client_key_exchange.c nx_secure_tls_process_clienthello.c nx_secure_tls_process_clienthello_extensions.c nx_secure_tls_process_encrypted_extensions.c nx_secure_tls_process_finished.c nx_secure_tls_process_handshake_header.c nx_secure_tls_process_header.c nx_secure_tls_process_newsessionticket.c nx_secure_tls_process_record.c nx_secure_tls_process_remote_certificate.c nx_secure_tls_process_server_key_exchange.c nx_secure_tls_process_serverhello.c nx_secure_tls_process_serverhello_extensions.c nx_secure_tls_protocol_version_get.c nx_secure_tls_psk_add.c nx_secure_tls_psk_binder_generate.c nx_secure_tls_psk_find.c nx_secure_tls_psk_identity_find.c nx_secure_tls_record_hash_calculate.c nx_secure_tls_record_hash_initialize.c nx_secure_tls_record_hash_update.c nx_secure_tls_record_payload_decrypt.c nx_secure_tls_record_payload_encrypt.c nx_secure_tls_remote_certificate_allocate.c nx_secure_tls_remote_certificate_buffer_allocate.c nx_secure_tls_remote_certificate_free.c nx_secure_tls_remote_certificate_free_all.c nx_secure_tls_remote_certificate_verify.c nx_secure_tls_send_alert.c nx_secure_tls_send_certificate.c nx_secure_tls_send_certificate_request.c nx_secure_tls_send_certificate_verify.c nx_secure_tls_send_changecipherspec.c nx_secure_tls_send_client_key_exchange.c nx_secure_tls_send_clienthello.c nx_secure_tls_send_clienthello_extensions.c nx_secure_tls_send_encrypted_extensions.c nx_secure_tls_send_finished.c nx_secure_tls_send_handshake_record.c nx_secure_tls_send_hellorequest.c nx_secure_tls_send_newsessionticket.c nx_secure_tls_send_record.c nx_secure_tls_send_server_key_exchange.c nx_secure_tls_send_serverhello.c nx_secure_tls_send_serverhello_extensions.c nx_secure_tls_server_certificate_add.c nx_secure_tls_server_certificate_find.c nx_secure_tls_server_certificate_remove.c nx_secure_tls_server_handshake.c nx_secure_tls_session_alert_value_get.c nx_secure_tls_session_certificate_callback_set.c nx_secure_tls_session_client_callback_set.c nx_secure_tls_session_client_verify_disable.c nx_secure_tls_session_client_verify_enable.c nx_secure_tls_session_create.c nx_secure_tls_session_create_ext.c nx_secure_tls_session_delete.c nx_secure_tls_session_end.c nx_secure_tls_session_iv_size_get.c nx_secure_tls_session_keys_set.c nx_secure_tls_session_packet_buffer_set.c nx_secure_tls_session_packet_pool_set.c nx_secure_tls_session_protocol_version_override.c nx_secure_tls_session_receive.c nx_secure_tls_session_receive_records.c nx_secure_tls_session_renegotiate.c nx_secure_tls_session_renegotiate_callback_set.c nx_secure_tls_session_reset.c nx_secure_tls_session_send.c nx_secure_tls_session_server_callback_set.c nx_secure_tls_session_sni_extension_parse.c nx_secure_tls_session_sni_extension_set.c nx_secure_tls_session_start.c nx_secure_tls_session_time_function_set.c nx_secure_tls_session_x509_client_verify_configure.c nx_secure_tls_shutdown.c nx_secure_tls_trusted_certificate_add.c nx_secure_tls_trusted_certificate_remove.c nx_secure_tls_verify_mac.c nx_secure_trusted_certificate_add.c nx_secure_verify_mac.c nx_secure_x509.c nx_secure_x509_asn1_tlv_block_parse.c nx_secure_x509_certificate_chain_verify.c nx_secure_x509_certificate_initialize.c nx_secure_x509_certificate_list_add.c nx_secure_x509_certificate_list_find.c nx_secure_x509_certificate_list_remove.c nx_secure_x509_certificate_revocation_list_parse.c nx_secure_x509_certificate_verify.c nx_secure_x509_common_name_dns_check.c nx_secure_x509_crl_revocation_check.c nx_secure_x509_crl_verify.c nx_secure_x509_distinguished_name_compare.c nx_secure_x509_distinguished_name_parse.c nx_secure_x509_dns_name_initialize.c nx_secure_x509_ec_private_key_parse.c nx_secure_x509_expiration_check.c nx_secure_x509_extended_key_usage_extension_parse.c nx_secure_x509_extension_find.c nx_secure_x509_find_certificate_methods.c nx_secure_x509_find_curve_method.c nx_secure_x509_free_certificate_get.c nx_secure_x509_key_usage_extension_parse.c nx_secure_x509_local_certificate_find.c nx_secure_x509_local_device_certificate_get.c nx_secure_x509_oid_parse.c nx_secure_x509_pkcs1_rsa_private_key_parse.c nx_secure_x509_pkcs7_decode.c nx_secure_x509_remote_endpoint_certificate_get.c nx_secure_x509_store_certificate_add.c nx_secure_x509_store_certificate_find.c nx_secure_x509_store_certificate_remove.c nx_secure_x509_subject_alt_names_find.c nx_secure_x509_wildcard_compare.c nxe_secure_dtls_client_protocol_version_override.c nxe_secure_dtls_client_session_start.c nxe_secure_dtls_ecc_initialize.c nxe_secure_dtls_packet_allocate.c nxe_secure_dtls_psk_add.c nxe_secure_dtls_server_create.c nxe_secure_dtls_server_delete.c nxe_secure_dtls_server_ecc_initialize.c nxe_secure_dtls_server_local_certificate_add.c nxe_secure_dtls_server_local_certificate_remove.c nxe_secure_dtls_server_notify_set.c nxe_secure_dtls_server_protocol_version_override.c nxe_secure_dtls_server_psk_add.c nxe_secure_dtls_server_session_send.c nxe_secure_dtls_server_session_start.c nxe_secure_dtls_server_start.c nxe_secure_dtls_server_stop.c nxe_secure_dtls_server_trusted_certificate_add.c nxe_secure_dtls_server_trusted_certificate_remove.c nxe_secure_dtls_server_x509_client_verify_configure.c nxe_secure_dtls_server_x509_client_verify_disable.c nxe_secure_dtls_session_client_info_get.c nxe_secure_dtls_session_create.c nxe_secure_dtls_session_delete.c nxe_secure_dtls_session_end.c nxe_secure_dtls_session_local_certificate_add.c nxe_secure_dtls_session_local_certificate_remove.c nxe_secure_dtls_session_receive.c nxe_secure_dtls_session_reset.c nxe_secure_dtls_session_send.c nxe_secure_dtls_session_start.c nxe_secure_dtls_session_trusted_certificate_add.c nxe_secure_dtls_session_trusted_certificate_remove.c nxe_secure_tls_active_certificate_set.c nxe_secure_tls_client_psk_set.c nxe_secure_tls_local_certificate_add.c nxe_secure_tls_local_certificate_find.c nxe_secure_tls_local_certificate_remove.c nxe_secure_tls_metadata_size_calculate.c nxe_secure_tls_packet_allocate.c nxe_secure_tls_psk_add.c nxe_secure_tls_remote_certificate_allocate.c nxe_secure_tls_remote_certificate_buffer_allocate.c nxe_secure_tls_remote_certificate_free_all.c nxe_secure_tls_server_certificate_add.c nxe_secure_tls_server_certificate_find.c nxe_secure_tls_server_certificate_remove.c nxe_secure_tls_session_alert_value_get.c nxe_secure_tls_session_certificate_callback_set.c nxe_secure_tls_session_client_callback_set.c nxe_secure_tls_session_client_verify_disable.c nxe_secure_tls_session_client_verify_enable.c nxe_secure_tls_session_create.c nxe_secure_tls_session_delete.c nxe_secure_tls_session_end.c nxe_secure_tls_session_packet_buffer_set.c nxe_secure_tls_session_packet_pool_set.c nxe_secure_tls_session_protocol_version_override.c nxe_secure_tls_session_receive.c nxe_secure_tls_session_renegotiate.c nxe_secure_tls_session_renegotiate_callback_set.c nxe_secure_tls_session_reset.c nxe_secure_tls_session_send.c nxe_secure_tls_session_server_callback_set.c nxe_secure_tls_session_sni_extension_parse.c nxe_secure_tls_session_sni_extension_set.c nxe_secure_tls_session_start.c nxe_secure_tls_session_time_function_set.c nxe_secure_tls_session_x509_client_verify_configure.c nxe_secure_tls_trusted_certificate_add.c nxe_secure_tls_trusted_certificate_remove.c nxe_secure_x509_certificate_initialize.c nxe_secure_x509_common_name_dns_check.c nxe_secure_x509_crl_revocation_check.c nxe_secure_x509_dns_name_initialize.c nxe_secure_x509_extended_key_usage_extension_parse.c nxe_secure_x509_extension_find.c nxe_secure_x509_key_usage_extension_parse.c
  group azure-rtos/netxduo/nx_secure/ports
    ../../../../../rtos/azure-rtos/netxduo/nx_secure/ports/: nx_secure_port.h
  group azure-rtos/threadx/common/inc
    ../../../../../rtos/azure-rtos/threadx/common/inc/: tx_api.h tx_block_pool.h tx_byte_pool.h tx_event_flags.h tx_initialize.h tx_mutex.h tx_queue.h tx_semaphore.h tx_thread.h tx_timer.h tx_trace.h tx_user_sample.h
  group azure-rtos/filex/common/inc
    ../../../../../rtos/azure-rtos/filex/common/inc/: fx_api.h fx_directory.h fx_fault_tolerant.h fx_file.h fx_media.h fx_system.h fx_unicode.h fx_user_sample.h fx_utility.h
  group azure-rtos/netxduo/common/inc
    ../../../../../rtos/azure-rtos/netxduo/common/inc/: nx_api.h nx_arp.h nx_http_proxy_client.h nx_icmp.h nx_icmpv4.h nx_icmpv6.h nx_igmp.h nx_ip.h nx_ipv4.h nx_ipv6.h nx_link.h nx_md5.h nx_mld.h nx_nd_cache.h nx_packet.h nx_rarp.h nx_system.h nx_tcp.h nx_udp.h nx_user_sample.h
  group azure-rtos/threadx/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc/: tx_port.h
  group azure-rtos/filex/ports/generic/inc
    ../../../../../rtos/azure-rtos/filex/ports/generic/inc/: fx_port.h
  group azure-rtos/netxduo/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/netxduo/ports/cortex_m7/ac6/inc/: nx_port.h
target netxduo_lib Release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: netxduo_lib.out (library)
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1062DVL6A, MCUXPRESSO_SDK, TX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, NX_INCLUDE_USER_DEFINE_FILE
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: NDEBUG, NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
