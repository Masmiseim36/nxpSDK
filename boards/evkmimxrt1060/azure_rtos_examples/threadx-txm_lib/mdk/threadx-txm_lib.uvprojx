# Keil uVision project threadx-txm_lib.uvprojx, settings and files
target threadx-txm_lib Debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: threadx-txm_lib.out (library)
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: DEBUG, CPU_MIMXRT1062DVL6A, MCUXPRESSO_SDK, TX_INCLUDE_USER_DEFINE_FILE
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../../rtos/azure-rtos/threadx/common/inc;../../../../../rtos/azure-rtos/threadx/common_modules/inc;../../../../../rtos/azure-rtos/threadx/common_modules/module_manager/inc;../../../../../rtos/azure-rtos/threadx/ports_module/cortex_m7/ac6/inc
  asm define: DEBUG, DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group doc
    ../: readme.txt
  group azure-rtos/config
    ../: tx_user.h
  group azure-rtos/threadx/common/inc
    ../../../../../rtos/azure-rtos/threadx/common/inc/: tx_api.h tx_block_pool.h tx_byte_pool.h tx_event_flags.h tx_initialize.h tx_mutex.h tx_queue.h tx_semaphore.h tx_thread.h tx_timer.h tx_trace.h tx_user_sample.h
  group azure-rtos/threadx/common/src
    ../../../../../rtos/azure-rtos/threadx/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_misra.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
  group azure-rtos/threadx/common_modules/inc
    ../../../../../rtos/azure-rtos/threadx/common_modules/inc/: txm_module.h txm_module_user_sample.h
  group azure-rtos/threadx/common_modules/module_manager/inc
    ../../../../../rtos/azure-rtos/threadx/common_modules/module_manager/inc/: txm_module_manager_dispatch.h txm_module_manager_util.h
  group azure-rtos/threadx/common_modules/module_manager/src
    ../../../../../rtos/azure-rtos/threadx/common_modules/module_manager/src/: txm_module_manager_absolute_load.c txm_module_manager_application_request.c txm_module_manager_callback_request.c txm_module_manager_event_flags_notify_trampoline.c txm_module_manager_file_load.c txm_module_manager_in_place_load.c txm_module_manager_initialize.c txm_module_manager_internal_load.c txm_module_manager_kernel_dispatch.c txm_module_manager_maximum_module_priority_set.c txm_module_manager_memory_load.c txm_module_manager_object_allocate.c txm_module_manager_object_deallocate.c txm_module_manager_object_pointer_get.c txm_module_manager_object_pointer_get_extended.c txm_module_manager_object_pool_create.c txm_module_manager_properties_get.c txm_module_manager_queue_notify_trampoline.c txm_module_manager_semaphore_notify_trampoline.c txm_module_manager_start.c txm_module_manager_stop.c txm_module_manager_thread_create.c txm_module_manager_thread_notify_trampoline.c txm_module_manager_thread_reset.c txm_module_manager_timer_notify_trampoline.c txm_module_manager_unload.c txm_module_manager_util.c
  group azure-rtos/threadx/ports_module/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/threadx/ports_module/cortex_m7/ac6/inc/: tx_port.h txm_module_port.h
  group azure-rtos/threadx/ports_module/cortex_m7/ac6/module_manager/src
    ../../../../../rtos/azure-rtos/threadx/ports_module/cortex_m7/ac6/module_manager/src/: tx_thread_context_restore.S tx_thread_context_save.S tx_thread_interrupt_control.S tx_thread_interrupt_disable.S tx_thread_interrupt_restore.S tx_thread_schedule.S tx_thread_stack_build.S tx_thread_system_return.S tx_timer_interrupt.S txm_module_manager_alignment_adjust.c txm_module_manager_external_memory_enable.c txm_module_manager_memory_fault_handler.c txm_module_manager_memory_fault_notify.c txm_module_manager_mm_register_setup.c txm_module_manager_thread_stack_build.S
target threadx-txm_lib Release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: threadx-txm_lib.out (library)
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1062DVL6A, MCUXPRESSO_SDK, TX_INCLUDE_USER_DEFINE_FILE
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: NDEBUG, NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
