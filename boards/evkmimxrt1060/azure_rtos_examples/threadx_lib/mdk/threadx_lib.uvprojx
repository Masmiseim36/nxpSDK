# Keil uVision project threadx_lib.uvprojx, settings and files
target threadx_lib Debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: libthreadx.lib (library)
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: DEBUG, CPU_MIMXRT1062DVL6A, TX_INCLUDE_USER_DEFINE_FILE
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../rtos/azure-rtos/binary/threadx;../../../../../rtos/azure-rtos/threadx/common/inc;../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc
  asm define: DEBUG, DEBUG, TX_ENABLE_FPU_SUPPORT, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group doc
    ../: readme.txt
  group azure-rtos/user
    ../../../../../rtos/azure-rtos/binary/threadx/: tx_user.h
  group azure-rtos/threadx/common/inc
    ../../../../../rtos/azure-rtos/threadx/common/inc/: tx_byte_pool.h tx_event_flags.h tx_timer.h tx_queue.h tx_thread.h tx_mutex.h tx_trace.h tx_initialize.h tx_api.h tx_user_sample.h tx_block_pool.h tx_semaphore.h
  group azure-rtos/threadx/common/src
    ../../../../../rtos/azure-rtos/threadx/common/src/: txe_thread_preemption_change.c txe_byte_allocate.c tx_queue_performance_system_info_get.c tx_mutex_delete.c tx_block_release.c tx_timer_thread_entry.c tx_byte_pool_prioritize.c txe_byte_pool_prioritize.c tx_initialize_high_level.c tx_event_flags_info_get.c txe_semaphore_ceiling_put.c tx_queue_receive.c tx_semaphore_cleanup.c tx_queue_front_send.c txe_thread_relinquish.c tx_trace_buffer_full_notify.c tx_byte_pool_create.c tx_byte_pool_cleanup.c tx_thread_system_preempt_check.c tx_semaphore_info_get.c txe_queue_info_get.c txe_byte_release.c txe_thread_wait_abort.c txe_mutex_get.c tx_event_flags_initialize.c txe_event_flags_create.c tx_timer_change.c tx_mutex_put.c tx_byte_pool_initialize.c tx_thread_performance_system_info_get.c txe_semaphore_delete.c tx_time_get.c tx_queue_performance_info_get.c tx_thread_preemption_change.c txe_queue_delete.c txe_block_release.c tx_mutex_info_get.c tx_byte_release.c txe_mutex_put.c tx_semaphore_put_notify.c txe_semaphore_get.c tx_trace_user_event_insert.c tx_timer_initialize.c txe_queue_create.c txe_mutex_create.c tx_event_flags_set.c tx_thread_delete.c tx_semaphore_get.c tx_mutex_performance_system_info_get.c txe_event_flags_get.c tx_thread_time_slice_change.c tx_semaphore_delete.c tx_semaphore_initialize.c tx_queue_delete.c tx_semaphore_ceiling_put.c txe_semaphore_put_notify.c tx_thread_timeout.c tx_thread_stack_analyze.c tx_semaphore_performance_info_get.c txe_byte_pool_info_get.c tx_thread_performance_info_get.c tx_timer_system_deactivate.c tx_event_flags_performance_system_info_get.c tx_trace_initialize.c tx_thread_reset.c tx_queue_prioritize.c tx_thread_shell_entry.c txe_timer_info_get.c tx_event_flags_performance_info_get.c tx_block_pool_initialize.c tx_mutex_prioritize.c tx_semaphore_create.c txe_block_pool_info_get.c tx_block_pool_performance_info_get.c tx_thread_priority_change.c tx_queue_info_get.c txe_thread_info_get.c tx_mutex_initialize.c tx_trace_isr_enter_insert.c tx_thread_entry_exit_notify.c tx_thread_stack_error_handler.c txe_timer_activate.c tx_trace_event_unfilter.c tx_thread_relinquish.c txe_semaphore_prioritize.c tx_initialize_kernel_enter.c txe_queue_prioritize.c tx_queue_create.c txe_queue_flush.c tx_trace_disable.c tx_thread_info_get.c tx_block_pool_info_get.c tx_timer_performance_info_get.c txe_timer_create.c tx_timer_info_get.c tx_thread_terminate.c txe_block_pool_create.c tx_block_allocate.c tx_event_flags_cleanup.c tx_mutex_get.c txe_event_flags_set.c tx_initialize_kernel_setup.c txe_byte_pool_create.c tx_timer_expiration_process.c tx_queue_initialize.c tx_timer_performance_system_info_get.c txe_timer_delete.c tx_byte_pool_search.c tx_semaphore_performance_system_info_get.c tx_timer_system_activate.c txe_queue_receive.c tx_block_pool_create.c tx_thread_identify.c tx_byte_pool_delete.c txe_queue_send.c tx_timer_create.c tx_trace_object_register.c tx_thread_resume.c tx_time_set.c tx_timer_activate.c txe_semaphore_create.c txe_semaphore_put.c txe_event_flags_delete.c txe_timer_deactivate.c txe_thread_time_slice_change.c tx_trace_enable.c txe_thread_entry_exit_notify.c txe_thread_delete.c tx_thread_stack_error_notify.c tx_thread_time_slice.c tx_block_pool_performance_system_info_get.c txe_thread_create.c tx_event_flags_delete.c tx_queue_cleanup.c txe_block_pool_prioritize.c tx_mutex_priority_change.c tx_byte_allocate.c tx_event_flags_create.c tx_event_flags_get.c tx_byte_pool_info_get.c tx_event_flags_set_notify.c tx_trace_event_filter.c txe_mutex_prioritize.c txe_queue_front_send.c tx_thread_suspend.c txe_thread_terminate.c txe_thread_suspend.c tx_timer_deactivate.c txe_thread_resume.c tx_thread_initialize.c tx_thread_create.c tx_block_pool_delete.c txe_semaphore_info_get.c tx_thread_sleep.c tx_queue_flush.c txe_block_allocate.c tx_mutex_cleanup.c tx_misra.c tx_mutex_create.c txe_block_pool_delete.c tx_byte_pool_performance_system_info_get.c tx_semaphore_put.c tx_queue_send.c tx_trace_isr_exit_insert.c txe_queue_send_notify.c tx_trace_object_unregister.c txe_byte_pool_delete.c tx_block_pool_prioritize.c tx_timer_delete.c tx_thread_wait_abort.c tx_thread_system_suspend.c tx_queue_send_notify.c tx_thread_system_resume.c tx_trace_interrupt_control.c tx_mutex_performance_info_get.c txe_event_flags_info_get.c txe_mutex_info_get.c txe_event_flags_set_notify.c txe_timer_change.c txe_thread_reset.c txe_mutex_delete.c txe_thread_priority_change.c tx_semaphore_prioritize.c tx_block_pool_cleanup.c tx_byte_pool_performance_info_get.c
  group azure-rtos/threadx/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc/: tx_port.h
  group azure-rtos/threadx/ports/cortex_m7/ac6/src
    ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/src/: tx_thread_context_restore.S tx_thread_context_save.S tx_thread_interrupt_control.S tx_thread_schedule.S tx_thread_stack_build.S tx_thread_system_return.S tx_timer_interrupt.S
target threadx_lib Release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: libthreadx.lib (library)
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1062DVL6A, TX_INCLUDE_USER_DEFINE_FILE
  c misc: as above
  c include: as above
  asm define: NDEBUG, NDEBUG, TX_ENABLE_FPU_SUPPORT, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
