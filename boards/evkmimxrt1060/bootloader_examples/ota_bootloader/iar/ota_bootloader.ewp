# IAR project ota_bootloader.ewp, settings and files
configuration flexspi_nor_release (ARM)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1062DVL6A; CPU_IS_ARM_CORTEX_M7=1; BL_TARGET_FLASH; MIMXRT1062; USB_STACK_BM
  ICCARM.CCDiagSuppress: Pa082,Pe177,Pe186,Ms014,Pa182
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../middleware/mcu-boot/targets/MIMXRT1062/src; ../../../../../middleware/mcu-boot/src/autobaud; ../../../../../middleware/mcu-boot/src/drivers/sdmmc/inc; ..; ../../../../../middleware/mcu-boot/src/bootloader; ../../../../../devices/MIMXRT1062; ../../../../../devices/MIMXRT1062/drivers; ../../../../../middleware/mcu-boot/src/bm_usb; ../../../../../middleware/mcu-boot/src/crc; ../../../../../middleware/mcu-boot/src/include; ../../../../../middleware/mcu-boot/src/startup; ../../../../../middleware/mcu-boot/src/utilities; ../../../../../middleware/mcu-boot/src/memory; ../../../../../middleware/mcu-boot/src/memory/src; ../../../../../middleware/mcu-boot/src/packet; ../../../../../middleware/mcu-boot/src/property; ../../../../../middleware/mcu-boot/src/sbloader; ../../../../../middleware/mcu-boot/src/drivers/smc; ../../../../../middleware/mcu-boot/src/drivers/dcp; ../../../../../middleware/mcu-boot/src/drivers/trng; ../../../../../components/osa; ../../../../../middleware/usb/device; ../../../../../middleware/usb/include; ../../../../../middleware/mcu-boot/src/drivers/microseconds; ../../../../../middleware/mcu-boot/src/drivers/flexspi; ../../../../../middleware/mcu-boot/src/drivers/flexspi_nand; ../../../../../middleware/mcu-boot/src/drivers/ocotp; ../../../../../components/lists; ../../../../../middleware/usb/phy; ../../../../../middleware/mcu-boot/src/drivers/flexspi_nor; ../../../../../middleware/mcu-boot/src/drivers/semc; ../../../../../middleware/mcu-boot/src/drivers/semc_nor; ../../../../../middleware/mcu-boot/src/drivers/semc_nand; ../../../../../middleware/mcu-boot/src/drivers/nand_ecc; ../../../../../middleware/mcu-boot/src/drivers/usdhc; ../../../../../middleware/mcu-boot/src/drivers/serial_nor_eeprom
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG
  AARM.AUserIncludes: ../../../../../middleware/mcu-boot/src/startup
  ILINK.IlinkOutputFile: ota_bootloader.out
  ILINK.IlinkIcfFile: MIMXRT1062_flash_bootloader.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group board
    ../: pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group source/bootloader
    ../../../../../middleware/mcu-boot/src/bootloader/: bl_reliable_update.h bl_app_crc_check.h bl_command.h bl_context.h bl_irq_common.h bl_peripheral.h bl_peripheral_interface.h bl_shutdown_cleanup.h bl_user_entry.h bl_version.h bootloader.h bl_keyblob.h bl_nor_encrypt.h
  group source/bootloader/src
    ../../../../../middleware/mcu-boot/src/bootloader/src/: bl_reliable_update_common.c bl_app_crc_check.c bl_command.c bl_context.c bl_exception_handler.c bl_main.c bl_misc.c bl_shutdown_cleanup.c bl_tree_root.c bl_user_entry.c bl_keyblob.c bl_keyblob_dcp.c bl_nor_encrypt_bee.c lpuart_peripheral_interface.c usb_hid_msc_peripheral_interface.c
  group source/usb/bm_composite
    ../../../../../middleware/mcu-boot/src/bm_usb/: bootloader_hid_report_ids.h composite.c composite.h fat_directory_entry.h hid_bootloader.c hid_bootloader.h usb_descriptor.c usb_descriptor.h
    ../../../../../middleware/mcu-boot/targets/MIMXRT1062/src/: usb_device_config.h
  group source/autobaud
    ../../../../../middleware/mcu-boot/src/autobaud/: autobaud.h
    ../../../../../middleware/mcu-boot/src/autobaud/src/: autobaud_irq.c
  group source/crc
    ../../../../../middleware/mcu-boot/src/crc/: crc16.h crc32.h
    ../../../../../middleware/mcu-boot/src/crc/src/: crc16.c crc32.c
  group source/include
    ../../../../../middleware/mcu-boot/src/include/: bootloader_common.h bootloader_core.h
  group source/memory
    ../../../../../middleware/mcu-boot/src/memory/: memory.h
  group source/memory/src
    ../../../../../middleware/mcu-boot/src/memory/src/: memory.c normal_memory.c normal_memory.h pattern_fill.h pattern_fill.s sram_init.h flexspi_nor_memory.c flexspi_nor_memory.h spinand_memory.c spinand_memory.h semc_nor_memory.c semc_nor_memory.h semc_nand_memory.c semc_nand_memory.h mmc_memory.c mmc_memory.h sd_memory.c sd_memory.h spi_nor_eeprom_memory.c spi_nor_eeprom_memory.h
    ../../../../../middleware/mcu-boot/targets/MIMXRT1062/src/: sram_init_MIMXRT1062.c
  group source/packet
    ../../../../../middleware/mcu-boot/src/packet/: command_packet.h serial_packet.h
  group source/packet/src
    ../../../../../middleware/mcu-boot/src/packet/src/: serial_packet.c
  group source/property
    ../../../../../middleware/mcu-boot/src/property/: property.h
  group source/property/src
    ../../../../../middleware/mcu-boot/src/property/src/: property_imx.c
  group source/sbloader
    ../../../../../middleware/mcu-boot/src/sbloader/: sb_file_format.h sbloader.h
  group source/sbloader/src
    ../../../../../middleware/mcu-boot/src/sbloader/src/: sbloader.c
  group source/utilities
    ../../../../../middleware/mcu-boot/src/utilities/: fsl_assert.h fsl_rtos_abstraction.h vector_table_info.h
  group source/utilities/src
    ../../../../../middleware/mcu-boot/src/utilities/src/: debug_util.c fsl_assert.c fsl_rtos_abstraction.c
  group source/drivers
    ../../../../../middleware/mcu-boot/src/drivers/smc/: smc.h
  group source/drivers/dcp
    ../../../../../middleware/mcu-boot/src/drivers/dcp/: bl_dcp.c bl_dcp.h
  group source/drivers/trng
    ../../../../../middleware/mcu-boot/src/drivers/trng/: bl_trng.c bl_trng.h
  group source/drivers/microseconds
    ../../../../../middleware/mcu-boot/src/drivers/microseconds/: microseconds.h
    ../../../../../middleware/mcu-boot/src/drivers/microseconds/src/: microseconds_pit.c
  group source/drivers/flexspi
    ../../../../../middleware/mcu-boot/src/drivers/flexspi/: bl_flexspi.c bl_flexspi.h bl_flexspi.c bl_flexspi.h
  group source/drivers/flexspi_nand
    ../../../../../middleware/mcu-boot/src/drivers/flexspi_nand/: flexspi_nand_flash.c flexspi_nand_flash.h
  group source/drivers/ocotp
    ../../../../../middleware/mcu-boot/src/drivers/ocotp/: bl_ocotp.c bl_ocotp.h
  group source/drivers/flexspi_nor
    ../../../../../middleware/mcu-boot/src/drivers/flexspi_nor/: flexspi_nor_flash.c flexspi_nor_flash.h
  group source/drivers/semc
    ../../../../../middleware/mcu-boot/src/drivers/semc/: bl_semc.c bl_semc.h bl_semc.c bl_semc.h
  group source/drivers/semc_nor
    ../../../../../middleware/mcu-boot/src/drivers/semc_nor/: semc_nor_flash.c semc_nor_flash.h
  group source/drivers/nand_ecc
    ../../../../../middleware/mcu-boot/src/drivers/nand_ecc/: nand_ecc.c nand_ecc.h
  group source/drivers/semc_nand
    ../../../../../middleware/mcu-boot/src/drivers/semc_nand/: semc_nand_flash.c semc_nand_flash.h
  group source/drivers/sdmmc
    ../../../../../middleware/mcu-boot/src/drivers/sdmmc/inc/: bl_card.h bl_host.h bl_sdmmc.h bl_specification.h
    ../../../../../middleware/mcu-boot/src/drivers/sdmmc/port/usdhc/polling/: bl_host.c
    ../../../../../middleware/mcu-boot/src/drivers/sdmmc/src/: bl_mmc.c bl_sd.c bl_sdmmc.c
  group source/drivers/usdhc
    ../../../../../middleware/mcu-boot/src/drivers/usdhc/: bl_usdhc.c bl_usdhc.h
  group source/drivers/serial_nor_eeprom
    ../../../../../middleware/mcu-boot/src/drivers/serial_nor_eeprom/: serial_nor_eeprom.c serial_nor_eeprom.h
  group device
    ../../../../../devices/MIMXRT1062/: MIMXRT1062.h MIMXRT1062_features.h fsl_device_registers.h system_MIMXRT1062.h
    ../../../../../middleware/mcu-boot/targets/MIMXRT1062/src/startup/: system_MIMXRT1062.c
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_clock.c fsl_clock.h fsl_gpio.c fsl_gpio.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h fsl_common.c fsl_common.h fsl_lpspi.c fsl_lpspi.h
    ../../../../../middleware/mcu-boot/targets/MIMXRT1062/src/: fsl_rtwdog.h fsl_wdog.h
  group startup
    ../../../../../middleware/mcu-boot/targets/MIMXRT1062/src/startup/iar/: startup_MIMXRT1062.s
    ../../../../../middleware/mcu-boot/src/startup/: ar_asm_macros.h startup.c
  group MIMXRT1062
    ../../../../../middleware/mcu-boot/targets/MIMXRT1062/src/: bl_api.c bl_api.h bl_clock_config_MIMXRT1062.c bl_lpuart_irq_config_MIMXRT1062.c bl_peripherals_MIMXRT1062.c bootloader_config.h external_memory_property_map_MIMXRT1062.c flexspi_nand_config_MIMXRT1062.c flexspi_nor_config_MIMXRT1062.c fusemap.h hardware_init_MIMXRT1062.c memory_map_MIMXRT1062.c peripherals_pinmux.h sdmmc_config_MIMXRT1062.c sdmmc_init.h semc_nand_config_MIMXRT1062.c semc_nor_config_MIMXRT1062.c target_config.h
    ../../../../../middleware/mcu-boot/targets/common/src/: pinmux_utility_imxrt_series.c
  group usb/device/include
    ../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group usb/device/source
    ../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h usb_device_dci.h
    ../: usb_device_ch9.c usb_device_ch9.h
  group usb/device/source/ehci
    ../../../../../middleware/usb/device/: usb_device_ehci.c usb_device_ehci.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/hid
    ../: usb_device_hid.c usb_device_hid.h
  group usb/phy
    ../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group usb/include
    ../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
