# IAR project mc_pmsm.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1062DVL6A; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../middleware/motor_control/boards/evkmimxrt1060/mc_pmsm/pmsm_snsless; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_drivers; ../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_state_machine; ../../../../../../platform/drivers/adc_etc; ../../../../../../middleware/motor_control/fmstr_cfg_lpuart; ../../../../../../middleware/motor_control/boards/evkmimxrt1060/mc_pmsm/pmsm_enc; ..; ../../../../../../devices/MIMXRT1062/drivers; ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_IAR/AMCLIB; ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_IAR/AMCLIB/Include; ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_IAR/GDFLIB; ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_IAR/GDFLIB/Include; ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_IAR/GFLIB; ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_IAR/GFLIB/Include; ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_IAR/GMCLIB; ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_IAR/GMCLIB/Include; ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_IAR/MLIB; ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_IAR/MLIB/Include; ../../../../../../middleware/motor_control/pmsm/pmsm_float; ../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_algorithms; ../../../../../../middleware/motor_control/pmsm/pmsm_float/state_machine; ../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_identification; ../../../../../../devices/MIMXRT1062; ../../../../../../devices/MIMXRT1062/utilities/str; ../../../../../../devices/MIMXRT1062/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1062/xip; ../../../../xip; ../../../../../../middleware/freemaster/src/common; ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial; ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can; ../../../../../../middleware/freemaster/src/platforms/gen32le; ../../../../../../devices/MIMXRT1062/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: mc_pmsm.out
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_ram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_IAR/AMCLIB/AMCLIB.a; ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_IAR/GDFLIB/GDFLIB.a; ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_IAR/GFLIB/GFLIB.a; ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_IAR/GMCLIB/GMCLIB.a; ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_IAR/MLIB/MLIB.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1062DVL6A; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; DEBUG; CPU_MIMXRT1062DVL6A; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1062DVL6A; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1062DVL6A; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1062DVL6A; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_sdram.icf
  group mc_drivers
    ../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_drivers/: mcdrv_adc_imxrt.h mcdrv_adc_imxrt.c mcdrv_pwm3ph_pwma.c mcdrv_pwm3ph_pwma.h mcdrv_enc_qd.c mcdrv_enc_qd.h
  group mc_state_machine
    ../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_state_machine/: m1_sm_snsless_enc.c m1_sm_snsless_enc.h sm_common_enc.h
  group source
    ../: freemaster_cfg.h main.c main.h
    ../../../../../../middleware/motor_control/pmsm/pmsm_float/: fm_tsa_pmsm.c fm_tsa_pmsm.h
  group board
    ../: m1_pmsm_appconfig.h mcdrv_evkmimxrt1060.c mcdrv_evkmimxrt1060.h mcdrv.h pin_mux.c pin_mux.h char_pwrstg.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MIMXRT1062/drivers/: fsl_dmamux.c fsl_dmamux.h fsl_xbara.c fsl_xbara.h fsl_clock.c fsl_clock.h fsl_adc_etc.c fsl_adc_etc.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h fsl_gpio.c fsl_gpio.h
  group rtcesl/amclib
    ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_IAR/AMCLIB/Include/: AMCLIB_ACIMCtrlMTPA_FLT.h AMCLIB_ACIMRotFluxObsrv_FLT.h AMCLIB_ACIMSpeedMRAS_FLT.h AMCLIB_AngleTrackObsrv_F32.h AMCLIB_AngleTrackObsrv_FLT.h AMCLIB_CtrlFluxWkng_A32.h AMCLIB_CtrlFluxWkng_FLT.h AMCLIB_PMSMBemfObsrvAB_A32.h AMCLIB_PMSMBemfObsrvAB_FLT.h AMCLIB_PMSMBemfObsrvDQ_A32.h AMCLIB_PMSMBemfObsrvDQ_FLT.h AMCLIB_TrackObsrv_F32.h AMCLIB_TrackObsrv_FLT.h amclib.h amclib_FP.h amclib_types.h
  group rtcesl/gdflib
    ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_IAR/GDFLIB/Include/: GDFLIB_FilterExp_F32.h GDFLIB_FilterExp_FLT.h GDFLIB_FilterIIR1_F32.h GDFLIB_FilterIIR1_F32_Asmi.h GDFLIB_FilterIIR1_FLT.h GDFLIB_FilterIIR2_F32.h GDFLIB_FilterIIR2_FLT.h GDFLIB_FilterIIR3_F32.h GDFLIB_FilterIIR3_FLT.h GDFLIB_FilterIIR4_F32.h GDFLIB_FilterIIR4_FLT.h GDFLIB_FilterMA_A32.h GDFLIB_FilterMA_FLT.h gdflib.h gdflib_FP.h gdflib_types.h
  group rtcesl/gflib
    ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_IAR/GFLIB/Include/: GFLIB_Acos_F16.h GFLIB_Acos_FLT.h GFLIB_Asin_F16.h GFLIB_Asin_FLT.h GFLIB_AtanYX_F16.h GFLIB_AtanYX_FLT.h GFLIB_Atan_F32.h GFLIB_Atan_FLT.h GFLIB_CtrlBetaIPDp_A32.h GFLIB_CtrlBetaIPDp_FLT.h GFLIB_CtrlBetaIPp_A32.h GFLIB_CtrlBetaIPp_FLT.h GFLIB_CtrlPIDp_A32.h GFLIB_CtrlPIDp_FLT.h GFLIB_CtrlPIp_A32.h GFLIB_CtrlPIp_FLT.h GFLIB_DFlexRamp_A32.h GFLIB_DFlexRamp_FLT.h GFLIB_DRamp_F16.h GFLIB_DRamp_F32.h GFLIB_DRamp_FLT.h GFLIB_FlexRamp_A32.h GFLIB_FlexRamp_FLT.h GFLIB_FlexSRamp_A32.h GFLIB_FlexSRamp_FLT.h GFLIB_Hyst_F16_Asmi.h GFLIB_Hyst_FLT.h GFLIB_Integrator_A32.h GFLIB_Integrator_FLT.h GFLIB_Limit_F16.h GFLIB_Limit_F32.h GFLIB_Limit_FLT.h GFLIB_LowerLimit_F16.h GFLIB_LowerLimit_F32.h GFLIB_LowerLimit_FLT.h GFLIB_LutPer_F16_Asmi.h GFLIB_LutPer_F32.h GFLIB_LutPer_FLT.h GFLIB_Lut_F16_Asmi.h GFLIB_Lut_F32.h GFLIB_Lut_FLT.h GFLIB_Ramp_F16.h GFLIB_Ramp_F32.h GFLIB_Ramp_FLT.h GFLIB_SinCos_F32.h GFLIB_SinCos_FLT.h GFLIB_Sqrt_F16.h GFLIB_Sqrt_F32.h GFLIB_Sqrt_FLT_Asmi.h GFLIB_Tan_F32.h GFLIB_Tan_FLT.h GFLIB_UpperLimit_F16.h GFLIB_UpperLimit_F32.h GFLIB_UpperLimit_FLT.h GFLIB_VectorLimit_F16.h GFLIB_VectorLimit_FLT.h gflib.h gflib_FP.h gflib_types.h
  group rtcesl/gmclib
    ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_IAR/GMCLIB/Include/: GMCLIB_Clark_F16_Asmi.h GMCLIB_Clark_FLT.h GMCLIB_Decoupling_A32.h GMCLIB_Decoupling_FLT.h GMCLIB_ElimDcBusRip_A32_Asmi.h GMCLIB_ElimDcBusRip_F16_Asmi.h GMCLIB_ElimDcBusRip_FLT.h GMCLIB_Park_F16_Asmi.h GMCLIB_Park_FLT.h GMCLIB_Svm_F16.h gmclib.h gmclib_FP.h gmclib_types.h
  group rtcesl/mlib
    ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_IAR/MLIB/Include/: MLIB_Abs_F16.h MLIB_Abs_F16_Asmi.h MLIB_Abs_F32.h MLIB_Abs_F32_Asmi.h MLIB_Abs_FLT.h MLIB_Abs_FLT_Asmi.h MLIB_Add4_F16_Asmi.h MLIB_Add4_F32_Asmi.h MLIB_Add4_FLT.h MLIB_Add_A32.h MLIB_Add_F16.h MLIB_Add_F16_Asmi.h MLIB_Add_F32.h MLIB_Add_F32_Asmi.h MLIB_Add_FLT.h MLIB_BiShift_F16.h MLIB_BiShift_F32.h MLIB_Clb_F16.h MLIB_Clb_F32.h MLIB_ConvSc_FLT_Asmi.h MLIB_Conv_F32.h MLIB_Conv_FLT_Asmi.h MLIB_Div1Q_A32.h MLIB_Div1Q_F16.h MLIB_Div1Q_F32.h MLIB_Div_A32.h MLIB_Div_F16.h MLIB_Div_F32.h MLIB_Div_FLT.h MLIB_Log2_U16.h MLIB_Mac4Rnd_F16_Asmi.h MLIB_Mac4Rnd_F32.h MLIB_Mac4Rnd_F32_Asmi.h MLIB_Mac4_F32.h MLIB_Mac4_F32_Asmi.h MLIB_Mac4_FLT.h MLIB_MacRnd_A32.h MLIB_MacRnd_F16_Asmi.h MLIB_MacRnd_F32.h MLIB_MacRnd_F32_Asmi.h MLIB_Mac_A32.h MLIB_Mac_F16_Asmi.h MLIB_Mac_F32.h MLIB_Mac_F32_Asmi.h MLIB_Mac_FLT.h MLIB_MnacRnd_A32.h MLIB_MnacRnd_F16_Asmi.h MLIB_MnacRnd_F32.h MLIB_MnacRnd_F32_Asmi.h MLIB_Mnac_A32.h MLIB_Mnac_F16_Asmi.h MLIB_Mnac_F32.h MLIB_Mnac_F32_Asmi.h MLIB_Mnac_FLT.h MLIB_Msu4Rnd_F16.h MLIB_Msu4Rnd_F16_Asmi.h MLIB_Msu4Rnd_F32.h MLIB_Msu4Rnd_F32_Asmi.h MLIB_Msu4_F32.h MLIB_Msu4_F32_Asmi.h MLIB_Msu4_FLT.h MLIB_MsuRnd_A32.h MLIB_MsuRnd_F16_Asmi.h MLIB_MsuRnd_F32.h MLIB_MsuRnd_F32_Asmi.h MLIB_Msu_A32.h MLIB_Msu_F16_Asmi.h MLIB_Msu_F32_Asmi.h MLIB_Msu_FLT.h MLIB_MulRnd_A32.h MLIB_MulRnd_A32_Asmi.h MLIB_MulRnd_F16.h MLIB_MulRnd_F16_Asmi.h MLIB_MulRnd_F32.h MLIB_MulRnd_F32_Asmi.h MLIB_Mul_A32.h MLIB_Mul_A32_Asmi.h MLIB_Mul_F16.h MLIB_Mul_F16_Asmi.h MLIB_Mul_F32.h MLIB_Mul_F32_Asmi.h MLIB_Mul_FLT.h MLIB_Neg_F16.h MLIB_Neg_F16_Asmi.h MLIB_Neg_F32.h MLIB_Neg_F32_Asmi.h MLIB_Neg_FLT.h MLIB_Rcp1Q_A32.h MLIB_Rcp_A32.h MLIB_Rnd_F32.h MLIB_Rnd_F32_Asmi.h MLIB_Sat_A32_Asmi.h MLIB_Shift_F16.h MLIB_Shift_F16_Asmi.h MLIB_Shift_F32.h MLIB_Shift_F32_Asmi.h MLIB_Sign_F16_Asmi.h MLIB_Sign_F32_Asmi.h MLIB_Sign_FLT_Asmi.h MLIB_Sub4_F16_Asmi.h MLIB_Sub4_F32_Asmi.h MLIB_Sub4_FLT.h MLIB_Sub_A32.h MLIB_Sub_F16.h MLIB_Sub_F16_Asmi.h MLIB_Sub_F32.h MLIB_Sub_F32_Asmi.h MLIB_Sub_F64.h MLIB_Sub_FLT.h RTCESL_cfg.h asm_mac.h mlib.h mlib_FP.h mlib_types.h
  group mc_algorithms
    ../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_algorithms/: pmsm_control.c pmsm_control.h
  group mc_identification
    ../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_identification/: hall_calib.c hall_calib.h ke_measure.c ke_measure.h ls_measure.c ls_measure.h mech_measure.c mech_measure.h mid_auxiliary.c mid_auxiliary.h mid_def.h mid_sm_ctrl.c mid_sm_ctrl.h mid_sm_states.c mid_sm_states.h pp_measure.c pp_measure.h pwrstg_characteristic.c pwrstg_characteristic.h rs_measure.c rs_measure.h
  group state_machine
    ../../../../../../middleware/motor_control/pmsm/pmsm_float/state_machine/: state_machine.c state_machine.h
  group device
    ../../../../../../devices/MIMXRT1062/: MIMXRT1062.h MIMXRT1062_features.h fsl_device_registers.h system_MIMXRT1062.c system_MIMXRT1062.h
  group utilities
    ../../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../components/uart/: lpuart_adapter.c uart.h
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group xip
    ../../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
  group freemaster
    ../../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_can.c freemaster_can.h freemaster_defcfg.h freemaster_pdbdm.c freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_serial.c freemaster_serial.h freemaster_sha.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h
  group freemaster/drivers/mcuxsdk/can
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mcan.c freemaster_mcan.h freemaster_mscan.c freemaster_mscan.h
  group freemaster/drivers/mcuxsdk/serial
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_usb.c freemaster_serial_usb.h
  group freemaster/platforms
    ../../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
