# IAR project sai_peripheral.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM7; CPU_MIMXRT1062DVL6A; PRINTF_FLOAT_ENABLE=1; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; DISABLEFLOAT16; SD_ENABLED
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../devices/MIMXRT1062/drivers; ../../../../../components/codec/wm8960; ../../../../../CMSIS/DSP/Include; ../../../../../CMSIS/DSP/PrivateInclude; ../../../../../CMSIS/DSP/Source/DistanceFunctions; ../../../../../middleware/fatfs/source/fsl_sd_disk; ../../../../../middleware/fatfs/source; ../../../../../components/codec/port/wm8960; ../../../../../components/codec/port; ../../../../../components/codec; ../../../../../components/i2c; ../../../../../components/codec/i2c; ../../../../../middleware/sdmmc/host/usdhc; ../../../../../middleware/sdmmc/sd; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../devices/MIMXRT1062/utilities/debug_console_lite; ../../../../../components/gpio; ../../../../../devices/MIMXRT1062; ../../../../../components/uart; ../../../../../components/lists; ../../../../../devices/MIMXRT1062/xip; ../../../xip; ../../../../../middleware/sdmmc/common; ../../../../../middleware/sdmmc/osa; ../../../../../components/osa; ../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: sai_peripheral.out
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; ARM_MATH_CM7; CPU_MIMXRT1062DVL6A; PRINTF_FLOAT_ENABLE=1; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; DISABLEFLOAT16; SD_ENABLED
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; DEBUG; ARM_MATH_CM7; CPU_MIMXRT1062DVL6A; PRINTF_FLOAT_ENABLE=1; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; DISABLEFLOAT16; SD_ENABLED
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM7; CPU_MIMXRT1062DVL6A; PRINTF_FLOAT_ENABLE=1; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; DISABLEFLOAT16; SD_ENABLED
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; ARM_MATH_CM7; CPU_MIMXRT1062DVL6A; PRINTF_FLOAT_ENABLE=1; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; DISABLEFLOAT16; SD_ENABLED
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; NDEBUG; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; ARM_MATH_CM7; CPU_MIMXRT1062DVL6A; PRINTF_FLOAT_ENABLE=1; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; DISABLEFLOAT16; SD_ENABLED
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_sdram.icf
  group source
    ../: ffconf.h recordtoSdcard.c sai.h sai_peripheral.c recordPlayback.c playbackSineWave.c
  group board
    ../: sdmmc_config.h sdmmc_config.c pin_mux.c pin_mux.h peripherals.c peripherals.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.md
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_lpi2c.c fsl_lpi2c.h fsl_usdhc.c fsl_usdhc.h fsl_cache.c fsl_cache.h fsl_clock.h fsl_clock.c fsl_sai.h fsl_sai.c fsl_sai_edma.h fsl_sai_edma.c fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group codec
    ../../../../../components/codec/wm8960/: fsl_wm8960.h fsl_wm8960.c
    ../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
  group codec/port
    ../../../../../components/codec/port/: fsl_codec_adapter.h
  group codec/port/wm8960
    ../../../../../components/codec/port/wm8960/: fsl_codec_wm8960_adapter.c fsl_codec_wm8960_adapter.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
  group CMSIS/DSP/Include
    ../../../../../CMSIS/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h arm_common_tables_f16.h arm_const_structs_f16.h arm_helium_utils.h arm_math_f16.h arm_math_memory.h arm_math_types.h arm_math_types_f16.h arm_mve_tables.h arm_mve_tables_f16.h arm_vec_math.h arm_vec_math_f16.h
  group CMSIS/DSP/Include/dsp
    ../../../../../CMSIS/DSP/Include/dsp/: basic_math_functions.h basic_math_functions_f16.h bayes_functions.h bayes_functions_f16.h complex_math_functions.h complex_math_functions_f16.h controller_functions.h controller_functions_f16.h distance_functions.h distance_functions_f16.h fast_math_functions.h fast_math_functions_f16.h filtering_functions.h filtering_functions_f16.h interpolation_functions.h interpolation_functions_f16.h matrix_functions.h matrix_functions_f16.h none.h quaternion_math_functions.h statistics_functions.h statistics_functions_f16.h support_functions.h support_functions_f16.h svm_defines.h svm_functions.h svm_functions_f16.h transform_functions.h transform_functions_f16.h utils.h
  group CMSIS/DSP/PrivateInclude
    ../../../../../CMSIS/DSP/PrivateInclude/: arm_sorting.h arm_vec_fft.h arm_vec_filtering.h
  group CMSIS/DSP/Source/BasicMathFunctions
    ../../../../../CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
  group CMSIS/DSP/Source/BayesFunctions
    ../../../../../CMSIS/DSP/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
  group CMSIS/DSP/Source/CommonTables
    ../../../../../CMSIS/DSP/Source/CommonTables/: CommonTables.c CommonTablesF16.c
  group CMSIS/DSP/Source/ComplexMathFunctions
    ../../../../../CMSIS/DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
  group CMSIS/DSP/Source/ControllerFunctions
    ../../../../../CMSIS/DSP/Source/ControllerFunctions/: ControllerFunctions.c
  group CMSIS/DSP/Source/DistanceFunctions
    ../../../../../CMSIS/DSP/Source/DistanceFunctions/: DistanceFunctions.c arm_boolean_distance_template.h DistanceFunctionsF16.c
  group CMSIS/DSP/Source/FastMathFunctions
    ../../../../../CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
  group CMSIS/DSP/Source/FilteringFunctions
    ../../../../../CMSIS/DSP/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
  group CMSIS/DSP/Source/InterpolationFunctions
    ../../../../../CMSIS/DSP/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
  group CMSIS/DSP/Source/MatrixFunctions
    ../../../../../CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
  group CMSIS/DSP/Source/QuaternionMathFunctions
    ../../../../../CMSIS/DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
  group CMSIS/DSP/Source/SVMFunctions
    ../../../../../CMSIS/DSP/Source/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
  group CMSIS/DSP/Source/StatisticsFunctions
    ../../../../../CMSIS/DSP/Source/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
  group CMSIS/DSP/Source/SupportFunctions
    ../../../../../CMSIS/DSP/Source/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
  group CMSIS/DSP/Source/TransformFunctions
    ../../../../../CMSIS/DSP/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
  group fatfs/source
    ../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_sd_disk
    ../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group component/i2c
    ../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group component/gpio
    ../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c fsl_os_abstraction.h fsl_os_abstraction_config.h
  group sdmmc/host
    ../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt ChangeLogKSDK.txt
    ../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group sdmmc/src
    ../../../../../middleware/sdmmc/sd/: fsl_sd.c
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc/sd/: fsl_sd.h
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sd
    ../../../../../middleware/sdmmc/sd/: ChangeLogKSDK.txt
  group sdmmc/osa
    ../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c fsl_assert.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group startup
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
