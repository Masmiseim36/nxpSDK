# Keil uVision project sd_jpeg.uvprojx, settings and files
target sd_jpeg sdram_debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: sd_jpeg.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, DEBUG, CPU_MIMXRT1062DVL6A, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SDK_DEBUGCONSOLE_UART, SD_ENABLED, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../devices/MIMXRT1062/drivers;../../../../../components/video/display/dc/elcdif;../../../../../middleware/sdmmc/sd;../../../../../middleware/sdmmc/common;../../../../../middleware/sdmmc/host/usdhc;../../../../../devices/MIMXRT1062/utilities/str;../../../../../devices/MIMXRT1062/utilities/debug_console_lite;../../../../../components/gpio;../../../../../middleware/libjpeg/inc;../../../../../middleware/fatfs/source;../../../../../middleware/fatfs/source/fsl_sd_disk;../../../../../components/video;../../../../../components/video/display/dc;../../../../../devices/MIMXRT1062;../../../../../components/uart;../../../../../components/lists;../../../../../devices/MIMXRT1062/xip;../../../xip;../../../../../CMSIS/Core/Include;../../../../../middleware/sdmmc/osa;../../../../../components/osa
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_sdram.scf
  link misc: --remove --entry=Reset_Handler --predefine="-D__stack_size__=0x1000" --predefine="-D__heap_size__=0x20000"
  group source
    ../: sd_jpeg.c jconfig.h ffconf.h
  group board
    ../: display_support.h display_support.c sdmmc_config.h sdmmc_config.c pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_cache.c fsl_cache.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_usdhc.c fsl_usdhc.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_elcdif.c fsl_elcdif.h
  group video
    ../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.h fsl_dc_fb_elcdif.c
    ../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../components/video/display/dc/: fsl_dc_fb.h
  group sdmmc/src
    ../../../../../middleware/sdmmc/sd/: fsl_sd.c
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc/sd/: fsl_sd.h
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sd
    ../../../../../middleware/sdmmc/sd/: ChangeLogKSDK.txt
  group sdmmc/host
    ../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt
    ../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group component/gpio
    ../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group libjpeg/inc
    ../../../../../middleware/libjpeg/inc/: cderror.h cdjpeg.h jdct.h jerror.h jinclude.h jmemsys.h jmorecfg.h jpegint.h jpeglib.h jversion.h transupp.h
  group libjpeg/src
    ../../../../../middleware/libjpeg/src/: jaricom.c jcapimin.c jcapistd.c jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcprepct.c jcsample.c jctrans.c jdapimin.c jdapistd.c jdarith.c jdatadst.c jdatasrc.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jdtrans.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jmemmgr.c jmemnobs.c jquant1.c jquant2.c jutils.c
  group fatfs/source
    ../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_sd_disk
    ../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1062/arm/: startup_MIMXRT1062.S
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
  group sdmmc/osa
    ../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.c
target sd_jpeg flexspi_nor_sdram_debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: sd_jpeg.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, DEBUG, CPU_MIMXRT1062DVL6A, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SDK_DEBUGCONSOLE_UART, SD_ENABLED, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor_sdram.scf
  link misc: --remove --entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-D__stack_size__=0x1000" --predefine="-D__heap_size__=0x20000"
target sd_jpeg sdram_release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: sd_jpeg.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, CPU_MIMXRT1062DVL6A, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SDK_DEBUGCONSOLE_UART, SD_ENABLED, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_sdram.scf
  link misc: as above
target sd_jpeg flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: sd_jpeg.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, CPU_MIMXRT1062DVL6A, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SDK_DEBUGCONSOLE_UART, SD_ENABLED, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor_sdram.scf
  link misc: as above
