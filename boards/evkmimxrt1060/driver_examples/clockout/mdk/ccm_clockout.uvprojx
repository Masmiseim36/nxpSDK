# Keil uVision project ccm_clockout.uvprojx, settings and files
target ccm_clockout debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ccm_clockout.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT1062DVL6A, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../devices/MIMXRT1062/drivers;../../../../../devices/MIMXRT1062;../../../../../devices/MIMXRT1062/utilities/str;../../../../../devices/MIMXRT1062/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../devices/MIMXRT1062/xip;../../../xip;../../../../../components/silicon_id;../../../../../CMSIS/Core/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_ram.scf
  link misc: --remove --entry=Reset_Handler
  group source
    ../: clockout.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1062/arm/: startup_MIMXRT1062.S
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
  group component/silicon_id
    ../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
target ccm_clockout flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ccm_clockout.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1062DVL6A, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: --remove --entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
target ccm_clockout sdram_debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ccm_clockout.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, DEBUG, CPU_MIMXRT1062DVL6A, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_sdram.scf
  link misc: --remove --entry=Reset_Handler
target ccm_clockout release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ccm_clockout.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1062DVL6A, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_ram.scf
  link misc: --remove --entry=Reset_Handler
target ccm_clockout flexspi_nor_release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ccm_clockout.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1062DVL6A, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: as above
target ccm_clockout sdram_release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ccm_clockout.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, CPU_MIMXRT1062DVL6A, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_sdram.scf
  link misc: --remove --entry=Reset_Handler
