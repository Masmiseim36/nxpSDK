# IAR project sai_edma_transfer.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1062DVL6A; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../..; ..; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MIMXRT1062/drivers; ../../../../../../components/codec/wm8960; ../../../../../../components/codec; ../../../../../../components/codec/port/wm8960; ../../../../../../components/codec/i2c; ../../../../../../components/i2c; ../../../../../../devices/MIMXRT1062; ../../../../../../devices/MIMXRT1062/utilities/str; ../../../../../../devices/MIMXRT1062/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1062/xip; ../../../../xip; ../../../../../../devices/MIMXRT1062/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: sai_edma_transfer.out
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1062DVL6A; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; DEBUG; CPU_MIMXRT1062DVL6A; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1062DVL6A; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1062DVL6A; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1062DVL6A; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_sdram.icf
  group source
    ../: sai_edma_transfer.c music.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MIMXRT1062/drivers/: fsl_lpi2c.c fsl_lpi2c.h fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h fsl_gpio.c fsl_gpio.h
  group codec
    ../../../../../../components/codec/wm8960/: fsl_wm8960.c fsl_wm8960.h
    ../../../../../../components/codec/: fsl_codec_common.c fsl_codec_common.h
    ../../../../../../components/codec/port/wm8960/: fsl_codec_adapter.c fsl_codec_adapter.h
    ../../../../../../components/codec/i2c/: fsl_codec_i2c.c fsl_codec_i2c.h
  group component/i2c
    ../../../../../../components/i2c/: i2c.h lpi2c_adapter.c
  group component/uart
    ../../../../../../components/uart/: lpuart_adapter.c uart.h
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group device
    ../../../../../../devices/MIMXRT1062/: MIMXRT1062.h MIMXRT1062_features.h fsl_device_registers.h system_MIMXRT1062.c system_MIMXRT1062.h
  group utilities
    ../../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c
  group startup
    ../../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group xip
    ../../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
