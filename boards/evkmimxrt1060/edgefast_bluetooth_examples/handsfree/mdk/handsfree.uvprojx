# Keil uVision project handsfree.uvprojx, settings and files
target handsfree flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: handsfree.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1062DVL6A, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, APPL_USE_STANDARD_IO, GATT_CLIENT, GATT_DB, FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0, SDK_COMPONENT_INTEGRATION=1, gNvStorageIncluded_d=1, gNvTableKeptInRam_d=1, IOT_WIFI_ENABLE_SAVE_NETWORK=1, FSL_OSA_MAIN_FUNC_ENABLE=0, HAL_UART_ADAPTER_FIFO=1, FSL_FEATURE_FLASH_PAGE_SIZE_BYTES=4096, gMemManagerLight=0, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, SDK_OS_FREE_RTOS, FSL_OSA_TASK_ENABLE=1, SDIO_ENABLED=1, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, MBEDTLS_CONFIG_FILE='\"mbedtls_config_client.h\"', SDK_DEBUGCONSOLE_UART=1, CONFIG_BT_BREDR=1, CONFIG_BT_PERIPHERAL=1, CONFIG_BT_CENTRAL=1, CONFIG_BT_SMP=1, CONFIG_BT_DEVICE_NAME='\"edgefast hfp\"', OSA_USED=1, SHELL_USE_COMMON_TASK=0, SHELL_TASK_STACK_SIZE=2048, SHELL_TASK_PRIORITY=configMAX_PRIORITIES-2, NVM_NO_COMPONNET=1, CPU_MIMXRT1062DVL6A_cm7, HAL_UART_DMA_ENABLE=1, HAL_AUDIO_DMA_INIT_ENABLE=0, LFS_NO_INTRINSICS=1, LFS_NO_ERROR=1, SERIAL_PORT_TYPE_UART=1, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8960_ENABLE, DEBUG_CONSOLE_RX_ENABLE=0, LOG_ENABLE_ASYNC_MODE=1, LOG_MAX_ARGUMENT_COUNT=10, LOG_ENABLE_OVERWRITE=0, CONFIG_ARM=1, MFLASH_FILE_BASEADDR=7340032, MCUXPRESSO_SDK
  c misc: -include ../app_config.h -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../middleware/wifi/wifi_bt_firmware;../../../../../middleware/edgefast_bluetooth/edgefast/bluetooth/pal/bt_ble/configs;../../../../../devices/MIMXRT1062/drivers;../../../../../devices/MIMXRT1062;../../../../../components/uart;../../../../../devices/MIMXRT1062/utilities/str;../../../../../devices/MIMXRT1062/utilities/debug_console;../../../../../devices/MIMXRT1062/xip;../../../xip;../../../../../components/serial_manager;../../../../../components/lists;../../../../../middleware/sdmmc/sdio;../../../../../middleware/sdmmc/common;../../../../../middleware/sdmmc/host/usdhc;../../../../../middleware/usb/host;../../../../../middleware/usb/host/class;../../../../../middleware/usb/include;../../../../../components/osa;../../../../../middleware/usb/phy;../../../../../middleware/fatfs/source;../../../../../middleware/fatfs/source/fsl_usb_disk;../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/controller;../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/controller/configs;../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/platform;../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/platform/configs;../../../../../middleware/edgefast_bluetooth/source/impl/ethermind;../../../../../middleware/wireless/framework/SecLib;../../../../../components/mem_manager;../../../../../components/messaging;../../../../../components/rng;../../../../../components/codec/wm8960;../../../../../components/codec;../../../../../components/codec/port/wm8960;../../../../../components/codec/port;../../../../../components/codec/i2c;../../../../../components/i2c;../../../../../components/audio;../../../../../devices/MIMXRT1062/utilities;../../../../../rtos/freertos/freertos_kernel/include;../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM4F;../../../../../middleware/wireless/ethermind/bluetooth/export/eOSAL;../../../../../middleware/wireless/ethermind/bluetooth/export/include;../../../../../middleware/wireless/ethermind/bluetooth/export/vendor;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/att;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avctp;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avdtp;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/bnep;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/common;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/dbase;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/hci_1.2;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/mcap;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/obex;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/rfcomm;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sdp;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sm;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/smp;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/write_task;../../../../../middleware/wireless/ethermind/bluetooth/private/utils/aes_cmac;../../../../../middleware/wireless/ethermind/bluetooth/private/utils/at_parser;../../../../../middleware/wireless/ethermind/bluetooth/private/utils/btsnoop;../../../../../middleware/wireless/ethermind/bluetooth/private/utils/object_parser;../../../../../middleware/wireless/ethermind/bluetooth/private/utils/racp;../../../../../middleware/wireless/ethermind/bluetooth/private/utils/security;../../../../../middleware/wireless/ethermind/bluetooth/private/utils/status;../../../../../middleware/wireless/ethermind/bluetooth/private/utils/storage;../../../../../middleware/wireless/ethermind/bluetooth/private/utils/xml_parser;../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth;../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth/controller;../../../../../middleware/wireless/ethermind/port/pal/mcux/ethal;../../../../../middleware/wireless/ethermind/port/pal/mcux/sbc;../../../../../middleware/wireless/ethermind/port/osal/src/freertos;../../../../../middleware/wireless/ethermind/port/pal/mcux;../../../../../middleware/wireless/ethermind/bluetooth/private/utils/sbc;../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/config;../../../../../middleware/wireless/ethermind/bluetooth/export/extension;../../../../../middleware/wifi/incl;../../../../../middleware/wifi/incl/port/os;../../../../../middleware/wifi/incl/wifidriver;../../../../../middleware/wifi/incl/wlcmgr;../../../../../middleware/wifi/wifidriver;../../../../../middleware/wifi/wifidriver/incl;../../../../../middleware/edgefast_bluetooth/source;../../../../../middleware/edgefast_bluetooth/include;../../../../../middleware/edgefast_bluetooth/bluetooth;../../../../../middleware/edgefast_bluetooth/source/porting;../../../../../middleware/edgefast_bluetooth/source/services;../../../../../components/common_task;../../../../../components/internal_flash;../../../../../middleware/wireless/framework/FunctionLib;../../../../../middleware/wireless/framework/Common;../../../../../middleware/littlefs;../../../../../components/flash/mflash;../../../../../components/flash/mflash/mimxrt1062;../../../../../CMSIS/Core/Include;../../../../../middleware/sdmmc/osa;../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits;../../../../../components/wifi_bt_module/Murata/tx_pwr_limits;../../../../../components/log
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../../../../middleware/edgefast_bluetooth/edgefast/bluetooth/pal/bt_ble/configs
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: ../../../../../middleware/wireless/framework/SecLib/lib_crypto_m7.a ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/mdk/libethermind_bt_a2dp.lib ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/mdk/libethermind_bt_avrcp.lib ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/mdk/libethermind_bt_bip.lib ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/mdk/libethermind_bt_bpp.lib ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/mdk/libethermind_bt_core.lib ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/mdk/libethermind_bt_ctn.lib ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/mdk/libethermind_bt_ftp.lib ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/mdk/libethermind_bt_gatt.lib ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/mdk/libethermind_bt_hfp.lib ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/mdk/libethermind_bt_hid.lib ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/mdk/libethermind_bt_map.lib ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/mdk/libethermind_bt_opp.lib ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/mdk/libethermind_bt_pan.lib ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/mdk/libethermind_bt_pbap.lib ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/mdk/libethermind_bt_protocol.lib ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/mdk/libethermind_bt_sap.lib ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/mdk/libethermind_bt_spp.lib ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/mdk/libethermind_bt_util.lib ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/mdk/libethermind_sbc_common.lib ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/mdk/libethermind_sbc_decoder.lib ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm7f/mdk/libethermind_sbc_encoder.lib --remove --keep=*(._bt_*) --keep=*(._net_buf_pool*) --keep=*(._settings_handler_static*) --keep=mflash_drv.o(*) --entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group source
    ../: FreeRTOSConfig.h app_config.h main.c app_handsfree.c app_handsfree.h app_shell.c app_shell.h sco_audio_pl_ext.c ringtone.h edgefast_bluetooth_config.h bt_module_config.h
  group wifi/wifi_bt_firmware
    ../../../../../middleware/wifi/wifi_bt_firmware/: sduartIW416_wlan_bt.h sd8801_wlan.h sduart8977_wlan_bt.h sduartIW416_wlan_bt.h sduart8987_wlan_bt.h wlan_bt_fw.h
  group board
    ../: sdmmc_config.c sdmmc_config.h wifi_bt_config.c wifi_bt_config.h board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h dcd.c dcd.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_iomuxc.h fsl_trng.c fsl_trng.h fsl_dcp.c fsl_dcp.h fsl_cache.c fsl_cache.h fsl_flexspi.c fsl_flexspi.h fsl_lpi2c.c fsl_lpi2c.h fsl_sai.h fsl_sai.c fsl_sai_edma.h fsl_sai_edma.c fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_lpuart_edma.h fsl_lpuart_edma.c fsl_usdhc.c fsl_usdhc.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group startup
    ../../../../../devices/MIMXRT1062/arm/: startup_MIMXRT1062.S
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c fsl_shell.c fsl_shell.h
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group sdmmc/src
    ../../../../../middleware/sdmmc/sdio/: fsl_sdio.c
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc/sdio/: fsl_sdio.h
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sdio
    ../../../../../middleware/sdmmc/sdio/: ChangeLogKSDK.txt
  group sdmmc/host
    ../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt
    ../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group usb/host
    ../../../../../middleware/usb/host/: usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c usb_host_ehci.c usb_host_ehci.h usb_host.h usb_host_hci.h usb_host_devices.h usb_host_framework.h
  group usb/host/class
    ../../../../../middleware/usb/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_msd.c usb_host_msd.h usb_host_msd_ufi.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c
  group usb/phy
    ../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group fatfs/source
    ../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_usb_disk
    ../../../../../middleware/fatfs/source/fsl_usb_disk/: fsl_usb_disk.h fsl_usb_disk_freertos.c
  group edgefast/bluetooth/controller/configs
    ../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/controller/configs/: lwipopts.h lwippools.h wifi_config.h
  group bt_ble/port/pal/mcux/edgefast_support
    ../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/platform/: bt_ble_platform.c bt_ble_platform.h bt_ble_settings.c bt_ble_settings.h host_msd_fatfs.c host_msd_fatfs.h
    ../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/: bt_db_gen.c
  group bt_ble/port/pal/mcux/edgefast_support/configs
    ../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/platform/configs/: ffconf.h usb_host_config.h
  group framework/SecLib
    ../../../../../middleware/wireless/framework/SecLib/: SecLib.h CryptoLibSW.h SecLib.c
  group component/mem_manager
    ../../../../../components/mem_manager/: fsl_component_mem_manager.h fsl_component_mem_manager.c
  group component/messaging
    ../../../../../components/messaging/: fsl_component_messaging.h fsl_component_messaging.c
  group component/rng
    ../../../../../components/rng/: fsl_adapter_rng.h fsl_adapter_software_rng.c
  group codec
    ../../../../../components/codec/wm8960/: fsl_wm8960.h fsl_wm8960.c
    ../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
  group codec/port/wm8960
    ../../../../../components/codec/port/wm8960/: fsl_codec_wm8960_adapter.c fsl_codec_wm8960_adapter.h
  group codec/port
    ../../../../../components/codec/port/: fsl_codec_adapter.h
  group component/i2c
    ../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group component/audio
    ../../../../../components/audio/: fsl_adapter_audio.h fsl_adapter_sai.c
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    ../../../../../rtos/freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos_kernel/portable/GCC/ARM_CM4F
    ../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos/freertos_kernel/portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group bt_ble/bluetooth/export/eOSAL
    ../../../../../middleware/wireless/ethermind/bluetooth/export/eOSAL/: eBT_assert.h eBT_config.h eBT_debug_api.h eBT_fops.h eBT_os.h eBT_serial.h eBT_timer.h
  group bt_ble/bluetooth/export/include
    ../../../../../middleware/wireless/ethermind/bluetooth/export/include/: BT_a2dp_api.h BT_api.h BT_assigned_numbers.h BT_at_parser_api.h BT_att_api.h BT_avctp_api.h BT_avdtp_api.h BT_avrcp_api.h BT_avrcp_ca_api.h BT_bip_api.h BT_bnep_api.h BT_bottom_half.h BT_bpp_api.h BT_common.h BT_ctn_api.h BT_dbase_api.h BT_device_queue.h BT_error.h BT_ftp_api.h BT_gap_api.h BT_gatt_db_api.h BT_hci_api.h BT_hdp_api.h BT_hfp_ag_api.h BT_hfp_unit_api.h BT_hid_device_api.h BT_hid_host_api.h BT_irobex_api.h BT_jpl_api.h BT_map_api.h BT_mcap_api.h BT_obex_api.h BT_opp_api.h BT_pan_api.h BT_pbap_api.h BT_racp.h BT_rfcomm_api.h BT_sap_api.h BT_sdp_api.h BT_security.h BT_sm_api.h BT_smp_api.h BT_snoop.h BT_spp_api.h BT_status.h BT_storage.h BT_version.h fsm_defines.h fsm_engine.h gatt_defines.h hci_transport.h l2cap.h write_task.h
  group bt_ble/bluetooth/export/vendor
    ../../../../../middleware/wireless/ethermind/bluetooth/export/vendor/: vendor_specific_commands.h vendor_specific_init.c vendor_specific_init.h
  group bt_ble/bluetooth/private/protocols/att
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/att/: att.h
  group bt_ble/bluetooth/private/protocols/avctp
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avctp/: avctp.h
  group bt_ble/bluetooth/private/protocols/avdtp
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avdtp/: avdtp.h
  group bt_ble/bluetooth/private/protocols/bnep
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/bnep/: bnep.h
  group bt_ble/bluetooth/private/protocols/dbase
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/dbase/: database.h
  group bt_ble/bluetooth/private/protocols/hci_1.2
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/hci_1.2/: hci_h.h
  group bt_ble/bluetooth/private/protocols/mcap
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/mcap/: mcap.h
  group bt_ble/bluetooth/private/protocols/obex
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/obex/: obex.h
  group bt_ble/bluetooth/private/protocols/rfcomm
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/rfcomm/: rfcomm.h
  group bt_ble/bluetooth/private/protocols/sdp
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sdp/: sdp.h
  group bt_ble/bluetooth/private/protocols/sm
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sm/: sm.h sm_extern.h sm_internal.h
  group bt_ble/bluetooth/private/protocols/smp
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/smp/: smp.h smp_extern.h smp_fsm.h smp_fsm_engine.h smp_internal.h
  group bt_ble/bluetooth/private/utils/aes_cmac
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/aes_cmac/: aes_cmac.h
  group bt_ble/bluetooth/private/utils/at_parser
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/at_parser/: at_parser_hsp_hfp.h
  group bt_ble/bluetooth/private/utils/object_parser
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/object_parser/: object_parser_api.h tokenizer.h
  group bt_ble/bluetooth/private/utils/racp
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/racp/: racp.h
  group bt_ble/bluetooth/private/utils/storage
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/storage/: storage.h
  group bt_ble/bluetooth/private/utils/xml_parser
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/xml_parser/: xml_common_defines.h xml_encoder.h xml_parser.h
  group bt_ble/port/osal/src/freertos
    ../../../../../middleware/wireless/ethermind/port/osal/src/freertos/: EM_assert.h EM_config.c EM_config.h EM_debug.c EM_debug.h EM_debug_api.h EM_debug_internal.h EM_fops.c EM_fops.h EM_os.c EM_os.h EM_serial.c EM_serial.h EM_timer.c EM_timer.h EM_timer_internal.h
  group bt_ble/port/pal/mcux/bluetooth
    ../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth/: BT_assert.h BT_config.h BT_debug.h BT_debug_api.h BT_fops.h BT_os.h BT_status_pl.c BT_storage_pl.c BT_storage_pl.h BT_timer.h btsnoop_pl.c btsnoop_pl.h sco_audio_pl.c sco_audio_pl.h ctn_pl.c ctn_pl.h ftp_pl.c ftp_pl.h hci_uart.c hci_uart.h hci_uart_internal.h ht_read_task_pl.c map_pl.c map_pl.h obex_pl.c obex_pl.h pbap_pl.c pbap_pl.h write_task_extern_pl.h write_task_pl.c write_task_pl.h littlefs_pl.c littlefs_pl.h controller.c controller.h
    ../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth/controller/: controller_wifi_nxp.c controller_wifi_nxp.h
  group bt_ble/port/pal/mcux/ethal
    ../../../../../middleware/wireless/ethermind/port/pal/mcux/ethal/: ethal_assert.h ethal_config.c ethal_config.h ethal_debug.c ethal_debug.h ethal_debug_api.h ethal_debug_internal.h ethal_fops.c ethal_fops.h ethal_os.c ethal_os.h ethal_serial.c ethal_serial.h ethal_timer.c ethal_timer.h ethal_timer_internal.h
  group bt_ble/port/pal/mcux/sbc
    ../../../../../middleware/wireless/ethermind/port/pal/mcux/sbc/: sbc_os.h
  group bt_ble/port/pal/mcux
    ../../../../../middleware/wireless/ethermind/port/pal/mcux/: EM_platform.c EM_platform.h
  group bt_ble/bluetooth/private/utils/sbc
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/sbc/: sbc_api.h
  group bt_ble/bluetooth/private/lib/config
    ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/config/: BT_features.h BT_limits.h db_gen.h
  group bt_ble/bluetooth/export/extension
    ../../../../../middleware/wireless/ethermind/bluetooth/export/extension/: aes_cmac_pl.c aes_cmac_pl.h BT_common_pl.c BT_common_pl.h device_queue_pl.c device_queue_pl.h sm_pl.c sm_pl.h sm_ssp_pl.c sm_ssp_pl.h smp_pl.c smp_pl.h gatt_db_pl.c gatt_db_pl.h
  group wifi/incl/port/os
    ../../../../../middleware/wifi/incl/port/os/: wm_os.h
  group wifi/incl
    ../../../../../middleware/wifi/incl/: WIFI_IW416_BOARD_AW_AM457_CAL_DATA_EXT.h wm_utils.h wmerrno.h wmlog.h wmtypes.h
  group wifi/wifidriver/incl
    ../../../../../middleware/wifi/wifidriver/incl/: mlan_11ac.h mlan_11h.h mlan_11n.h mlan_11n_aggr.h mlan_11n_rxreorder.h mlan_fw.h mlan_ieee.h mlan_init.h mlan_join.h mlan_main.h mlan_meas.h mlan_remap_mem_operations.h mlan_sdio.h mlan_uap.h mlan_util.h mlan_wmm.h mlan.h mlan_ioctl.h mlan_decl.h mlan_api.h
  group wifi/incl/wlcmgr
    ../../../../../middleware/wifi/incl/wlcmgr/: wlan_11d.h wlan.h
  group wifi/incl/wifidriver
    ../../../../../middleware/wifi/incl/wifidriver/: mlan_sdio_api.h wifi-decl.h wifi.h wifi_events.h
  group wifi/port/os
    ../../../../../middleware/wifi/port/os/: os.c
  group wifi/wifidriver
    ../../../../../middleware/wifi/wifidriver/: wifi-debug.h wifi-internal.h wifi-sdio.h mlan_sdio.c sdio.c sdio.h firmware_dnld.c firmware_dnld.h
  group edgefast/bluetooth/source
    ../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/host/: bt_pal_a2dp.c bt_pal_a2dp_internal.h bt_pal_avrcp.c bt_pal_avrcp_al_api.h bt_pal_avrcp_al_internal.c bt_pal_avrcp_al_internal.h bt_pal_avrcp_al_api.c bt_pal_avrcp_internal.h bt_pal_att.c bt_pal_at.h bt_pal_att_internal.h bt_pal_avdtp_internal.h bt_pal_conn.c bt_pal_conn_internal.h bt_pal_crypto.c bt_pal_crypto_internal.h bt_pal_gatt.c bt_pal_gatt_internal.h bt_pal_hci_core.c bt_pal_hci_core.h bt_pal_adv.c bt_pal_adv.h bt_pal_br.c bt_pal_br.h bt_pal_id.c bt_pal_id.h bt_pal_scan.c bt_pal_scan.h bt_pal_ecc.c bt_pal_ecc.h bt_pal_addr.c bt_pal_buf.c bt_pal_direction.c bt_pal_direction_internal.h bt_pal_hci_ecc.h bt_pal_keys.c bt_pal_keys.h bt_pal_keys_br.c bt_pal_l2cap.c bt_pal_l2cap_br.c bt_pal_l2cap_internal.h bt_pal_monitor.c bt_pal_monitor.h bt_pal_rfcomm.c bt_pal_rfcomm_internal.h bt_pal_spp.c bt_pal_rpa.c bt_pal_rpa.h bt_pal_settings.h bt_pal_settings.c bt_pal_sdp.c bt_pal_sdp_internal.h bt_pal_smp.c bt_pal_smp.h bt_pal_ssp.c bt_pal_ssp.h bt_pal_uuid.c bt_pal_hfp_ag.c bt_pal_hfp_hf.c bt_pal_hfp_internal.h
  group edgefast/bluetooth/source/a2dp_codec/sbc
    ../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/host/a2dp_codec/sbc/: a2dp_codec_sbc.c
  group edgefast/bluetooth/include/bluetooth
    ../../../../../middleware/edgefast_bluetooth/include/bluetooth/: a2dp.h avrcp.h a2dp_codec_sbc.h addr.h att.h avdtp.h bluetooth.h direction.h buf.h l2cap.h rfcomm.h spp.h sdp.h conn.h crypto.h gap.h gatt.h hci.h hci_err.h hci_raw.h hci_vs.h hfp_hf.h hfp_ag.h iso.h testing.h uuid.h
  group edgefast/bluetooth/include/sys
    ../../../../../middleware/edgefast_bluetooth/include/sys/: util.h printk.h byteorder.h work_queue.h slist.h atomic.h
  group edgefast/bluetooth/include/zephyr
    ../../../../../middleware/edgefast_bluetooth/include/zephyr/: types.h
  group edgefast/bluetooth/porting
    ../../../../../middleware/edgefast_bluetooth/source/porting/: porting.c porting.h work_queue.c buf.c slist.c atomic_c.c
  group edgefast/bluetooth/porting/errno
    ../../../../../middleware/edgefast_bluetooth/source/porting/errno/: errno.h
  group edgefast/bluetooth/include/toolchain
    ../../../../../middleware/edgefast_bluetooth/include/toolchain/: common.h gcc.h iar.h armcc.h
  group edgefast/bluetooth/include
    ../../../../../middleware/edgefast_bluetooth/include/: toolchain.h
  group edgefast/bluetooth/include/net
    ../../../../../middleware/edgefast_bluetooth/include/net/: buf.h
  group edgefast/bluetooth/source/services
    ../../../../../middleware/edgefast_bluetooth/source/services/: bas.c hrs.c
  group edgefast/bluetooth/include/bluetooth/services
    ../../../../../middleware/edgefast_bluetooth/include/bluetooth/services/: bas.h hrs.h
  group component/common_task
    ../../../../../components/common_task/: fsl_component_common_task.h fsl_component_common_task.c
  group component/internal_flash
    ../../../../../components/internal_flash/: fsl_adapter_flash.h fsl_adapter_flexspi_nor_flash.c
  group framework/FunctionLib
    ../../../../../middleware/wireless/framework/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/Common
    ../../../../../middleware/wireless/framework/Common/: EmbeddedTypes.h
  group littlefs
    ../../../../../middleware/littlefs/: lfs.c lfs_util.c lfs.h lfs_util.h
  group flash/mflash
    ../../../../../components/flash/mflash/: mflash_file.h mflash_file.c mflash_common.h
  group flash/mflash/mimxrt1062
    ../../../../../components/flash/mflash/mimxrt1062/: mflash_drv.h mflash_drv.c
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group sdmmc/osa
    ../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group usb/include
    ../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group component/wifi_bt_module/AzureWave/tx_pwr_limits
    ../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits/: wlan_txpwrlimit_cfg_WW.h
  group component/wifi_bt_module/Murata/tx_pwr_limits
    ../../../../../components/wifi_bt_module/Murata/tx_pwr_limits/: wlan_txpwrlimit_cfg_murata_1XK_CA.h wlan_txpwrlimit_cfg_murata_1XK_EU.h wlan_txpwrlimit_cfg_murata_1XK_JP.h wlan_txpwrlimit_cfg_murata_1XK_US.h wlan_txpwrlimit_cfg_murata_1XK_WW.h wlan_txpwrlimit_cfg_murata_1ZM_CA.h wlan_txpwrlimit_cfg_murata_1ZM_EU.h wlan_txpwrlimit_cfg_murata_1ZM_JP.h wlan_txpwrlimit_cfg_murata_1ZM_US.h wlan_txpwrlimit_cfg_murata_1ZM_WW.h wlan_txpwrlimit_cfg_murata_2DS_CA.h wlan_txpwrlimit_cfg_murata_2DS_EU.h wlan_txpwrlimit_cfg_murata_2DS_JP.h wlan_txpwrlimit_cfg_murata_2DS_US.h wlan_txpwrlimit_cfg_murata_2DS_WW.h
  group component/log
    ../../../../../components/log/: fsl_component_log_backend_debugconsole.c fsl_component_log_backend_debugconsole.h fsl_component_log.h fsl_component_log_config.h fsl_component_log.c
target handsfree flexspi_nor_release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: handsfree.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1062DVL6A, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, APPL_USE_STANDARD_IO, GATT_CLIENT, GATT_DB, FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0, SDK_COMPONENT_INTEGRATION=1, gNvStorageIncluded_d=1, gNvTableKeptInRam_d=1, IOT_WIFI_ENABLE_SAVE_NETWORK=1, FSL_OSA_MAIN_FUNC_ENABLE=0, HAL_UART_ADAPTER_FIFO=1, FSL_FEATURE_FLASH_PAGE_SIZE_BYTES=4096, gMemManagerLight=0, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, SDK_OS_FREE_RTOS, FSL_OSA_TASK_ENABLE=1, SDIO_ENABLED=1, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, MBEDTLS_CONFIG_FILE='\"mbedtls_config_client.h\"', SDK_DEBUGCONSOLE_UART=1, CONFIG_BT_BREDR=1, CONFIG_BT_PERIPHERAL=1, CONFIG_BT_CENTRAL=1, CONFIG_BT_SMP=1, CONFIG_BT_DEVICE_NAME='\"edgefast hfp\"', OSA_USED=1, SHELL_USE_COMMON_TASK=0, SHELL_TASK_STACK_SIZE=2048, SHELL_TASK_PRIORITY=configMAX_PRIORITIES-2, NVM_NO_COMPONNET=1, CPU_MIMXRT1062DVL6A_cm7, HAL_UART_DMA_ENABLE=1, HAL_AUDIO_DMA_INIT_ENABLE=0, LFS_NO_INTRINSICS=1, LFS_NO_ERROR=1, SERIAL_PORT_TYPE_UART=1, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8960_ENABLE, DEBUG_CONSOLE_RX_ENABLE=0, LOG_ENABLE_ASYNC_MODE=1, LOG_MAX_ARGUMENT_COUNT=10, LOG_ENABLE_OVERWRITE=0, CONFIG_ARM=1, MFLASH_FILE_BASEADDR=7340032, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: as above
