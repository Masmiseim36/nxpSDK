# IAR project wifi_provisioning.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; FILE=void; CPU_MIMXRT1062DVL6A; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; APPL_USE_STANDARD_IO; GATT_CLIENT; GATT_DB; FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0; SDK_COMPONENT_INTEGRATION=1; gNvStorageIncluded_d=1; gNvTableKeptInRam_d=1; IOT_WIFI_ENABLE_SAVE_NETWORK=1; FSL_OSA_MAIN_FUNC_ENABLE=0; HAL_UART_ADAPTER_FIFO=1; WIFI_BOARD_AW_AM457; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; FSL_RTOS_FREE_RTOS; FSL_OSA_TASK_ENABLE=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; CONFIG_SHADOW_DEMO_ENABLED; MBEDTLS_CONFIG_FILE="aws_mbedtls_config.h"; IOT_MQTT_ENABLE_SERIALIZER_OVERRIDES=1; SDK_DEBUGCONSOLE_UART=1; CONTROLLER_INIT_ESCAPE=1; NVM_NO_COMPONNET=1; SDIO_ENABLED=1; CPU_MIMXRT1062DVL6A_cm7; SERIAL_PORT_TYPE_UART=1; MFLASH_FILE_BASEADDR=5767168
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.IExtraOptions: --diag_suppress Pa082,Pa050
  ICCARM.PreInclude: ../wifi_config.h
  ICCARM.CCIncludePath2: ../../../../../middleware/wifi/wifi_bt_firmware; ../../..; ../config_files; ..; ../aws_iot_wifi_acs_porting_layer; ../aws_iot_bt_acs_porting_layer; ../aws_iot_bt_acs_porting_layer/ble; ../aws_iot_bt_acs_porting_layer/ble/profile_appl; ../aws_iot_bt_acs_porting_layer/ble/protocol_appl; ../aws_iot_bt_acs_porting_layer/br/protocol_appl; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062; ../../../../../components/uart; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../devices/MIMXRT1062/utilities/debug_console; ../../../../../devices/MIMXRT1062/xip; ../../../xip; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../middleware/sdmmc/sdio; ../../../../../middleware/sdmmc/common; ../../../../../middleware/sdmmc/host/usdhc; ../../../../../middleware/usb/host; ../../../../../middleware/usb/host/class; ../../../../../middleware/usb/include; ../../../../../components/osa; ../../../../../middleware/usb/phy; ../../../../../middleware/fatfs/source; ../../../../../middleware/fatfs/source/fsl_usb_disk; ../../../../../rtos/freertos/freertos_kernel/include; ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F; ../../../../../middleware/wireless/ethermind/bluetooth/export/eOSAL; ../../../../../middleware/wireless/ethermind/bluetooth/export/include; ../../../../../middleware/wireless/ethermind/bluetooth/export/vendor; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/att; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avctp; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avdtp; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/bnep; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/common; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/dbase; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/hci_1.2; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/mcap; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/obex; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/rfcomm; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sdp; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sm; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/smp; ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/write_task; ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/aes_cmac; ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/at_parser; ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/btsnoop; ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/object_parser; ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/racp; ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/security; ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/status; ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/storage; ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/xml_parser; ../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth; ../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth/controller; ../../../../../middleware/wireless/ethermind/port/pal/mcux/ethal; ../../../../../middleware/wireless/ethermind/port/pal/mcux/sbc; ../../../../../middleware/wireless/ethermind/port/osal/src/freertos; ../../../../../middleware/wireless/ethermind/port/pal/mcux; ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/sbc; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/config; ../../../../../middleware/wireless/ethermind/bluetooth/export/extension; ../../../../../rtos/freertos/demos/include; ../../../../../rtos/freertos/demos/dev_mode_key_provisioning/include; ../../../../../rtos/freertos/libraries/abstractions/wifi/include; ../../../../../middleware/lwip/port; ../../../../../middleware/lwip/src; ../../../../../middleware/lwip/src/include; ../../../../../middleware/wifi/dhcpd; ../../../../../middleware/wifi/incl/port/lwip; ../../../../../middleware/wifi/port/lwip; ../../../../../rtos/freertos/libraries/abstractions/platform/freertos/include/platform; ../../../../../rtos/freertos/libraries/abstractions/platform/include/platform; ../../../../../rtos/freertos/libraries/abstractions/platform/include/types; ../../../../../rtos/freertos/libraries/abstractions/platform/freertos/include; ../../../../../rtos/freertos/libraries/abstractions/platform/include; ../../../../../rtos/freertos/libraries/abstractions/secure_sockets/include; ../../../../../rtos/freertos/libraries/freertos_plus/standard/crypto/include; ../../../../../rtos/freertos/libraries/freertos_plus/standard/pkcs11/include; ../../../../../rtos/freertos/libraries/freertos_plus/standard/utils/include; ../../../../../rtos/freertos/libraries/freertos_plus/standard/tls/include; ../../../../../rtos/freertos/libraries/abstractions/pkcs11/include; ../../../../../rtos/freertos/libraries/3rdparty/pkcs11; ../../../../../rtos/freertos/libraries/3rdparty/jsmn; ../../../../../components/flash/mflash; ../../../../../components/flash/mflash/mimxrt1062; ../../../../../middleware/mbedtls/include; ../../../../../middleware/mbedtls/library; ../../../../../middleware/mbedtls/port/ksdk; ../../../../../rtos/freertos/libraries/c_sdk/standard/ble/include; ../../../../../rtos/freertos/libraries/c_sdk/standard/ble/src; ../../../../../rtos/freertos/libraries/abstractions/ble_hal/include; ../../../../../rtos/freertos/libraries/3rdparty/tinycbor/src; ../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/include; ../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/include/types; ../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/src; ../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/src/private; ../../../../../rtos/freertos/libraries/c_sdk/standard/serializer/include; ../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/include; ../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/include/types; ../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/src/private; ../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/src; ../../../../../components/internal_flash; ../../../../../middleware/wireless/framework/FunctionLib; ../../../../../middleware/wireless/framework/NVM/Interface; ../../../../../middleware/wireless/framework/NVM/Source; ../../../../../middleware/wireless/framework/Common; ../../../../../components/nvm; ../../../../../CMSIS/Include; ../../../../../middleware/sdmmc/osa; ../../../../../rtos/freertos/libraries/c_sdk/standard/common/include; ../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/private; ../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/types; ../../../../../rtos/freertos/libraries/3rdparty/mbedtls_utils; ../../../../../rtos/freertos/libraries/abstractions/pkcs11/mbedtls; ../../../../../rtos/freertos/demos/network_manager; ../../../../../middleware/wifi/incl; ../../../../../middleware/wifi/incl/port/os; ../../../../../middleware/wifi/incl/wifidriver; ../../../../../middleware/wifi/incl/wlcmgr; ../../../../../middleware/wifi/wifidriver; ../../../../../middleware/wifi/wifidriver/incl
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ../config_files; ..
  ILINK.IlinkOutputFile: wifi_provisioning.out
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/cm7f/iar/libethermind_bt_core.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/cm7f/iar/libethermind_bt_util.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/cm7f/iar/libethermind_bt_protocol.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/cm7f/iar/libethermind_bt_a2dp.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/cm7f/iar/libethermind_sbc_common.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/cm7f/iar/libethermind_sbc_encoder.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/cm7f/iar/libethermind_sbc_decoder.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/cm7f/iar/libethermind_bt_gatt.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/cm7f/iar/libethermind_bt_bpp.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/cm7f/iar/libethermind_bt_bip.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/cm7f/iar/libethermind_bt_avrcp.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/cm7f/iar/libethermind_bt_ftp.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/cm7f/iar/libethermind_bt_hid.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/cm7f/iar/libethermind_bt_ctn.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/cm7f/iar/libethermind_bt_pbap.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/cm7f/iar/libethermind_bt_sap.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/cm7f/iar/libethermind_bt_spp.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/cm7f/iar/libethermind_bt_map.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/cm7f/iar/libethermind_bt_opp.a; ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/cm7f/iar/libethermind_bt_hfp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; FILE=void; CPU_MIMXRT1062DVL6A; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; APPL_USE_STANDARD_IO; GATT_CLIENT; GATT_DB; FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0; SDK_COMPONENT_INTEGRATION=1; gNvStorageIncluded_d=1; gNvTableKeptInRam_d=1; IOT_WIFI_ENABLE_SAVE_NETWORK=1; FSL_OSA_MAIN_FUNC_ENABLE=0; HAL_UART_ADAPTER_FIFO=1; WIFI_BOARD_AW_AM457; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; FSL_RTOS_FREE_RTOS; FSL_OSA_TASK_ENABLE=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; CONFIG_SHADOW_DEMO_ENABLED; MBEDTLS_CONFIG_FILE="aws_mbedtls_config.h"; IOT_MQTT_ENABLE_SERIALIZER_OVERRIDES=1; SDK_DEBUGCONSOLE_UART=1; CONTROLLER_INIT_ESCAPE=1; NVM_NO_COMPONNET=1; SDIO_ENABLED=1; CPU_MIMXRT1062DVL6A_cm7; SERIAL_PORT_TYPE_UART=1; MFLASH_FILE_BASEADDR=5767168
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group wifi/wifi_bt_firmware
    ../../../../../middleware/wifi/wifi_bt_firmware/: sduart8978_wlan_bt.h sd8801_wlan.h sduart8977_wlan_bt.h sduart8978_wlan_bt.h
  group wifi/dhcpd
    ../../../../../middleware/wifi/dhcpd/: dhcp-bootp.h dhcp-priv.h dhcp-server-main.c dhcp-server.c dns-server.c dns.h
  group wifi/incl
    ../../../../../middleware/wifi/incl/: dhcp-server.h wm_utils.h wmerrno.h wmlog.h wmtypes.h
  group wifi/incl/port/lwip
    ../../../../../middleware/wifi/incl/port/lwip/: wm_net.h
  group wifi/incl/port/os
    ../../../../../middleware/wifi/incl/port/os/: wm_os.h
  group wifi/incl/wifidriver
    ../../../../../middleware/wifi/incl/wifidriver/: mlan_sdio_api.h wifi-decl.h wifi.h wifi_events.h
  group wifi/incl/wlcmgr
    ../../../../../middleware/wifi/incl/wlcmgr/: wlan.h wlan_11d.h
  group wifi/port/lwip
    ../../../../../middleware/wifi/port/lwip/: net.c netif_decl.h wifi_netif.c
  group wifi/port/os
    ../../../../../middleware/wifi/port/os/: os.c
  group wifi/wlcmgr
    ../../../../../middleware/wifi/wlcmgr/: wlan.c wlan_txpwrlimit_cfg.c
  group wifi/wifidriver
    ../../../../../middleware/wifi/wifidriver/: mlan_11ac.c mlan_11d.c mlan_11h.c mlan_11n.c mlan_11n_aggr.c mlan_11n_rxreorder.c mlan_api.c mlan_cfp.c mlan_cmdevt.c mlan_glue.c mlan_init.c mlan_join.c mlan_misc.c mlan_scan.c mlan_sdio.c mlan_shim.c mlan_sta_cmd.c mlan_sta_cmdresp.c mlan_sta_event.c mlan_sta_ioctl.c mlan_sta_rx.c mlan_txrx.c mlan_uap_cmdevent.c mlan_uap_ioctl.c mlan_wmm.c wifi-debug.c wifi-debug.h wifi-internal.h wifi-mem.c wifi-sdio.c wifi-sdio.h wifi-uap.c wifi.c wifi_common.h wifi_pwrmgr.c
  group wifi/wifidriver/incl
    ../../../../../middleware/wifi/wifidriver/incl/: mlan.h mlan_11ac.h mlan_11h.h mlan_11n.h mlan_11n_aggr.h mlan_11n_rxreorder.h mlan_api.h mlan_decl.h mlan_fw.h mlan_ieee.h mlan_init.h mlan_ioctl.h mlan_join.h mlan_main.h mlan_meas.h mlan_remap_mem_operations.h mlan_sdio.h mlan_uap.h mlan_util.h mlan_wmm.h
  group board
    ../../../: sdmmc_config.c sdmmc_config.h
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h dcd.c dcd.h
  group freertos/config_files
    ../config_files/: FreeRTOSConfig.h aws_bufferpool_config.h aws_demo_config.h aws_mqtt_config.h aws_secure_sockets_config.h aws_shadow_config.h FreeRTOSIPConfig.h iot_config.h iot_mqtt_agent_config.h iot_pkcs11_config.h aws_iot_network_config.h iot_ble_config.h aws_wifi_config.h
  group freertos/freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/include
    ../../../../../rtos/freertos/freertos_kernel/include/: croutine.h StackMacros.h atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/vendors/nxp/secure_sockets/lwip
    ../../../../../rtos/freertos/vendors/nxp/secure_sockets/lwip/: iot_secure_sockets.c
  group freertos/vendors/nxp/pkcs11/common
    ../../../../../rtos/freertos/vendors/nxp/pkcs11/common/: iot_pkcs11_pal.c
  group freertos/demos
    ../../../../../rtos/freertos/demos/: CMakeLists.txt directories.txt README.md
  group freertos/demos/demo_runner
    ../../../../../rtos/freertos/demos/demo_runner/: aws_demo.c iot_demo_freertos.c iot_demo_runner.c
  group freertos/demos/include
    ../../../../../rtos/freertos/demos/include/: aws_clientcredential.h aws_clientcredential_keys.h aws_demo.h aws_iot_demo_network.h aws_ota_codesigner_certificate.h iot_config_common.h iot_demo_logging.h iot_demo_runner.h aws_ble_gatt_server_demo.h aws_wifi_connect_task.h iot_ble_numericComparison.h
  group freertos/demos/network_manager
    ../../../../../rtos/freertos/demos/network_manager/: aws_iot_demo_network.c aws_iot_network_manager.c iot_network_manager_private.h
  group freertos/demos/dev_mode_key_provisioning
    ../../../../../rtos/freertos/demos/dev_mode_key_provisioning/: CMakeLists.txt README.md
  group freertos/demos/dev_mode_key_provisioning/include
    ../../../../../rtos/freertos/demos/dev_mode_key_provisioning/include/: aws_dev_mode_key_provisioning.h
  group freertos/demos/dev_mode_key_provisioning/src
    ../../../../../rtos/freertos/demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c
  group freertos/demos/ble
    ../../../../../rtos/freertos/demos/ble/: aws_ble_gatt_server_demo.c CMakeLists.txt iot_ble_numericComparison.c README.md
  group freertos/demos/greengrass_connectivity
    ../../../../../rtos/freertos/demos/greengrass_connectivity/: CMakeLists.txt README.md
  group freertos/demos/mqtt
    ../../../../../rtos/freertos/demos/mqtt/: CMakeLists.txt iot_demo_mqtt.c
  group freertos/demos/ota
    ../../../../../rtos/freertos/demos/ota/: CMakeLists.txt
  group freertos/demos/shadow
    ../../../../../rtos/freertos/demos/shadow/: CMakeLists.txt
  group freertos/demos/wifi_provisioning
    ../../../../../rtos/freertos/demos/wifi_provisioning/: aws_wifi_connect_task.c CMakeLists.txt README.md
  group freertos/libraries/abstractions/wifi/include
    ../../../../../rtos/freertos/libraries/abstractions/wifi/include/: iot_wifi.h
  group freertos/libraries/abstractions/platform/freertos
    ../../../../../rtos/freertos/libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_metrics.c iot_network_freertos.c iot_threads_freertos.c
  group freertos/libraries/abstractions/platform/freertos/include/platform
    ../../../../../rtos/freertos/libraries/abstractions/platform/freertos/include/platform/: iot_network_ble.h iot_network_freertos.h iot_platform_types_freertos.h
  group freertos/libraries/abstractions/platform/include/platform
    ../../../../../rtos/freertos/libraries/abstractions/platform/include/platform/: iot_clock.h iot_metrics.h iot_network.h iot_threads.h
  group freertos/libraries/abstractions/platform/include/types
    ../../../../../rtos/freertos/libraries/abstractions/platform/include/types/: iot_platform_types.h
  group freertos/libraries/abstractions/secure_sockets/include
    ../../../../../rtos/freertos/libraries/abstractions/secure_sockets/include/: iot_secure_sockets.h iot_secure_sockets_config_defaults.h iot_secure_sockets_wrapper_metrics.h
  group freertos/libraries/abstractions/pkcs11/include
    ../../../../../rtos/freertos/libraries/abstractions/pkcs11/include/: iot_pkcs11_pal.h
  group freertos/libraries/abstractions/pkcs11/mbedtls
    ../../../../../rtos/freertos/libraries/abstractions/pkcs11/mbedtls/: iot_pkcs11_mbedtls.c threading_alt.h
  group freertos/libraries/abstractions/ble_hal
    ../../../../../rtos/freertos/libraries/abstractions/ble_hal/: CMakeLists.txt
  group freertos/libraries/abstractions/ble_hal/include
    ../../../../../rtos/freertos/libraries/abstractions/ble_hal/include/: bt_hal_avsrc_profile.h bt_hal_gatt_client.h bt_hal_gatt_server.h bt_hal_gatt_types.h bt_hal_manager.h bt_hal_manager_adapter_ble.h bt_hal_manager_adapter_classic.h bt_hal_manager_types.h
  group freertos/libraries/freertos_plus/standard/crypto/include
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/crypto/include/: iot_crypto.h
  group freertos/libraries/freertos_plus/standard/crypto/src
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group freertos/libraries/freertos_plus/standard/pkcs11/include
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/pkcs11/include/: iot_pkcs11.h
  group freertos/libraries/freertos_plus/standard/pkcs11/src
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/pkcs11/src/: iot_pkcs11.c
  group freertos/libraries/freertos_plus/standard/utils/include
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/utils/include/: iot_pki_utils.h iot_system_init.h
  group freertos/libraries/freertos_plus/standard/utils/src
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/utils/src/: iot_pki_utils.c iot_system_init.c
  group freertos/libraries/freertos_plus/standard/tls/include
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/tls/include/: iot_tls.h
  group freertos/libraries/freertos_plus/standard/tls/src
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group freertos/libraries/3rdparty/pkcs11
    ../../../../../rtos/freertos/libraries/3rdparty/pkcs11/: pkcs11.h pkcs11f.h pkcs11t.h CONTRIBUTING.md LICENSE.md README.md
  group freertos/libraries/3rdparty/jsmn
    ../../../../../rtos/freertos/libraries/3rdparty/jsmn/: jsmn.c jsmn.h LICENSE
  group freertos/libraries/3rdparty/tinycbor/src
    ../../../../../rtos/freertos/libraries/3rdparty/tinycbor/src/: cbor.h cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborinternal_p.h cborparser.c cborparser_dup_string.c cborvalidation.c compilersupport_p.h LICENSE README.md tinycbor-version.h utf8_p.h
  group freertos/libraries/3rdparty/mbedtls_utils
    ../../../../../rtos/freertos/libraries/3rdparty/mbedtls_utils/: mbedtls_error.c mbedtls_error.h mbedtls_utils.c README.md LICENSE-2.0.txt
  group freertos/libraries/c_sdk/standard/ble
    ../../../../../rtos/freertos/libraries/c_sdk/standard/ble/: CMakeLists.txt
  group freertos/libraries/c_sdk/standard/ble/include
    ../../../../../rtos/freertos/libraries/c_sdk/standard/ble/include/: iot_ble.h iot_ble_config_defaults.h iot_ble_data_transfer.h iot_ble_device_information.h iot_ble_mqtt_serialize.h iot_ble_wifi_provisioning.h
  group freertos/libraries/c_sdk/standard/ble/src
    ../../../../../rtos/freertos/libraries/c_sdk/standard/ble/src/: iot_ble_gap.c iot_ble_gatt.c iot_ble_internal.h
  group freertos/libraries/c_sdk/standard/ble/src/services/device_information
    ../../../../../rtos/freertos/libraries/c_sdk/standard/ble/src/services/device_information/: iot_ble_device_information.c
  group freertos/libraries/c_sdk/standard/ble/src/services/mqtt_ble
    ../../../../../rtos/freertos/libraries/c_sdk/standard/ble/src/services/mqtt_ble/: iot_ble_data_transfer.c iot_network_ble.c
  group freertos/libraries/c_sdk/standard/ble/src/services/wifi_provisioning
    ../../../../../rtos/freertos/libraries/c_sdk/standard/ble/src/services/wifi_provisioning/: iot_ble_wifi_provisioning.c
  group freertos/libraries/c_sdk/standard/serializer/src
    ../../../../../rtos/freertos/libraries/c_sdk/standard/serializer/src/: iot_json_utils.c iot_serializer_static_memory.c
  group freertos/libraries/c_sdk/standard/serializer/src/cbor
    ../../../../../rtos/freertos/libraries/c_sdk/standard/serializer/src/cbor/: iot_serializer_tinycbor_decoder.c iot_serializer_tinycbor_encoder.c
  group freertos/libraries/c_sdk/standard/serializer/src/json
    ../../../../../rtos/freertos/libraries/c_sdk/standard/serializer/src/json/: iot_serializer_json_decoder.c iot_serializer_json_encoder.c
  group freertos/libraries/c_sdk/standard/serializer/include
    ../../../../../rtos/freertos/libraries/c_sdk/standard/serializer/include/: iot_json_utils.h iot_serializer.h
  group freertos/libraries/c_sdk/standard/mqtt/include
    ../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/include/: iot_mqtt.h iot_mqtt_agent.h iot_mqtt_agent_config_defaults.h iot_mqtt_config_defaults.h iot_mqtt_lib.h
  group freertos/libraries/c_sdk/standard/mqtt/include/types
    ../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/include/types/: iot_mqtt_types.h
  group freertos/libraries/c_sdk/standard/mqtt/src
    ../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/src/: iot_mqtt_agent.c iot_mqtt_api.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_serialize.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_validate.c
  group freertos/libraries/c_sdk/standard/mqtt/src/private
    ../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/src/private/: iot_mqtt_internal.h
  group freertos/libraries/c_sdk/standard/common
    ../../../../../rtos/freertos/libraries/c_sdk/standard/common/: iot_device_metrics.c iot_init.c iot_static_memory_common.c
  group freertos/libraries/c_sdk/standard/common/include
    ../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/: iot_linear_containers.h iot_appversion32.h iot_atomic.h iot_init.h iot_logging_setup.h iot_logging_task.h iot_taskpool.h
  group freertos/libraries/c_sdk/standard/common/include/private
    ../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/private/: iot_default_root_certificates.h iot_doubly_linked_list.h iot_error.h iot_lib_init.h iot_logging.h iot_static_memory.h iot_taskpool_internal.h
  group freertos/libraries/c_sdk/standard/common/include/types
    ../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/types/: iot_network_types.h iot_taskpool_types.h
  group freertos/libraries/c_sdk/standard/common/logging
    ../../../../../rtos/freertos/libraries/c_sdk/standard/common/logging/: iot_logging.c iot_logging_task_dynamic_buffers.c
  group freertos/libraries/c_sdk/standard/common/taskpool
    ../../../../../rtos/freertos/libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group freertos/libraries/c_sdk/aws/shadow/include
    ../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/include/: aws_iot_shadow.h aws_shadow.h
  group freertos/libraries/c_sdk/aws/shadow/include/types
    ../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/include/types/: aws_iot_shadow_types.h
  group freertos/libraries/c_sdk/aws/shadow/src
    ../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/src/: aws_iot_shadow_api.c aws_iot_shadow_operation.c aws_iot_shadow_parser.c aws_iot_shadow_static_memory.c aws_iot_shadow_subscription.c aws_shadow.c aws_shadow_config_defaults.h
  group freertos/libraries/c_sdk/aws/shadow/src/private
    ../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/src/private/: aws_iot_shadow_internal.h
  group source
    ../config_files/: aws_mbedtls_config.h
    ../: ffconf.h host_msd_fatfs.c host_msd_fatfs.h usb_host_config.h wifi_config.h main.c aws_iot_demo_shadow.c lwipopts.h lwippools.h db_gen.c
    ../aws_iot_wifi_acs_porting_layer/: iot_wifi.c
    ../aws_iot_bt_acs_porting_layer/: appl_utils.c appl_utils.h gatt_db_pl.c gatt_db_pl.h iot_ble_hal_common_gap.c iot_ble_hal_gap.c iot_ble_hal_gatt_server.c iot_ble_hal_internals.h
    ../aws_iot_bt_acs_porting_layer/ble/: appl_le.c appl_le.h
    ../aws_iot_bt_acs_porting_layer/ble/profile_appl/: appl_gatt_client.c appl_gatt_client.h appl_gatt_server.c appl_gatt_server.h appl_service.c appl_service.h appl_service_mops.c appl_service_mops.h gatt.c gatt.h gatt_db.c
    ../aws_iot_bt_acs_porting_layer/ble/protocol_appl/: gatt_db.h appl_att_client.c appl_att_client.h appl_gap_le.c appl_gap_le.h appl_hci_le.c appl_hci_le.h appl_hci_le_api.c appl_l2cap_le.c appl_l2cap_le.h appl_smp.c appl_smp.h
    ../aws_iot_bt_acs_porting_layer/br/protocol_appl/: appl_hci.c appl_hci.h appl_hci_api.c
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_iomuxc.h fsl_trng.c fsl_trng.h fsl_dcp.c fsl_dcp.h fsl_cache.c fsl_cache.h fsl_flexspi.c fsl_flexspi.h fsl_usdhc.c fsl_usdhc.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group startup
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c
  group component/internal_flash
    ../../../../../components/internal_flash/: fsl_adapter_flash.h fsl_adapter_flexspi_nor_flash.c
  group component/nvm
    ../../../../../components/nvm/: nvm_adapter.h nvm_adapter.c
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
  group sdmmc/src
    ../../../../../middleware/sdmmc/sdio/: fsl_sdio.c
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc/sdio/: fsl_sdio.h
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sdio
    ../../../../../middleware/sdmmc/sdio/: ChangeLogKSDK.txt
  group sdmmc/host
    ../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt
    ../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group sdmmc/osa
    ../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group usb/host
    ../../../../../middleware/usb/host/: usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c usb_host_ehci.c usb_host_ehci.h usb_host.h usb_host_hci.h usb_host_devices.h usb_host_framework.h
  group usb/host/class
    ../../../../../middleware/usb/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_msd.c usb_host_msd.h usb_host_msd_ufi.c
  group usb/phy
    ../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group usb/include
    ../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group fatfs/source
    ../../../../../middleware/fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c diskio.h ff.h
  group fatfs/source/fsl_usb_disk
    ../../../../../middleware/fatfs/source/fsl_usb_disk/: fsl_usb_disk.h fsl_usb_disk_freertos.c
  group ethermind/bluetooth/export/eOSAL
    ../../../../../middleware/wireless/ethermind/bluetooth/export/eOSAL/: eBT_assert.h eBT_config.h eBT_debug_api.h eBT_fops.h eBT_os.h eBT_serial.h eBT_timer.h
  group ethermind/bluetooth/export/include
    ../../../../../middleware/wireless/ethermind/bluetooth/export/include/: BT_ftp_api.h BT_at_parser_api.h write_task.h BT_bpp_api.h BT_security.h BT_bip_api.h BT_opp_api.h BT_pan_api.h BT_dbase_api.h BT_a2dp_api.h BT_hid_host_api.h BT_hfp_ag_api.h BT_status.h fsm_defines.h BT_bottom_half.h BT_racp.h BT_jpl_api.h BT_snoop.h gatt_defines.h BT_storage.h BT_rfcomm_api.h BT_gatt_db_api.h BT_assigned_numbers.h BT_avdtp_api.h BT_hdp_api.h BT_bnep_api.h BT_att_api.h hci_transport.h fsm_engine.h BT_error.h BT_api.h BT_smp_api.h BT_obex_api.h BT_ctn_api.h BT_sdp_api.h l2cap.h BT_version.h BT_hfp_unit_api.h BT_device_queue.h BT_common.h BT_avctp_api.h BT_avrcp_ca_api.h BT_avrcp_api.h BT_mcap_api.h BT_spp_api.h BT_pbap_api.h BT_sap_api.h BT_hid_device_api.h BT_sm_api.h BT_irobex_api.h BT_hci_api.h BT_map_api.h BT_gap_api.h
  group ethermind/bluetooth/export/vendor
    ../../../../../middleware/wireless/ethermind/bluetooth/export/vendor/: vendor_specific_commands.h vendor_specific_init.c vendor_specific_init.h
  group ethermind/bluetooth/export/extension
    ../../../../../middleware/wireless/ethermind/bluetooth/export/extension/: aes_cmac_pl.c aes_cmac_pl.h BT_common_pl.c BT_common_pl.h device_queue_pl.c device_queue_pl.h sm_pl.c sm_pl.h sm_ssp_pl.c sm_ssp_pl.h smp_pl.c smp_pl.h
  group ethermind/bluetooth/private/protocols/att
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/att/: att.h
  group ethermind/bluetooth/private/protocols/avctp
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avctp/: avctp.h
  group ethermind/bluetooth/private/protocols/avdtp
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avdtp/: avdtp.h
  group ethermind/bluetooth/private/protocols/bnep
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/bnep/: bnep.h
  group ethermind/bluetooth/private/protocols/dbase
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/dbase/: database.h
  group ethermind/bluetooth/private/protocols/hci_1.2
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/hci_1.2/: hci_h.h
  group ethermind/bluetooth/private/protocols/mcap
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/mcap/: mcap.h
  group ethermind/bluetooth/private/protocols/obex
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/obex/: obex.h
  group ethermind/bluetooth/private/protocols/rfcomm
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/rfcomm/: rfcomm.h
  group ethermind/bluetooth/private/protocols/sdp
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sdp/: sdp.h
  group ethermind/bluetooth/private/protocols/sm
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sm/: sm.h sm_extern.h sm_internal.h
  group ethermind/bluetooth/private/protocols/smp
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/smp/: smp.h smp_extern.h smp_fsm.h smp_fsm_engine.h smp_internal.h
  group ethermind/bluetooth/private/utils/aes_cmac
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/aes_cmac/: aes_cmac.h
  group ethermind/bluetooth/private/utils/at_parser
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/at_parser/: at_parser_hsp_hfp.h
  group ethermind/bluetooth/private/utils/object_parser
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/object_parser/: tokenizer.h object_parser_api.h
  group ethermind/bluetooth/private/utils/racp
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/racp/: racp.h
  group ethermind/bluetooth/private/utils/storage
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/storage/: storage.h
  group ethermind/bluetooth/private/utils/xml_parser
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/xml_parser/: xml_common_defines.h xml_encoder.h xml_parser.h
  group ethermind/bluetooth/private/utils/sbc
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/sbc/: sbc_api.h
  group ethermind/bluetooth/private/lib/config
    ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/config/: BT_features.h BT_limits.h db_gen.h
  group ethermind/port/osal/src/freertos
    ../../../../../middleware/wireless/ethermind/port/osal/src/freertos/: EM_debug_api.h EM_serial.c EM_timer.c EM_os.c EM_debug_internal.h EM_fops.h EM_serial.h EM_timer_internal.h EM_fops.c EM_debug.h EM_debug.c EM_os.h EM_config.c EM_assert.h EM_config.h EM_timer.h
  group ethermind/port/pal/mcux
    ../../../../../middleware/wireless/ethermind/port/pal/mcux/: EM_platform.c EM_platform.h
  group ethermind/port/pal/mcux/bluetooth
    ../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth/: BT_assert.h BT_config.h BT_debug.h BT_debug_api.h BT_fops.h BT_os.h BT_status_pl.c BT_storage_pl.c BT_storage_pl.h BT_timer.h btsnoop_pl.c btsnoop_pl.h ctn_pl.c ctn_pl.h ftp_pl.c ftp_pl.h hci_uart.c hci_uart.h hci_uart_internal.h ht_read_task_pl.c map_pl.c map_pl.h obex_pl.c obex_pl.h pbap_pl.c pbap_pl.h write_task_extern_pl.h write_task_pl.c write_task_pl.h controller.c controller.h
    ../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth/controller/: controller_wifi_nxp.c controller_wifi_nxp.h
  group ethermind/port/pal/mcux/ethal
    ../../../../../middleware/wireless/ethermind/port/pal/mcux/ethal/: ethal_timer_internal.h ethal_debug.c ethal_config.c ethal_fops.c ethal_serial.h ethal_config.h ethal_timer.c ethal_fops.h ethal_debug_api.h ethal_assert.h ethal_debug.h ethal_serial.c ethal_os.c ethal_timer.h ethal_os.h ethal_debug_internal.h
  group ethermind/port/pal/mcux/sbc
    ../../../../../middleware/wireless/ethermind/port/pal/mcux/sbc/: sbc_os.h
  group lwip/port
    ../../../../../middleware/lwip/port/: sys_arch.c
  group lwip/port/arch
    ../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src/api
    ../../../../../middleware/lwip/src/api/: sockets.c netifapi.c netdb.c netbuf.c tcpip.c api_msg.c err.c if_api.c api_lib.c
  group lwip/src/core
    ../../../../../middleware/lwip/src/core/: memp.c def.c ip.c pbuf.c altcp.c tcp_out.c raw.c altcp_tcp.c sys.c init.c inet_chksum.c timeouts.c tcp_in.c netif.c mem.c udp.c tcp.c stats.c dns.c altcp_alloc.c
  group lwip/src/core/ipv6
    ../../../../../middleware/lwip/src/core/ipv6/: ethip6.c dhcp6.c ip6_addr.c nd6.c mld6.c icmp6.c ip6_frag.c ip6.c inet6.c
  group lwip/src/core/ipv4
    ../../../../../middleware/lwip/src/core/ipv4/: dhcp.c ip4.c autoip.c icmp.c acd.c etharp.c ip4_addr.c igmp.c ip4_frag.c
  group lwip/src/include/compat/stdc
    ../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/compat/posix
    ../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/sys
    ../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/posix/net
    ../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/lwip
    ../../../../../middleware/lwip/src/include/lwip/: inet_chksum.h ip6.h udp.h def.h mld6.h err.h ip4.h opt.h errno.h debug.h icmp.h netif.h sio.h ip6_zone.h igmp.h netdb.h dhcp.h altcp_tls.h altcp_tcp.h ip_addr.h inet.h tcp.h api.h arch.h autoip.h ip4_addr.h altcp.h mem.h sys.h init.h dns.h tcpbase.h stats.h icmp6.h netifapi.h ethip6.h snmp.h raw.h if_api.h tcpip.h ip6_frag.h nd6.h ip.h pbuf.h acd.h ip4_frag.h timeouts.h dhcp6.h sockets.h netbuf.h etharp.h ip6_addr.h memp.h
  group lwip/src/include/lwip/priv
    ../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h mem_priv.h memp_priv.h memp_std.h api_msg.h nd6_priv.h tcpip_priv.h tcp_priv.h raw_priv.h sockets_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../middleware/lwip/src/include/lwip/prot/: ip6.h udp.h mld6.h ip4.h icmp.h igmp.h dhcp.h tcp.h autoip.h iana.h ieee.h dns.h icmp6.h ethernet.h nd6.h ip.h acd.h dhcp6.h etharp.h
  group lwip/src/include/netif
    ../../../../../middleware/lwip/src/include/netif/: bridgeif.h zepif.h lowpan6.h ieee802154.h ethernet.h lowpan6_common.h lowpan6_opts.h bridgeif_opts.h slipif.h lowpan6_ble.h etharp.h
  group lwip/src/include/netif/ppp
    ../../../../../middleware/lwip/src/include/netif/ppp/: ipv6cp.h pppapi.h magic.h ppp.h upap.h mppe.h pppol2tp.h pppoe.h ipcp.h pppdebug.h eap.h pppos.h ppp_opts.h pppcrypt.h vj.h chap-new.h eui64.h chap_ms.h ccp.h ecp.h lcp.h fsm.h ppp_impl.h chap-md5.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: sha1.h des.h md5.h md4.h arc4.h
  group lwip/src/netif
    ../../../../../middleware/lwip/src/netif/: lowpan6.c ethernet.c bridgeif.c bridgeif_fdb.c zepif.c lowpan6_common.c lowpan6_ble.c slipif.c
  group lwip/src/netif/ppp
    ../../../../../middleware/lwip/src/netif/ppp/: pppol2tp.c mppe.c vj.c pppcrypt.c ppp.c eap.c chap-md5.c lcp.c pppos.c ipcp.c fsm.c ccp.c utils.c chap-new.c demand.c pppoe.c ipv6cp.c lwip_ecp.c multilink.c eui64.c magic.c upap.c pppapi.c chap_ms.c auth.c
  group flash/mflash
    ../../../../../components/flash/mflash/: mflash_file.h mflash_file.c mflash_common.h
  group flash/mflash/mimxrt1062
    ../../../../../components/flash/mflash/mimxrt1062/: mflash_drv.h mflash_drv.c
  group mbedtls/include/mbedtls
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/library
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c chacha20.c chachapoly.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/port/ksdk
    ../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c ecp_alt.h ecp_alt.c ecp_curves_alt.c ecp_alt_ksdk.c
  group framework/FunctionLib
    ../../../../../middleware/wireless/framework/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/NVM/interface
    ../../../../../middleware/wireless/framework/NVM/Interface/: NVM_Interface.h
  group framework/NVM/source
    ../../../../../middleware/wireless/framework/NVM/Source/: NV_Flash.c NV_Flash.h
  group framework/Common
    ../../../../../middleware/wireless/framework/Common/: EmbeddedTypes.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
