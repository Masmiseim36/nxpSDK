# Keil uVision project cmsis_nn_cifar10.uvprojx, settings and files
target cmsis_nn_cifar10 flexspi_nor_sdram_debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: cmsis_nn_cifar10.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, DEBUG, CPU_MIMXRT1062DVL6A, SDK_DEBUGCONSOLE_UART, ARM_MATH_CM7, __FPU_PRESENT=1, SDK_I2C_BASED_COMPONENT_USED=1, SDK_I2C_BASED_COMPONENT_USED=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../middleware/eiq/cmsis-nn/Examples/cifar10;../../../../../middleware/eiq/common;../../../../../middleware/eiq/common/image;..;../../../../../components/video/camera/device;../../../../../components/video/camera/receiver;../../../../../components/video/camera/device/sccb;../../../../../components/video/camera/device/ov7725;../../../../../components/video/camera/device/mt9m114;../../../../../components/video/camera;../../../../../components/video/camera/receiver/csi;../../../../../devices/MIMXRT1062/drivers;../../../../../components/video;../../../../../components/video/i2c;../../../../../components/video/display/dc;../../../../../components/video/display/dc/elcdif;../../../../../devices/MIMXRT1062/utilities/debug_console_lite;../../../../../middleware/eiq/common/video;../../../../../middleware/eiq/cmsis-nn/Include;../../../../../components/lists;../../../../../components/uart;../../../../../devices/MIMXRT1062;../../../../../devices/MIMXRT1062/xip;../../../xip;../../../../../CMSIS/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ../../../../../devices/MIMXRT1062/arm/MIMXRT1062xxxxx_flexspi_nor_sdram.scf
  link misc: ../../../../../CMSIS/DSP/Lib/ARM/arm_cortexM7lfdp_math.lib --remove --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-D__stack_size__=0x10000" --predefine="-D__heap_size__=0x800000"
  group source/image
    ../../../../../middleware/eiq/common/image/: image_conv.c image.h image_capture.c image_decode_raw.c image_draw.c image_resize_nearest.c image_utils.h
    ../../../../../middleware/eiq/cmsis-nn/Examples/cifar10/: demo_config.h image_data.h
  group source
    ../../../../../middleware/eiq/cmsis-nn/Examples/cifar10/: cifar10.c labels.h parameter.h weights.h
    ../../../../../middleware/eiq/common/: timer.h timer.c eiq_common.h eiq_iui.h eiq_iworker.h
  group doc
    ../../../../../middleware/eiq/cmsis-nn/Examples/cifar10/: ship.bmp
    ../: readme.txt
  group board
    ../../../../../middleware/eiq/common/: board_init.h
    ../: pin_mux.c pin_mux.h board.c board.h board_init.c clock_config.c clock_config.h dcd.c dcd.h
    ./: retarget.c
  group video
    ../../../../../components/video/camera/device/: fsl_camera_device.h
    ../../../../../components/video/camera/receiver/: fsl_camera_receiver.h
    ../../../../../components/video/camera/device/sccb/: fsl_sccb.h fsl_sccb.c
    ../../../../../components/video/camera/device/ov7725/: fsl_ov7725.h fsl_ov7725.c
    ../../../../../components/video/camera/device/mt9m114/: fsl_mt9m114.h fsl_mt9m114.c
    ../../../../../components/video/camera/: fsl_camera.h
    ../../../../../components/video/camera/receiver/csi/: fsl_csi_camera_adapter.h fsl_csi_camera_adapter.c
    ../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../components/video/i2c/: fsl_video_i2c.h fsl_video_i2c.c
    ../../../../../components/video/display/dc/: fsl_dc_fb.h
    ../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.h fsl_dc_fb_elcdif.c
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_csi.c fsl_csi.h fsl_elcdif.c fsl_elcdif.h fsl_pxp.c fsl_pxp.h fsl_gpio.h fsl_gpio.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group source/video
    ../../../../../middleware/eiq/common/video/camera/MT9M114_OV7725/: eiq_camera_conf.c
    ../../../../../middleware/eiq/common/video/display/RK043FN02HC/: eiq_display_conf.c
    ../../../../../middleware/eiq/common/video/: eiq_display.c eiq_video_worker.c eiq_pxp.c eiq_camera.c eiq_video_worker.h eiq_pxp.h eiq_camera_conf.h eiq_display_conf.h eiq_display.h eiq_camera.h
  group eiq/cmsis-nn/Include
    ../../../../../middleware/eiq/cmsis-nn/Include/: arm_nnsupportfunctions.h arm_nnfunctions.h arm_nn_tables.h
  group eiq/cmsis-nn/Source/ActivationFunctions
    ../../../../../middleware/eiq/cmsis-nn/Source/ActivationFunctions/: arm_relu_q15.c arm_relu_q7.c arm_nn_activations_q7.c arm_nn_activations_q15.c
  group eiq/cmsis-nn/Source/ConvolutionFunctions
    ../../../../../middleware/eiq/cmsis-nn/Source/ConvolutionFunctions/: arm_convolve_HWC_q7_basic.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_convolve_HWC_q7_basic_nonsquare.c arm_depthwise_separable_conv_HWC_q7.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q7_RGB.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_convolve_HWC_q15_basic.c arm_depthwise_conv_u8_basic_ver1.c arm_convolve_HWC_q7_fast.c arm_nn_mat_mult_kernel_q7_q15.c
  group eiq/cmsis-nn/Source/FullyConnectedFunctions
    ../../../../../middleware/eiq/cmsis-nn/Source/FullyConnectedFunctions/: arm_fully_connected_q7.c arm_fully_connected_q15_opt.c arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_q7_opt.c arm_fully_connected_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c
  group eiq/cmsis-nn/Source/NNSupportFunctions
    ../../../../../middleware/eiq/cmsis-nn/Source/NNSupportFunctions/: arm_nn_mult_q15.c arm_nntables.c arm_nn_mult_q7.c arm_q7_to_q15_reordered_no_shift.c arm_q7_to_q15_no_shift.c
  group eiq/cmsis-nn/Source/PoolingFunctions
    ../../../../../middleware/eiq/cmsis-nn/Source/PoolingFunctions/: arm_pool_q7_HWC.c
  group eiq/cmsis-nn/Source/SoftmaxFunctions
    ../../../../../middleware/eiq/cmsis-nn/Source/SoftmaxFunctions/: arm_softmax_q7.c arm_softmax_q15.c
  group eiq/cmsis-nn
    ../../../../../middleware/eiq/cmsis-nn/: readme.txt LICENSE.txt ChangeLogKSDK.txt
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group startup
    ../../../../../devices/MIMXRT1062/arm/: startup_MIMXRT1062.S
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
target cmsis_nn_cifar10 flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: cmsis_nn_cifar10.out
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, CPU_MIMXRT1062DVL6A, SDK_DEBUGCONSOLE_UART, ARM_MATH_CM7, __FPU_PRESENT=1, SDK_I2C_BASED_COMPONENT_USED=1, SDK_I2C_BASED_COMPONENT_USED=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: as above
  link misc: as above
