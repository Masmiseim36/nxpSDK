# IAR project glow_lenet_mnist.ewp, settings and files
configuration flexspi_nor_sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1062DVL6A; ARM_MATH_CM7; __FPU_PRESENT=1; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SDK_DEBUGCONSOLE=1; FSL_RTOS_BM; SDK_OS_BAREMETAL; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pe167
  ICCARM.IExtraOptions: --diag_suppress Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../source; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../source; ../../..; ../../../demo_apps/hello_world; ../../../project_template; ../../../../../middleware/eiq/glow/examples/common/source; ../../../../../middleware/eiq/glow/bundle_utils; ../../../../../components/lists; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062; ../../../../../devices/MIMXRT1062/xip; ../../../xip; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../devices/MIMXRT1062/utilities/debug_console; ../../../../../devices/MIMXRT1062/utilities
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: glow_lenet_mnist.out
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor_sdram.icf
  ILINK.IlinkExtraOptions: --diag_suppress=Lt009
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1062DVL6A; ARM_MATH_CM7; __FPU_PRESENT=1; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SDK_DEBUGCONSOLE=1; FSL_RTOS_BM; SDK_OS_BAREMETAL; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../source/: lenet_mnist.h lenet_mnist.o lenet_mnist.weights.bin lenet_mnist.weights.txt input_image.inc main.c timer.c timer.h
  group doc
    ../doc/: readme.txt
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h peripherals.h peripherals.c dcd.c dcd.h
  group glow
    ../../../../../middleware/eiq/glow/: LICENSE.txt readme.txt
    ../../../../../middleware/eiq/glow/bundle_utils/: glow_bundle_utils.c glow_bundle_utils.h
  group scripts
    ../../../../../middleware/eiq/glow/examples/common/: glow_process_image.py
  group component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group component/uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_clock.c fsl_clock.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h
  group device
    ../../../../../devices/MIMXRT1062/: MIMXRT1062.h MIMXRT1062_features.h fsl_device_registers.h system_MIMXRT1062.c system_MIMXRT1062.h
  group startup
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
