# Keil uVision project tensorflow_lite_adt.uvprojx, settings and files
target tensorflow_lite_adt flexspi_nor_sdram_debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: tensorflow_lite_adt.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, DEBUG, __CLK_TCK=1000000, CPU_MIMXRT1062DVL6A, SDK_DEBUGCONSOLE_UART, FLATBUFFERS_LITTLEENDIAN, TFLITE_MCU, ARM_MATH_CM7, __FPU_PRESENT=1, SDK_I2C_BASED_COMPONENT_USED=1, SERIAL_PORT_TYPE_UART=1
  c misc: -Wno-missing-field-initializers  -Wno-self-assign  -Wno-unreachable-code  -fno-exceptions  -Wno-armcc-pragma-import  -Wno-bad-function-cast  -Wno-c++98-compat-pedantic  -Wno-c11-extensions  -Wno-c99-extensions  -Wno-cast-qual  -Wno-conversion  -Wno-covered-switch-default  -Wno-dollar-in-identifier-extension  -Wno-double-promotion  -Wno-exit-time-destructors  -Wno-extern-c-compat  -Wno-extra-semi-stmt  -Wno-float-equal  -Wno-gnu-folding-constant  -Wno-inconsistent-missing-destructor-override  -Wno-missing-noreturn  -Wno-missing-prototypes  -Wno-missing-variable-declarations  -Wno-nested-anon-types  -Wno-old-style-cast  -Wno-padded  -Wno-shadow-uncaptured-local  -Wno-shadow  -Wno-sign-compare  -Wno-sign-conversion  -Wno-switch-enum  -Wno-undef  -Wno-unknown-warning-option  -Wno-unreachable-code-break  -Wno-unreachable-code-return  -Wno-unused-parameter  -Wno-unused-variable  -Wno-weak-vtables  -Wno-zero-as-null-pointer-constant  -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ../../../../../CMSIS/Include;../../../../../devices;../../../../../middleware/eiq/tensorflow-lite/examples/adt;../../../../../middleware/eiq/tensorflow-lite/examples/adt/evkmimxrt1060;..;../../../../../middleware/eiq/tensorflow-lite/examples/common/source;../../../../../devices/MIMXRT1062/drivers;../../../../../devices/MIMXRT1062/cmsis_drivers;../../../../../CMSIS/Driver/Include;../../../../../middleware/issdk/drivers/systick;../../../../../middleware/issdk/drivers/gpio;../../../../../middleware/issdk/drivers/gpio/i.mx;../../../../../middleware/issdk/sensors;../../../../../middleware/eiq/tensorflow-lite;../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include;../../../../../middleware/eiq/tensorflow-lite/third_party;../../../../../components/lists;../../../../../components/uart;../../../../../components/serial_manager;../../../../../devices/MIMXRT1062;../../../../../devices/MIMXRT1062/xip;../../../xip;../../../../../devices/MIMXRT1062/utilities/str;../../../../../devices/MIMXRT1062/utilities/debug_console;../../../../../devices/MIMXRT1062/utilities
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor_sdram.scf
  link misc: ../../../../../middleware/eiq/tensorflow-lite/lib/cm7/mdk/tensorflow-lite.lib --remove --predefine="-D__stack_size__=0x10000" --predefine="-D__heap_size__=0x800000" --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group board
    ../: frdm_stbc_agm01_shield.h issdk_hal.h RTE_Device.h evkmimxrt1060.c evkmimxrt1060.h pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
    ./: retarget.c
  group source
    ../../../../../middleware/eiq/tensorflow-lite/examples/adt/: adt.cpp adt_model.h parameters.h get_sensor_data.c get_sensor_data.h
  group doc
    ../../../../../middleware/eiq/tensorflow-lite/examples/adt/adt_train/: adt_model.tflite adt_train.py requirements.txt
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_edma.c fsl_edma.h fsl_dmamux.c fsl_dmamux.h fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.c fsl_lpspi_edma.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h
    ../../../../../devices/MIMXRT1062/cmsis_drivers/: fsl_lpi2c_cmsis.c fsl_lpi2c_cmsis.h fsl_lpspi_cmsis.c fsl_lpspi_cmsis.h fsl_lpuart_cmsis.c fsl_lpuart_cmsis.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
  group CMSIS_driver
    ../../../../../CMSIS/Driver/Include/: Driver_Common.h Driver_SPI.h Driver_USART.h Driver_I2C.h
  group utilities
    ../../../../../middleware/issdk/drivers/systick/: systick_utils.c systick_utils.h systick_utils.c systick_utils.h
    ../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
  group gpio_driver
    ../../../../../middleware/issdk/drivers/gpio/: Driver_GPIO.h
    ../../../../../middleware/issdk/drivers/gpio/i.mx/: gpio_driver.c gpio_driver.h
  group interfaces
    ../../../../../middleware/issdk/sensors/: register_io_i2c.c register_io_i2c.h register_io_spi.c register_io_spi.h sensor_drv.h sensor_io_i2c.c sensor_io_i2c.h sensor_io_spi.c sensor_io_spi.h
  group sensors
    ../../../../../middleware/issdk/sensors/: fxas21002.h fxas21002_drv.c fxas21002_drv.h fxos8700.h fxos8700_drv.c fxos8700_drv.h
  group tensorflow-lite-tensorflow-core-public
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/core/public/: session.h version.h
  group tensorflow-lite-tensorflow-core-util
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/core/util/: stat_summarizer_options.h stats_calculator.h
  group tensorflow-lite-tensorflow-lite
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/: allocation.h arena_planner.h builtin_op_data.h builtin_ops.h context.h context_util.h error_reporter.h external_cpu_backend_context.h graph_info.h interpreter.h memory_planner.h minimal_logging.h model.h mutable_op_resolver.h op_resolver.h optional_debug_tools.h simple_memory_arena.h stderr_reporter.h string_type.h string_util.h util.h version.h
  group tensorflow-lite-tensorflow-lite-c
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/c/: builtin_op_data.h c_api_internal.h
  group tensorflow-lite-tensorflow-lite-core-api
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/api/: error_reporter.h flatbuffer_conversions.h op_resolver.h profiler.h tensor_utils.h
  group tensorflow-lite-tensorflow-lite-core
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/: subgraph.h
  group tensorflow-lite-tensorflow-lite-experimental-resource_variable
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/experimental/resource_variable/: resource_variable.h
  group tensorflow-lite-tensorflow-lite-experimental-ruy
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/experimental/ruy/: ruy.h
  group tensorflow-lite-tensorflow-lite-kernels
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/: activation_functor.h builtin_op_kernels.h cpu_backend_context.h cpu_backend_gemm.h cpu_backend_gemm_custom_gemv.h cpu_backend_gemm_eigen.h cpu_backend_gemm_gemmlowp.h cpu_backend_gemm_params.h cpu_backend_gemm_ruy.h cpu_backend_threadpool.h custom_ops_register.h eigen_support.h fully_connected.h kernel_util.h lstm_eval.h op_macros.h padding.h register.h register_ref.h
  group tensorflow-lite-tensorflow-lite-kernels-internal-reference-integer_ops
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops/: add.h conv.h depthwise_conv.h dequantize.h fully_connected.h l2normalization.h log_softmax.h logistic.h mean.h mul.h pooling.h softmax.h tanh.h
  group tensorflow-lite-tensorflow-lite-profiling
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/profiling/: buffered_profiler.h memory_info.h noop_profiler.h profile_buffer.h profile_summarizer.h profiler.h time.h
  group tensorflow-lite-tensorflow-lite-schema
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/schema/: schema_generated.h
  group tensorflow-lite-tensorflow-lite-tools-benchmark
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/tools/benchmark/: benchmark_model.h benchmark_params.h benchmark_tflite_model.h benchmark_utils.h logging.h
  group tensorflow-lite-tensorflow-lite-tools
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/tools/: command_line_flags.h
  group tensorflow-lite-third_party-absl-base
    ../../../../../middleware/eiq/tensorflow-lite/third_party/absl/base/: attributes.h
  group tensorflow-lite-third_party-flatbuffers-include-flatbuffers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/: base.h code_generators.h flatbuffers.h flexbuffers.h hash.h idl.h minireflect.h reflection.h reflection_generated.h registry.h stl_emulation.h util.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group component-uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group device
    ../../../../../devices/MIMXRT1062/: MIMXRT1062.h MIMXRT1062_features.h fsl_device_registers.h system_MIMXRT1062.c system_MIMXRT1062.h
  group startup
    ../../../../../devices/MIMXRT1062/arm/: startup_MIMXRT1062.S
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
target tensorflow_lite_adt flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: tensorflow_lite_adt.out
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, __CLK_TCK=1000000, CPU_MIMXRT1062DVL6A, SDK_DEBUGCONSOLE_UART, FLATBUFFERS_LITTLEENDIAN, TFLITE_MCU, ARM_MATH_CM7, __FPU_PRESENT=1, SDK_I2C_BASED_COMPONENT_USED=1, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor_sdram.scf
  link misc: as above
