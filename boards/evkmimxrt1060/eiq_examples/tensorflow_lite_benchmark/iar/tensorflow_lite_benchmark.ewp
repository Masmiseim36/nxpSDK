# IAR project tensorflow_lite_benchmark.ewp, settings and files
configuration flexspi_nor_sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1062DVL6A; SDK_DEBUGCONSOLE_UART; FLATBUFFERS_LITTLEENDIAN; GEMMLOWP_MCU; TFLITE_MCU; ARM_MATH_CM7; __FPU_PRESENT=1; SDK_I2C_BASED_COMPONENT_USED=1
  ICCARM.CCDiagSuppress: Pa082,Pa089,Pa093,Pe111,Pe549,Pe550,Pe186,Pe611,Pe815
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.CCIncludePath2: ../../../../../middleware/eiq/tensorflow-lite/examples/benchmark; ../../../../../middleware/eiq/common; ..; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/utilities/debug_console_lite; ../../../../../middleware/eiq/tensorflow-lite; ../../../../../middleware/eiq/tensorflow-lite/third_party; ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include; ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp; ../../../../../components/lists; ../../../../../components/uart; ../../../../../devices/MIMXRT1062; ../../../../../devices/MIMXRT1062/xip; ../../../xip; ../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: tensorflow_lite_benchmark.out
  ILINK.IlinkConfigDefines: __stack_size__=0x10000; __heap_size__=0x800000
  ILINK.IlinkIcfFile: ../../../../../devices/MIMXRT1062/iar/MIMXRT1062xxxxx_flexspi_nor_sdram.icf
  ILINK.IlinkExtraOptions: --diag_suppress=Lt049
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/eiq/tensorflow-lite/lib/cm7/iar/libtensorflow-lite.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1062DVL6A; SDK_DEBUGCONSOLE_UART; FLATBUFFERS_LITTLEENDIAN; GEMMLOWP_MCU; TFLITE_MCU; ARM_MATH_CM7; __FPU_PRESENT=1; SDK_I2C_BASED_COMPONENT_USED=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../../../../../middleware/eiq/tensorflow-lite/examples/benchmark/: model.h benchmark_main.cpp benchmark_model.cpp benchmark_tflite_model.cpp
    ../../../../../middleware/eiq/common/: timer.c timer.h
  group doc
    ../../../../../middleware/eiq/tensorflow-lite/examples/benchmark/: model.tflite
    ../: readme.txt
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
    ./: retarget.c
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_gpio.h fsl_gpio.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group eiq/tensorflow-lite/tensorflow/core/public
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/core/public/: version.h session.h
  group eiq/tensorflow-lite/tensorflow/core/util
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/core/util/: stats_calculator.h stat_summarizer_options.h
  group eiq/tensorflow-lite/tensorflow/lite
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/: context.h type_to_tflitetype.h builtin_op_data.h builtin_ops.h op_resolver.h version.h stderr_reporter.h optional_debug_tools.h mutable_op_resolver.h util.h model_builder.h external_cpu_backend_context.h arena_planner.h context_util.h memory_planner.h graph_info.h minimal_logging.h configuration.h model.h simple_memory_arena.h tflite_with_xnnpack_optional.h allocation.h string_type.h string_util.h error_reporter.h interpreter.h interpreter_builder.h
  group eiq/tensorflow-lite/tensorflow/lite/c
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/c/: builtin_op_data.h c_api.h common.h c_api_internal.h
  group eiq/tensorflow-lite/tensorflow/lite/core
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/: macros.h subgraph.h
  group eiq/tensorflow-lite/tensorflow/lite/core/api
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/api/: op_resolver.h profiler.h flatbuffer_conversions.h error_reporter.h tensor_utils.h
  group eiq/tensorflow-lite/tensorflow/lite/experimental/resource
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/experimental/resource/: resource_base.h resource_variable.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/: register_ref.h eigen_support.h cpu_backend_threadpool.h padding.h cpu_backend_gemm_eigen.h cpu_backend_gemm_ruy.h kernel_util.h lstm_eval.h dequantize.h cpu_backend_gemm_gemmlowp.h register.h lstm_shared.h cpu_backend_gemm_custom_gemv.h fully_connected.h builtin_op_kernels.h custom_ops_register.h cpu_backend_context.h op_macros.h cpu_backend_gemm_params.h cpu_backend_gemm.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops/: depthwise_conv.h logistic.h mul.h dequantize.h fully_connected.h tanh.h conv.h log_softmax.h transpose_conv.h mean.h l2normalization.h add.h pooling.h
  group eiq/tensorflow-lite/tensorflow/lite/profiling
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/profiling/: platform_profiler.h profile_summary_formatter.h profiler.h profile_summarizer.h noop_profiler.h memory_info.h buffered_profiler.h profile_buffer.h time.h
  group eiq/tensorflow-lite/tensorflow/lite/schema
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/schema/: schema_generated.h
  group eiq/tensorflow-lite/tensorflow/lite/tools
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/tools/: command_line_flags.h logging.h tool_params.h
  group eiq/tensorflow-lite/tensorflow/lite/tools/benchmark
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/tools/benchmark/: benchmark_model.h benchmark_tflite_model.h benchmark_params.h profiling_listener.h benchmark_utils.h
  group eiq/tensorflow-lite/tensorflow/lite/tools/delegates
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/tools/delegates/: delegate_provider.h
  group eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/: idl.h reflection_generated.h hash.h minireflect.h util.h code_generators.h flexbuffers.h registry.h reflection.h base.h flatbuffers.h stl_emulation.h
  group eiq/tensorflow-lite/third_party/absl/base
    ../../../../../middleware/eiq/tensorflow-lite/third_party/absl/base/: attributes.h
  group eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint/: fixedpoint_msa.h fixedpoint.h fixedpoint_neon.h fixedpoint_sse.h
  group eiq/tensorflow-lite/third_party/gemmlowp/internal
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/internal/: output_sse.h detect_platform.h kernel.h multi_thread_gemm.h kernel_msa.h compute.h pack.h pack_neon.h kernel_reference.h simd_wrappers_sse.h simd_wrappers_common_neon_sse.h kernel_neon.h simd_wrappers.h output_msa.h output.h kernel_sse.h allocator.h common.h kernel_dsp.h block_params.h dispatch_gemm_shape.h platform.h pack_sse.h kernel_default.h simd_wrappers_neon.h output_neon.h single_thread_gemm.h simd_wrappers_msa.h unpack.h pack_msa.h
  group eiq/tensorflow-lite/third_party/gemmlowp/meta
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/meta/: multi_thread_gemm.h multi_thread_transform.h transform_kernels_arm_32.h streams.h streams_arm_32.h quantized_mul_kernels_arm_32.h legacy_single_thread_gemm.h multi_thread_common.h streams_arm_64.h legacy_multi_thread_common.h legacy_multi_thread_gemm.h transform_kernels.h quantized_mul_kernels.h base.h quantized_mul_kernels_arm_64.h legacy_operations_common.h transform_kernels_arm_64.h single_thread_transform.h legacy_multi_thread_gemv.h single_thread_gemm.h
  group eiq/tensorflow-lite/third_party/gemmlowp/profiling
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/profiling/: profiler.h instrumentation.h pthread_everywhere.h
  group eiq/tensorflow-lite/third_party/gemmlowp/public
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/public/: config.h bit_depth.h gemmlowp.h map.h output_stages.h
  group eiq/tensorflow-lite/third_party/ruy
    ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/: context.h side_pair.h thread_pool.h ctx_impl.h kernel.h size_util.h system_aligned_alloc.h ruy.h apply_multiplier.h matrix.h pack.h blocking_counter.h pack_x86.h kernel_arm.h trmul_params.h cpu_cache_params.h cpuinfo.h pack_common.h mat.h allocator.h common.h pack_arm.h prepacked_cache.h kernel_x86.h block_map.h opt_set.h ctx.h dispatch.h trmul.h have_built_path_for.h platform.h path.h kernel_common.h tune.h mul_params.h time.h check_macros.h context_get_ctx.h
  group eiq/tensorflow-lite/third_party/ruy/profiler
    ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/profiler/: treeview.h profiler.h instrumentation.h
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group startup
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
