# Keil uVision project tensorflow_lite_benchmark.uvprojx, settings and files
target tensorflow_lite_benchmark flexspi_nor_sdram_debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: tensorflow_lite_benchmark.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, DEBUG, __CLK_TCK=1000000, CPU_MIMXRT1062DVL6A, SDK_DEBUGCONSOLE_UART, FLATBUFFERS_LITTLEENDIAN, GEMMLOWP_MCU, TFLITE_MCU, ARM_MATH_CM7, __FPU_PRESENT=1, SDK_I2C_BASED_COMPONENT_USED=1
  c misc: -fno-exceptions  -Wno-armcc-pragma-import  -Wno-bad-function-cast  -Wno-c++98-compat-pedantic  -Wno-c11-extensions  -Wno-c99-extensions  -Wno-cast-qual  -Wno-conversion  -Wno-covered-switch-default  -Wno-dollar-in-identifier-extension  -Wno-double-promotion  -Wno-exit-time-destructors  -Wno-extern-c-compat  -Wno-extra-semi-stmt  -Wno-float-equal  -Wno-gnu-folding-constant  -Wno-inconsistent-missing-destructor-override  -Wno-missing-noreturn  -Wno-missing-prototypes  -Wno-missing-variable-declarations  -Wno-nested-anon-types  -Wno-old-style-cast  -Wno-padded  -Wno-shadow-uncaptured-local  -Wno-shadow  -Wno-sign-compare  -Wno-sign-conversion  -Wno-switch-enum  -Wno-undef  -Wno-unknown-warning-option  -Wno-unreachable-code-break  -Wno-unreachable-code-return  -Wno-unused-parameter  -Wno-unused-variable  -Wno-weak-vtables  -Wno-zero-as-null-pointer-constant  -Wno-typedef-redefinition  -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ../../../../../middleware/eiq/tensorflow-lite/examples/benchmark;../../../../../middleware/eiq/common;..;../../../../../devices/MIMXRT1062/drivers;../../../../../devices/MIMXRT1062/utilities/debug_console_lite;../../../../../middleware/eiq/tensorflow-lite;../../../../../middleware/eiq/tensorflow-lite/third_party;../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include;../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp;../../../../../components/lists;../../../../../components/uart;../../../../../devices/MIMXRT1062;../../../../../devices/MIMXRT1062/xip;../../../xip;../../../../../CMSIS/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ../../../../../devices/MIMXRT1062/arm/MIMXRT1062xxxxx_flexspi_nor_sdram.scf
  link misc: ../../../../../middleware/eiq/tensorflow-lite/lib/cm7/mdk/tensorflow-lite.lib --remove --predefine="-D__stack_size__=0x10000" --predefine="-D__heap_size__=0x800000" --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group source
    ../../../../../middleware/eiq/tensorflow-lite/examples/benchmark/: model.h benchmark_main.cpp benchmark_model.cpp benchmark_tflite_model.cpp
    ../../../../../middleware/eiq/common/: timer.c timer.h
  group doc
    ../../../../../middleware/eiq/tensorflow-lite/examples/benchmark/: model.tflite
    ../: readme.txt
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
    ./: retarget.c
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_gpio.h fsl_gpio.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group eiq/tensorflow-lite/tensorflow/core/public
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/core/public/: version.h session.h
  group eiq/tensorflow-lite/tensorflow/core/util
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/core/util/: stats_calculator.h stat_summarizer_options.h
  group eiq/tensorflow-lite/tensorflow/lite
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/: context.h type_to_tflitetype.h builtin_op_data.h builtin_ops.h op_resolver.h version.h stderr_reporter.h optional_debug_tools.h mutable_op_resolver.h util.h model_builder.h external_cpu_backend_context.h arena_planner.h context_util.h memory_planner.h graph_info.h minimal_logging.h configuration.h model.h simple_memory_arena.h tflite_with_xnnpack_optional.h allocation.h string_type.h string_util.h error_reporter.h interpreter.h interpreter_builder.h
  group eiq/tensorflow-lite/tensorflow/lite/c
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/c/: builtin_op_data.h c_api.h common.h c_api_internal.h
  group eiq/tensorflow-lite/tensorflow/lite/core
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/: macros.h subgraph.h
  group eiq/tensorflow-lite/tensorflow/lite/core/api
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/api/: op_resolver.h profiler.h flatbuffer_conversions.h error_reporter.h tensor_utils.h
  group eiq/tensorflow-lite/tensorflow/lite/experimental/resource
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/experimental/resource/: resource_base.h resource_variable.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/: register_ref.h eigen_support.h cpu_backend_threadpool.h padding.h cpu_backend_gemm_eigen.h cpu_backend_gemm_ruy.h kernel_util.h lstm_eval.h dequantize.h cpu_backend_gemm_gemmlowp.h register.h lstm_shared.h cpu_backend_gemm_custom_gemv.h fully_connected.h builtin_op_kernels.h custom_ops_register.h cpu_backend_context.h op_macros.h cpu_backend_gemm_params.h cpu_backend_gemm.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops/: depthwise_conv.h logistic.h mul.h dequantize.h fully_connected.h tanh.h conv.h log_softmax.h transpose_conv.h mean.h l2normalization.h add.h pooling.h
  group eiq/tensorflow-lite/tensorflow/lite/profiling
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/profiling/: platform_profiler.h profile_summary_formatter.h profiler.h profile_summarizer.h noop_profiler.h memory_info.h buffered_profiler.h profile_buffer.h time.h
  group eiq/tensorflow-lite/tensorflow/lite/schema
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/schema/: schema_generated.h
  group eiq/tensorflow-lite/tensorflow/lite/tools
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/tools/: command_line_flags.h logging.h tool_params.h
  group eiq/tensorflow-lite/tensorflow/lite/tools/benchmark
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/tools/benchmark/: benchmark_model.h benchmark_tflite_model.h benchmark_params.h profiling_listener.h benchmark_utils.h
  group eiq/tensorflow-lite/tensorflow/lite/tools/delegates
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/tools/delegates/: delegate_provider.h
  group eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/: idl.h reflection_generated.h hash.h minireflect.h util.h code_generators.h flexbuffers.h registry.h reflection.h base.h flatbuffers.h stl_emulation.h
  group eiq/tensorflow-lite/third_party/absl/base
    ../../../../../middleware/eiq/tensorflow-lite/third_party/absl/base/: attributes.h
  group eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint/: fixedpoint_msa.h fixedpoint.h fixedpoint_neon.h fixedpoint_sse.h
  group eiq/tensorflow-lite/third_party/gemmlowp/internal
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/internal/: output_sse.h detect_platform.h kernel.h multi_thread_gemm.h kernel_msa.h compute.h pack.h pack_neon.h kernel_reference.h simd_wrappers_sse.h simd_wrappers_common_neon_sse.h kernel_neon.h simd_wrappers.h output_msa.h output.h kernel_sse.h allocator.h common.h kernel_dsp.h block_params.h dispatch_gemm_shape.h platform.h pack_sse.h kernel_default.h simd_wrappers_neon.h output_neon.h single_thread_gemm.h simd_wrappers_msa.h unpack.h pack_msa.h
  group eiq/tensorflow-lite/third_party/gemmlowp/meta
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/meta/: multi_thread_gemm.h multi_thread_transform.h transform_kernels_arm_32.h streams.h streams_arm_32.h quantized_mul_kernels_arm_32.h legacy_single_thread_gemm.h multi_thread_common.h streams_arm_64.h legacy_multi_thread_common.h legacy_multi_thread_gemm.h transform_kernels.h quantized_mul_kernels.h base.h quantized_mul_kernels_arm_64.h legacy_operations_common.h transform_kernels_arm_64.h single_thread_transform.h legacy_multi_thread_gemv.h single_thread_gemm.h
  group eiq/tensorflow-lite/third_party/gemmlowp/profiling
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/profiling/: profiler.h instrumentation.h pthread_everywhere.h
  group eiq/tensorflow-lite/third_party/gemmlowp/public
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/public/: config.h bit_depth.h gemmlowp.h map.h output_stages.h
  group eiq/tensorflow-lite/third_party/ruy
    ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/: context.h side_pair.h thread_pool.h ctx_impl.h kernel.h size_util.h system_aligned_alloc.h ruy.h apply_multiplier.h matrix.h pack.h blocking_counter.h pack_x86.h kernel_arm.h trmul_params.h cpu_cache_params.h cpuinfo.h pack_common.h mat.h allocator.h common.h pack_arm.h prepacked_cache.h kernel_x86.h block_map.h opt_set.h ctx.h dispatch.h trmul.h have_built_path_for.h platform.h path.h kernel_common.h tune.h mul_params.h time.h check_macros.h context_get_ctx.h
  group eiq/tensorflow-lite/third_party/ruy/profiler
    ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/profiler/: treeview.h profiler.h instrumentation.h
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group startup
    ../../../../../devices/MIMXRT1062/arm/: startup_MIMXRT1062.S
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
target tensorflow_lite_benchmark flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: tensorflow_lite_benchmark.out
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, __CLK_TCK=1000000, CPU_MIMXRT1062DVL6A, SDK_DEBUGCONSOLE_UART, FLATBUFFERS_LITTLEENDIAN, GEMMLOWP_MCU, TFLITE_MCU, ARM_MATH_CM7, __FPU_PRESENT=1, SDK_I2C_BASED_COMPONENT_USED=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: as above
  link misc: as above
