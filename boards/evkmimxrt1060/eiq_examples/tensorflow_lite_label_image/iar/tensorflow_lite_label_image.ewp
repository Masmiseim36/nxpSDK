# IAR project tensorflow_lite_label_image.ewp, settings and files
configuration flexspi_nor_sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1062DVL6A; SDK_DEBUGCONSOLE_UART; FLATBUFFERS_LITTLEENDIAN; TFLITE_MCU; ARM_MATH_CM7; __FPU_PRESENT=1; SDK_I2C_BASED_COMPONENT_USED=1; SDK_I2C_BASED_COMPONENT_USED=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa093,Pe111,Pe549,Pe550,Pe186,Pe611
  ICCARM.IExtraOptions: --enable_restrict  --diag_suppress Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../middleware/eiq/tensorflow-lite/examples/label_image; ../../..; ../../../../../middleware/eiq/tensorflow-lite/examples/label_image/evkmimxrt1060; ..; ../../../../../middleware/eiq/tensorflow-lite/examples/common/source; ../../../../../components/video/camera/device; ../../../../../components/video/camera/receiver; ../../../../../components/video/camera/device/sccb; ../../../../../components/video/camera/device/ov7725; ../../../../../components/video/camera/device/mt9m114; ../../../../../components/video/camera; ../../../../../components/video/camera/receiver/csi; ../../../../../devices/MIMXRT1062/drivers; ../../../../../components/video; ../../../../../components/video/i2c; ../../../../../components/video/display/dc; ../../../../../components/video/display/dc/elcdif; ../../../../../middleware/eiq/tensorflow-lite; ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include; ../../../../../middleware/eiq/tensorflow-lite/third_party; ../../../../../components/lists; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../devices/MIMXRT1062; ../../../../../devices/MIMXRT1062/xip; ../../../xip; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../devices/MIMXRT1062/utilities/debug_console; ../../../../../devices/MIMXRT1062/utilities
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: tensorflow_lite_label_image.out
  ILINK.IlinkConfigDefines: __stack_size__=0x10000; __heap_size__=0x800000
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor_sdram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/eiq/tensorflow-lite/lib/cm7/iar/libtensorflow-lite.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1062DVL6A; SDK_DEBUGCONSOLE_UART; FLATBUFFERS_LITTLEENDIAN; TFLITE_MCU; ARM_MATH_CM7; __FPU_PRESENT=1; SDK_I2C_BASED_COMPONENT_USED=1; SDK_I2C_BASED_COMPONENT_USED=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../../../../../middleware/eiq/tensorflow-lite/examples/label_image/: bitmap_helpers.h bitmap_helpers_impl.h bitmap_helpers.cpp labels.h label_image.cpp label_image.h mobilenet_v1_0.25_128_quant_model.h stopwatch_image.h
    ../../../../../middleware/eiq/tensorflow-lite/examples/common/source/: get_top_n.h get_top_n_impl.h timer.c timer.h image.c image.h
  group doc
    ../../../../../middleware/eiq/tensorflow-lite/examples/label_image/: labels.txt mobilenet_v1_0.25_128_quant.tflite stopwatch.bmp
    ../: readme.txt
  group board
    ../../../: display_support.h display_support.c camera_support.h camera_support.c
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
    ./: retarget.c
  group video
    ../../../../../components/video/camera/device/: fsl_camera_device.h
    ../../../../../components/video/camera/receiver/: fsl_camera_receiver.h
    ../../../../../components/video/camera/device/sccb/: fsl_sccb.c fsl_sccb.h
    ../../../../../components/video/camera/device/ov7725/: fsl_ov7725.c fsl_ov7725.h
    ../../../../../components/video/camera/device/mt9m114/: fsl_mt9m114.c fsl_mt9m114.h
    ../../../../../components/video/camera/: fsl_camera.h
    ../../../../../components/video/camera/receiver/csi/: fsl_csi_camera_adapter.c fsl_csi_camera_adapter.h
    ../../../../../components/video/: fsl_video_common.c fsl_video_common.h
    ../../../../../components/video/i2c/: fsl_video_i2c.c fsl_video_i2c.h
    ../../../../../components/video/display/dc/: fsl_dc_fb.h
    ../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.c fsl_dc_fb_elcdif.h
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_csi.c fsl_csi.h fsl_elcdif.c fsl_elcdif.h fsl_pxp.c fsl_pxp.h fsl_gpio.c fsl_gpio.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_clock.c fsl_clock.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h
  group tensorflow-lite/tensorflow/core/public
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/core/public/: session.h version.h
  group tensorflow-lite/tensorflow/core/util
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/core/util/: stat_summarizer_options.h stats_calculator.h
  group tensorflow-lite/tensorflow/lite
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/: allocation.h arena_planner.h builtin_op_data.h builtin_ops.h context.h context_util.h error_reporter.h external_cpu_backend_context.h graph_info.h interpreter.h memory_planner.h minimal_logging.h model.h mutable_op_resolver.h op_resolver.h optional_debug_tools.h simple_memory_arena.h stderr_reporter.h string_type.h string_util.h util.h version.h
  group tensorflow-lite/tensorflow/lite/c
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/c/: builtin_op_data.h c_api_internal.h
  group tensorflow-lite/tensorflow/lite/core
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/: subgraph.h
  group tensorflow-lite/tensorflow/lite/core/api
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/api/: error_reporter.h flatbuffer_conversions.h op_resolver.h profiler.h tensor_utils.h
  group tensorflow-lite/tensorflow/lite/experimental/resource_variable
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/experimental/resource_variable/: resource_variable.h
  group tensorflow-lite/tensorflow/lite/experimental/ruy
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/experimental/ruy/: ruy.h
  group tensorflow-lite/tensorflow/lite/kernels
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/: activation_functor.h builtin_op_kernels.h cpu_backend_context.h cpu_backend_gemm.h cpu_backend_gemm_custom_gemv.h cpu_backend_gemm_eigen.h cpu_backend_gemm_gemmlowp.h cpu_backend_gemm_params.h cpu_backend_gemm_ruy.h cpu_backend_threadpool.h custom_ops_register.h eigen_support.h fully_connected.h kernel_util.h lstm_eval.h op_macros.h padding.h register.h register_ref.h
  group tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops/: add.h conv.h depthwise_conv.h dequantize.h fully_connected.h l2normalization.h log_softmax.h logistic.h mean.h mul.h pooling.h softmax.h tanh.h
  group tensorflow-lite/tensorflow/lite/profiling
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/profiling/: buffered_profiler.h memory_info.h noop_profiler.h profile_buffer.h profile_summarizer.h profiler.h time.h
  group tensorflow-lite/tensorflow/lite/schema
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/schema/: schema_generated.h
  group tensorflow-lite/tensorflow/lite/tools
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/tools/: command_line_flags.h
  group tensorflow-lite/tensorflow/lite/tools/benchmark
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/tools/benchmark/: benchmark_model.h benchmark_params.h benchmark_tflite_model.h benchmark_utils.h logging.h
  group tensorflow-lite/third_party/absl/base
    ../../../../../middleware/eiq/tensorflow-lite/third_party/absl/base/: attributes.h
  group tensorflow-lite/third_party/flatbuffers/include/flatbuffers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/: base.h code_generators.h flatbuffers.h flexbuffers.h hash.h idl.h minireflect.h reflection.h reflection_generated.h registry.h stl_emulation.h util.h
  group component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group component/uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group device
    ../../../../../devices/MIMXRT1062/: MIMXRT1062.h MIMXRT1062_features.h fsl_device_registers.h system_MIMXRT1062.c system_MIMXRT1062.h
  group startup
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
