# IAR project tensorflow_lite_lib.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1062DVL6A; EIGEN_MPL2_ONLY; EIGEN_STACK_ALLOCATION_LIMIT=16384; FARMHASH_MCU; FARMHASH_LITTLE_ENDIAN; FARMHASH_NO_BUILTIN_EXPECT; FLATBUFFERS_LITTLEENDIAN; GEMMLOWP_MCU; RUY_MCU; TFLITE_MCU
  ICCARM.CCDiagSuppress: Pa084,Pa089,Pa093,Pa118,Pa131,Pe111,Pe174,Pe177,Pe186,Pe191,Pe393,Pe550,Pe611,Pe815,Pe940,Pe1444
  ICCARM.CCIncludePath2: ../../../../../middleware/eiq/tensorflow-lite; ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen; ../../../../../middleware/eiq/tensorflow-lite/third_party/farmhash; ../../../../../middleware/eiq/tensorflow-lite/third_party/fft2d; ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include; ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp; ../../../../../middleware/eiq/tensorflow-lite/third_party
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: psp_arm.out
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1062DVL6A; EIGEN_MPL2_ONLY; EIGEN_STACK_ALLOCATION_LIMIT=16384; FARMHASH_MCU; FARMHASH_LITTLE_ENDIAN; FARMHASH_NO_BUILTIN_EXPECT; FLATBUFFERS_LITTLEENDIAN; GEMMLOWP_MCU; RUY_MCU; TFLITE_MCU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: libgeneric.out
  group doc
    ../: readme.txt
  group eiq/tensorflow-lite
    ../../../../../middleware/eiq/tensorflow-lite/: LICENSE AUTHORS readme.txt ChangeLogKSDK.txt
  group eiq/tensorflow-lite/tensorflow/lite
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/: context.h type_to_tflitetype.h builtin_op_data.h builtin_ops.h op_resolver.h version.h stderr_reporter.h optional_debug_tools.h mutable_op_resolver.h util.h model_builder.h external_cpu_backend_context.h arena_planner.h context_util.h memory_planner.h graph_info.h minimal_logging.h configuration.h model.h simple_memory_arena.h tflite_with_xnnpack_optional.h allocation.h string_type.h string_util.h error_reporter.h interpreter.h interpreter_builder.h mmap_allocation_disabled.cpp graph_info.cpp arena_planner.cpp minimal_logging_default.cpp allocation.cpp string_util.cpp interpreter.cpp tflite_with_xnnpack_optional.cpp util.cpp stderr_reporter.cpp optional_debug_tools.cpp interpreter_builder.cpp minimal_logging.cpp model_builder.cpp external_cpu_backend_context.cpp mutable_op_resolver.cpp simple_memory_arena.cpp configuration.cpp
  group eiq/tensorflow-lite/tensorflow/lite/experimental/resource
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/experimental/resource/: resource_base.h resource_variable.h resource_variable.cpp
  group eiq/tensorflow-lite/tensorflow/lite/delegates
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/delegates/: interpreter_utils.h utils.h status.h utils.cpp interpreter_utils.cpp
  group eiq/tensorflow-lite/tensorflow/lite/delegates/utils
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/delegates/utils/: simple_delegate.h simple_delegate.cpp
  group eiq/tensorflow-lite/tensorflow/lite/kernels
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/: register_ref.h eigen_support.h cpu_backend_threadpool.h padding.h cpu_backend_gemm_eigen.h cpu_backend_gemm_ruy.h kernel_util.h lstm_eval.h dequantize.h cpu_backend_gemm_gemmlowp.h register.h lstm_shared.h cpu_backend_gemm_custom_gemv.h fully_connected.h builtin_op_kernels.h custom_ops_register.h cpu_backend_context.h op_macros.h cpu_backend_gemm_params.h cpu_backend_gemm.h space_to_batch_nd.cpp mfcc.cpp conv.cpp pow.cpp add.cpp exp.cpp gather_nd.cpp unidirectional_sequence_rnn.cpp zeros_like.cpp sub.cpp rank.cpp split_v.cpp unpack.cpp reduce.cpp elementwise.cpp lsh_projection.cpp floor_div.cpp fake_quant.cpp where.cpp batch_to_space_nd.cpp unidirectional_sequence_lstm.cpp embedding_lookup.cpp logical.cpp bidirectional_sequence_lstm.cpp add_n.cpp tile.cpp round.cpp eigen_support.cpp unique.cpp neg.cpp matrix_set_diag.cpp depth_to_space.cpp numeric_verify.cpp sparse_to_dense.cpp comparisons.cpp floor_mod.cpp space_to_depth.cpp bidirectional_sequence_rnn.cpp basic_rnn.cpp lstm.cpp pack.cpp concatenation.cpp strided_slice.cpp register_ref.cpp audio_spectrogram.cpp reverse.cpp scatter_nd.cpp topk_v2.cpp batch_matmul.cpp floor.cpp l2norm.cpp cpu_backend_gemm_eigen.cpp mirror_pad.cpp arg_min_max.cpp assign_variable.cpp one_hot.cpp split.cpp select.cpp svdf.cpp shape.cpp fully_connected.cpp rfft2d.cpp local_response_norm.cpp dequantize.cpp cpu_backend_context.cpp reshape.cpp depthwise_conv.cpp kernel_util.cpp expand_dims.cpp mul.cpp transpose_conv.cpp quantize.cpp detection_postprocess.cpp pad.cpp non_max_suppression.cpp lstm_eval.cpp pooling.cpp segment_sum.cpp ceil.cpp reverse_sequence.cpp register.cpp skip_gram.cpp range.cpp if.cpp squared_difference.cpp cast.cpp resize_bilinear.cpp squeeze.cpp matrix_diag.cpp fill.cpp transpose.cpp gather.cpp slice.cpp embedding_lookup_sparse.cpp resize_nearest_neighbor.cpp hashtable_lookup.cpp div.cpp maximum_minimum.cpp while.cpp densify.cpp activations.cpp
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/: compatibility.h mfcc_dct.h tensor.h min.h transpose_utils.h quantization_util.h kernel_utils.h strided_slice_logic.h mfcc_mel_filterbank.h spectrogram.h tensor_ctypes.h cppmath.h common.h legacy_types.h max.h mfcc.h types.h tensor_utils.h mfcc_mel_filterbank.cpp spectrogram.cpp mfcc_dct.cpp kernel_utils.cpp quantization_util.cpp tensor_utils.cpp mfcc_.cpp transpose_utils.cpp
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized/: eigen_tensor_reduced_instantiations_oss.h depthwiseconv_uint8.h im2col_utils.h neon_tensor_utils_impl.h cpu_check.h neon_tensor_utils.h batch_matmul.h neon_check.h depthwiseconv_3x3_filter_common.h multithreaded_conv.h sse_tensor_utils.h depthwiseconv_float.h eigen_spatial_convolutions.h depthwiseconv_uint8_3x3_filter.h depthwiseconv_uint8_transitional.h eigen_tensor_reduced_instantiations_google.h sse_check.h depthwiseconv_multithread.h legacy_optimized_ops.h optimized_ops.h sse_tensor_utils_impl.h cpu_check.cpp sse_tensor_utils.cpp neon_tensor_utils.cpp
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized/integer_ops
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized/integer_ops/: depthwise_conv.h depthwise_conv_hybrid_3x3_filter.h mul.h fully_connected.h conv.h depthwise_conv_hybrid.h transpose_conv.h mean.h add.h depthwise_conv_3x3_filter.h pooling.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized/sparse_ops
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized/sparse_ops/: fully_connected.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/: depthwiseconv_uint8.h arg_min_max.h floor.h densify.h softmax.h portable_tensor_utils_impl.h round.h requantize.h process_broadcast_shapes.h reduce.h resize_nearest_neighbor.h concatenation.h batch_matmul.h reference_ops.h ceil.h logistic.h mul.h dequantize.h depthwiseconv_float.h sub.h prelu.h legacy_reference_ops.h strided_slice.h fully_connected.h tanh.h conv.h comparisons.h pad.h quantize.h l2normalization.h add.h maximum_minimum.h neg.h binary_function.h svdf.h non_max_suppression.h portable_tensor_utils.h pooling.h portable_tensor_utils.cpp
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops/: depthwise_conv.h logistic.h mul.h dequantize.h fully_connected.h tanh.h conv.h log_softmax.h transpose_conv.h mean.h l2normalization.h add.h pooling.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/sparse_ops
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/sparse_ops/: fully_connected.h
  group eiq/tensorflow-lite/tensorflow/lite/nnapi
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/nnapi/: NeuralNetworksShim.h
  group eiq/tensorflow-lite/tensorflow/lite/profiling
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/profiling/: platform_profiler.h profile_summary_formatter.h profiler.h profile_summarizer.h noop_profiler.h memory_info.h buffered_profiler.h profile_buffer.h time.h platform_profiler.cpp profile_summarizer.cpp time.cpp memory_info.cpp profile_summary_formatter.cpp
  group eiq/tensorflow-lite/tensorflow/lite/schema
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/schema/: schema_generated.h
  group eiq/tensorflow-lite/tensorflow/lite/c
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/c/: builtin_op_data.h c_api.h common.h c_api_internal.h common.c c_api.cpp
  group eiq/tensorflow-lite/tensorflow/lite/core
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/: macros.h subgraph.h subgraph.cpp
  group eiq/tensorflow-lite/tensorflow/lite/core/api
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/api/: op_resolver.h profiler.h flatbuffer_conversions.h error_reporter.h tensor_utils.h op_resolver.cpp flatbuffer_conversions.cpp tensor_utils_.cpp error_reporter.cpp
  group eiq/tensorflow-lite/tensorflow/lite/tools
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/tools/: command_line_flags.h logging.h tool_params.h tool_params.cpp command_line_flags.cpp
  group eiq/tensorflow-lite/tensorflow/lite/tools/benchmark
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/tools/benchmark/: profiling_listener.cpp benchmark_utils.cpp benchmark_model.h benchmark_tflite_model.h benchmark_params.h profiling_listener.h benchmark_utils.h
  group eiq/tensorflow-lite/tensorflow/lite/tools/delegates
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/tools/delegates/: delegate_provider.h default_execution_provider.cpp
  group eiq/tensorflow-lite/tensorflow/lite/tools/optimize/sparsity
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/tools/optimize/sparsity/: format_converter.cpp format_converter.h
  group eiq/tensorflow-lite/tensorflow/core/util
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/core/util/: stats_calculator.h stat_summarizer_options.h stats_calculator.cpp
  group eiq/tensorflow-lite/tensorflow/core/public
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/core/public/: version.h session.h
  group eiq/tensorflow-lite/third_party/eigen
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/: COPYING.BSD COPYING.LGPL README.md COPYING.MINPACK COPYING.MPL2 COPYING.README
  group eiq/tensorflow-lite/third_party/eigen/Eigen
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/: SparseCholesky Eigen Householder SparseLU PardisoSupport Cholesky SVD SPQRSupport CholmodSupport Dense StdVector LU IterativeLinearSolvers StdList SparseCore MetisSupport SparseQR StdDeque SuperLUSupport Geometry Jacobi Core QR QtAlignedMalloc OrderingMethods PaStiXSupport KLUSupport UmfPackSupport Eigenvalues Sparse
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Cholesky
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Cholesky/: LLT.h LDLT.h LLT_LAPACKE.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/CholmodSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/CholmodSupport/: CholmodSupport.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/: VectorBlock.h SolverBase.h MatrixBase.h Product.h Map.h StableNorm.h SelfCwiseBinaryOp.h Ref.h Assign_MKL.h AssignEvaluator.h MathFunctionsImpl.h Select.h MathFunctions.h GeneralProduct.h Block.h NumTraits.h IndexedView.h GenericPacketMath.h DenseBase.h NoAlias.h DenseStorage.h ProductEvaluators.h ReturnByValue.h PartialReduxEvaluator.h CoreIterators.h DiagonalProduct.h Matrix.h PlainObjectBase.h Visitor.h ConditionEstimator.h CwiseTernaryOp.h StlIterators.h GlobalFunctions.h PermutationMatrix.h CoreEvaluators.h BandMatrix.h DenseCoeffsBase.h CwiseUnaryView.h Reverse.h BooleanRedux.h CwiseNullaryOp.h MapBase.h SolveTriangular.h Stride.h SelfAdjointView.h Inverse.h Random.h Assign.h ArrayWrapper.h ForceAlignedAccess.h Dot.h CommaInitializer.h Redux.h CwiseUnaryOp.h Swap.h Transpose.h TriangularMatrix.h Solve.h Transpositions.h CwiseBinaryOp.h Array.h Fuzzy.h ArrayBase.h Diagonal.h Reshaped.h EigenBase.h VectorwiseOp.h IO.h NestByValue.h ArithmeticSequence.h DiagonalMatrix.h Replicate.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/AltiVec
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/AltiVec/: MathFunctions.h PacketMath.h Complex.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/AVX
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/AVX/: TypeCasting.h MathFunctions.h PacketMath.h Complex.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/AVX512
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/AVX512/: TypeCasting.h MathFunctions.h PacketMath.h Complex.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/CUDA
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/CUDA/: Complex.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/Default
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/Default/: GenericPacketMathFunctions.h TypeCasting.h Half.h ConjHelper.h BFloat16.h Settings.h GenericPacketMathFunctionsFwd.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/GPU
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/GPU/: TypeCasting.h MathFunctions.h PacketMath.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/MSA
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/MSA/: MathFunctions.h PacketMath.h Complex.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/NEON
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/NEON/: TypeCasting.h MathFunctions.h PacketMath.h Complex.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/SSE
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/SSE/: TypeCasting.h MathFunctions.h PacketMath.h Complex.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/SYCL
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/SYCL/: TypeCasting.h MathFunctions.h InteropHeaders.h PacketMath.h SyclMemoryModel.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/ZVector
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/ZVector/: MathFunctions.h PacketMath.h Complex.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/functors
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/functors/: AssignmentFunctors.h UnaryFunctors.h TernaryFunctors.h BinaryFunctors.h NullaryFunctors.h StlFunctors.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/products
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/products/: TriangularSolverMatrix_BLAS.h GeneralMatrixMatrixTriangular_BLAS.h Parallelizer.h SelfadjointRank2Update.h GeneralMatrixVector.h SelfadjointMatrixVector.h SelfadjointMatrixVector_BLAS.h TriangularSolverMatrix.h GeneralMatrixMatrix_BLAS.h TriangularMatrixMatrix_BLAS.h GeneralMatrixVector_BLAS.h SelfadjointMatrixMatrix_BLAS.h TriangularMatrixVector.h GeneralBlockPanelKernel.h SelfadjointMatrixMatrix.h SelfadjointProduct.h TriangularSolverVector.h GeneralMatrixMatrix.h TriangularMatrixVector_BLAS.h GeneralMatrixMatrixTriangular.h TriangularMatrixMatrix.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/util
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/util/: StaticAssert.h Constants.h ReenableStupidWarnings.h NonMPL2.h Meta.h XprHelper.h DisableStupidWarnings.h ForwardDeclarations.h MKL_support.h ConfigureVectorization.h Macros.h Memory.h BlasUtil.h SymbolicIndex.h IndexedViewHelper.h IntegralConstant.h ReshapedHelper.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Eigenvalues
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Eigenvalues/: ComplexEigenSolver.h GeneralizedEigenSolver.h ComplexSchur_LAPACKE.h RealSchur.h MatrixBaseEigenvalues.h Tridiagonalization.h SelfAdjointEigenSolver_LAPACKE.h RealSchur_LAPACKE.h EigenSolver.h ComplexSchur.h GeneralizedSelfAdjointEigenSolver.h RealQZ.h SelfAdjointEigenSolver.h HessenbergDecomposition.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Geometry
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Geometry/: Hyperplane.h AlignedBox.h ParametrizedLine.h Umeyama.h AngleAxis.h Quaternion.h Homogeneous.h EulerAngles.h Rotation2D.h Scaling.h RotationBase.h Translation.h Transform.h OrthoMethods.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Geometry/arch
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Geometry/arch/: Geometry_SSE.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Householder
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Householder/: HouseholderSequence.h BlockHouseholder.h Householder.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/IterativeLinearSolvers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/IterativeLinearSolvers/: IncompleteCholesky.h SolveWithGuess.h IterativeSolverBase.h BiCGSTAB.h BasicPreconditioners.h LeastSquareConjugateGradient.h ConjugateGradient.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Jacobi
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Jacobi/: Jacobi.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/KLUSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/KLUSupport/: KLUSupport.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/LU
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/LU/: InverseImpl.h PartialPivLU_LAPACKE.h FullPivLU.h Determinant.h PartialPivLU.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/LU/arch
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/LU/arch/: Inverse_SSE.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/MetisSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/MetisSupport/: MetisSupport.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/misc
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/misc/: lapack.h blas.h RealSvd2x2.h lapacke.h Image.h Kernel.h lapacke_mangling.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/OrderingMethods
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/OrderingMethods/: Eigen_Colamd.h Ordering.h Amd.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/PardisoSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/PardisoSupport/: PardisoSupport.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/PaStiXSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/PaStiXSupport/: PaStiXSupport.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/plugins
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/plugins/: ArrayCwiseBinaryOps.h MatrixCwiseBinaryOps.h CommonCwiseBinaryOps.h IndexedViewMethods.h ReshapedMethods.h BlockMethods.h CommonCwiseUnaryOps.h ArrayCwiseUnaryOps.h MatrixCwiseUnaryOps.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/QR
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/QR/: ColPivHouseholderQR.h CompleteOrthogonalDecomposition.h HouseholderQR.h HouseholderQR_LAPACKE.h FullPivHouseholderQR.h ColPivHouseholderQR_LAPACKE.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/SparseCholesky
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/SparseCholesky/: SimplicialCholesky_impl.h SimplicialCholesky.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/SparseCore
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/SparseCore/: SparseProduct.h SparseTranspose.h SparseTriangularView.h SparseCompressedBase.h SparsePermutation.h ConservativeSparseSparseProduct.h SparseVector.h SparseSelfAdjointView.h SparseFuzzy.h SparseCwiseBinaryOp.h SparseDenseProduct.h TriangularSolver.h SparseMatrixBase.h SparseView.h SparseUtil.h SparseMatrix.h AmbiVector.h SparseDot.h MappedSparseMatrix.h SparseColEtree.h SparseRef.h SparseRedux.h SparseMap.h SparseSolverBase.h SparseDiagonalProduct.h SparseAssign.h SparseSparseProductWithPruning.h SparseCwiseUnaryOp.h CompressedStorage.h SparseBlock.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/SparseLU
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/SparseLU/: SparseLU_kernel_bmod.h SparseLU_column_dfs.h SparseLU_relax_snode.h SparseLU_Structs.h SparseLU_Utils.h SparseLU_Memory.h SparseLU.h SparseLU_heap_relax_snode.h SparseLU_panel_dfs.h SparseLU_column_bmod.h SparseLU_panel_bmod.h SparseLU_SupernodalMatrix.h SparseLU_copy_to_ucol.h SparseLU_pivotL.h SparseLU_gemm_kernel.h SparseLUImpl.h SparseLU_pruneL.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/SparseQR
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/SparseQR/: SparseQR.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/SPQRSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/SPQRSupport/: SuiteSparseQRSupport.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/StlSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/StlSupport/: StdDeque.h StdVector.h StdList.h details.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/SuperLUSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/SuperLUSupport/: SuperLUSupport.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/SVD
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/SVD/: JacobiSVD.h UpperBidiagonalization.h JacobiSVD_LAPACKE.h BDCSVD.h SVDBase.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/UmfPackSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/UmfPackSupport/: UmfPackSupport.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/: KroneckerProduct MatrixFunctions SparseExtra AutoDiff ArpackSupport Skyline EulerAngles LevenbergMarquardt Splines NumericalDiff Polynomials OpenGLSupport SpecialFunctions AlignedVector3 FFT NonLinearOptimization AdolcForward MPRealSupport MoreVectorization IterativeSolvers BVH
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/: TensorSymmetry Tensor ThreadPool
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/Tensor
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/Tensor/: TensorContractionMapper.h TensorContraction.h TensorImagePatch.h TensorDimensionList.h TensorCustomOp.h TensorArgMax.h TensorDeviceDefault.h TensorGlobalFunctions.h TensorExpr.h TensorAssign.h TensorIO.h TensorFunctors.h TensorMap.h TensorForcedEval.h TensorRandom.h TensorLayoutSwap.h TensorGpuHipCudaDefines.h Tensor.h TensorScan.h TensorUInt128.h TensorRef.h TensorInitializer.h TensorContractionCuda.h TensorReverse.h TensorTraits.h TensorPadding.h TensorConversion.h TensorChipping.h TensorIntDiv.h TensorGenerator.h TensorFFT.h TensorReductionGpu.h TensorDevice.h TensorDeviceThreadPool.h TensorPatch.h TensorDimensions.h TensorIndexList.h TensorDeviceSycl.h TensorVolumePatch.h TensorContractionBlocking.h TensorReduction.h TensorInflation.h TensorMorphing.h TensorEvalTo.h TensorBroadcasting.h TensorEvaluator.h TensorExecutor.h TensorForwardDeclarations.h TensorContractionGpu.h TensorScanSycl.h TensorStriding.h TensorConvolutionSycl.h TensorStorage.h TensorShuffling.h TensorReductionCuda.h TensorDeviceGpu.h TensorDeviceCuda.h TensorCostModel.h TensorBlockV2.h TensorGpuHipCudaUndefines.h TensorTrace.h TensorMacros.h TensorContractionSycl.h TensorReductionSycl.h TensorMeta.h TensorContractionThreadPool.h TensorBase.h TensorBlock.h TensorFixedSize.h TensorConvolution.h TensorConcatenation.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/TensorSymmetry
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/TensorSymmetry/: Symmetry.h DynamicSymmetry.h StaticSymmetry.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/TensorSymmetry/util
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/TensorSymmetry/util/: TemplateGroupTheory.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/ThreadPool
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/ThreadPool/: ThreadYield.h ThreadLocal.h ThreadPoolInterface.h NonBlockingThreadPool.h ThreadCancel.h ThreadEnvironment.h Barrier.h EventCount.h RunQueue.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/util
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/util/: MaxSizeVector.h CXX11Workarounds.h EmulateArray.h CXX11Meta.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/AutoDiff
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/AutoDiff/: AutoDiffScalar.h AutoDiffJacobian.h AutoDiffVector.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/BVH
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/BVH/: BVAlgorithms.h KdBVH.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/EulerAngles
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/EulerAngles/: EulerSystem.h EulerAngles.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/FFT
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/FFT/: ei_fftw_impl.h ei_kissfft_impl.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/IterativeSolvers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/IterativeSolvers/: IncompleteLU.h DGMRES.h MINRES.h Scaling.h GMRES.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/KroneckerProduct
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/KroneckerProduct/: KroneckerTensorProduct.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/LevenbergMarquardt
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/LevenbergMarquardt/: LMonestep.h LMpar.h LMcovar.h LevenbergMarquardt.h LMqrsolv.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/MatrixFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/MatrixFunctions/: MatrixExponential.h MatrixFunction.h MatrixSquareRoot.h MatrixLogarithm.h StemFunction.h MatrixPower.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/MoreVectorization
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/MoreVectorization/: MathFunctions.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/NonLinearOptimization
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/NonLinearOptimization/: fdjac1.h r1mpyq.h covar.h rwupdt.h chkder.h lmpar.h HybridNonLinearSolver.h LevenbergMarquardt.h qrsolv.h dogleg.h r1updt.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/NumericalDiff
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/NumericalDiff/: NumericalDiff.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/Polynomials
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/Polynomials/: PolynomialUtils.h PolynomialSolver.h Companion.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/Skyline
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/Skyline/: SkylineInplaceLU.h SkylineUtil.h SkylineMatrixBase.h SkylineStorage.h SkylineProduct.h SkylineMatrix.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/SparseExtra
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/SparseExtra/: MarketIO.h BlockSparseMatrix.h DynamicSparseMatrix.h RandomSetter.h MatrixMarketIterator.h BlockOfDynamicSparseMatrix.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/SpecialFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/SpecialFunctions/: SpecialFunctionsPacketMath.h BesselFunctionsArrayAPI.h BesselFunctionsHalf.h SpecialFunctionsBFloat16.h BesselFunctionsBFloat16.h SpecialFunctionsImpl.h HipVectorCompatibility.h BesselFunctionsImpl.h SpecialFunctionsFunctors.h BesselFunctionsPacketMath.h SpecialFunctionsArrayAPI.h SpecialFunctionsHalf.h BesselFunctionsFunctors.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/Splines
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/Splines/: SplineFwd.h Spline.h SplineFitting.h
  group eiq/tensorflow-lite/third_party/eigen3
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen3/: LICENSE
  group eiq/tensorflow-lite/third_party/eigen3/Eigen
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen3/Eigen/: SparseCholesky Cholesky SVD LU SparseCore Core QR OrderingMethods Eigenvalues
  group eiq/tensorflow-lite/third_party/eigen3/unsupported/Eigen
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen3/unsupported/Eigen/: MatrixFunctions SpecialFunctions
  group eiq/tensorflow-lite/third_party/eigen3/unsupported/Eigen/CXX11
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen3/unsupported/Eigen/CXX11/: FixedPoint Tensor ThreadPool
  group eiq/tensorflow-lite/third_party/eigen3/unsupported/Eigen/CXX11/src/FixedPoint
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen3/unsupported/Eigen/CXX11/src/FixedPoint/: PacketMathAVX2.h MatMatProduct.h MatVecProduct.h TypeCastingAVX512.h TypeCastingAVX2.h FixedPointTypes.h MatMatProductAVX2.h MatMatProductNEON.h PacketMathAVX512.h
  group eiq/tensorflow-lite/third_party/farmhash
    ../../../../../middleware/eiq/tensorflow-lite/third_party/farmhash/: COPYING farmhash.cpp farmhash.h
  group eiq/tensorflow-lite/third_party/fft2d
    ../../../../../middleware/eiq/tensorflow-lite/third_party/fft2d/: fftsg.c fft2d.h fft.h readme.txt LICENSE
  group eiq/tensorflow-lite/third_party/flatbuffers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/: readme.md LICENSE.txt
  group eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/: idl.h reflection_generated.h hash.h minireflect.h util.h code_generators.h flexbuffers.h registry.h reflection.h base.h flatbuffers.h stl_emulation.h
  group eiq/tensorflow-lite/third_party/gemmlowp
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/: LICENSE AUTHORS CONTRIBUTORS README.md
  group eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint/: fixedpoint_msa.h fixedpoint.h fixedpoint_neon.h fixedpoint_sse.h
  group eiq/tensorflow-lite/third_party/gemmlowp/internal
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/internal/: output_sse.h detect_platform.h kernel.h multi_thread_gemm.h kernel_msa.h compute.h pack.h pack_neon.h kernel_reference.h simd_wrappers_sse.h simd_wrappers_common_neon_sse.h kernel_neon.h simd_wrappers.h output_msa.h output.h kernel_sse.h allocator.h common.h kernel_dsp.h block_params.h dispatch_gemm_shape.h platform.h pack_sse.h kernel_default.h simd_wrappers_neon.h output_neon.h single_thread_gemm.h simd_wrappers_msa.h unpack.h pack_msa.h
  group eiq/tensorflow-lite/third_party/gemmlowp/meta
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/meta/: multi_thread_gemm.h multi_thread_transform.h transform_kernels_arm_32.h streams.h streams_arm_32.h quantized_mul_kernels_arm_32.h legacy_single_thread_gemm.h multi_thread_common.h streams_arm_64.h legacy_multi_thread_common.h legacy_multi_thread_gemm.h transform_kernels.h quantized_mul_kernels.h base.h quantized_mul_kernels_arm_64.h legacy_operations_common.h transform_kernels_arm_64.h single_thread_transform.h legacy_multi_thread_gemv.h single_thread_gemm.h
  group eiq/tensorflow-lite/third_party/gemmlowp/profiling
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/profiling/: profiler.h instrumentation.h pthread_everywhere.h
  group eiq/tensorflow-lite/third_party/gemmlowp/public
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/public/: config.h bit_depth.h gemmlowp.h map.h output_stages.h config.cpp
  group eiq/tensorflow-lite/third_party/absl
    ../../../../../middleware/eiq/tensorflow-lite/third_party/absl/: LICENSE
  group eiq/tensorflow-lite/third_party/absl/base
    ../../../../../middleware/eiq/tensorflow-lite/third_party/absl/base/: attributes.h config.h macros.h policy_checks.h optimization.h port.h
  group eiq/tensorflow-lite/third_party/absl/memory
    ../../../../../middleware/eiq/tensorflow-lite/third_party/absl/memory/: memory.h
  group eiq/tensorflow-lite/third_party/absl/meta
    ../../../../../middleware/eiq/tensorflow-lite/third_party/absl/meta/: type_traits.h
  group eiq/tensorflow-lite/third_party/ruy
    ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/: LICENSE context.h side_pair.h thread_pool.h ctx_impl.h kernel.h size_util.h system_aligned_alloc.h ruy.h apply_multiplier.h matrix.h pack.h blocking_counter.h pack_x86.h kernel_arm.h trmul_params.h cpu_cache_params.h cpuinfo.h pack_common.h mat.h allocator.h common.h pack_arm.h prepacked_cache.h kernel_x86.h block_map.h opt_set.h ctx.h dispatch.h trmul.h have_built_path_for.h platform.h path.h kernel_common.h tune.h mul_params.h time.h check_macros.h context_get_ctx.h block_map.cpp prepacked_cache.cpp tune.cpp context_get_ctx.cpp have_built_path_for_avx2.cpp kernel_avx512.cpp cpuinfo.cpp have_built_path_for_sse42.cpp ctx.cpp trmul.cpp allocator.cpp thread_pool.cpp pack_avx2.cpp kernel_arm32.cpp context.cpp kernel_avx2.cpp kernel_avxvnni.cpp system_aligned_alloc.cpp pack_avxvnni.cpp pack_arm.cpp kernel_arm64.cpp pack_avx512.cpp apply_multiplier.cpp pack_sse42.cpp blocking_counter.cpp have_built_path_for_avxvnni.cpp kernel_sse42.cpp have_built_path_for_avx512.cpp
  group eiq/tensorflow-lite/third_party/ruy/profiler
    ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/profiler/: treeview.h profiler.h instrumentation.h profiler.cpp treeview.cpp instrumentation.cpp
