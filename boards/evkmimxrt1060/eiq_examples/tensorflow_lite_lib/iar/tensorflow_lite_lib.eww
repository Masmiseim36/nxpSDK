<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/tensorflow_lite_lib.ewp</path>
  </project>
</workspace>
