# Keil uVision project ew_gui_bezier_clock.uvprojx, settings and files
target ew_gui_bezier_clock flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ew_gui_bezier_clock.out
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1062DVL6A, SKIP_SYSCLK_INIT, XIP_BOOT_HEADER_DCD_ENABLE=1, EW_USE_DOUBLE_BUFFER=1, EW_CPU_LOAD_MEASURING=1, EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565, EW_SURFACE_ROTATION=0, EW_USE_FREE_RTOS=0
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../devices/MIMXRT1062/drivers;../../../../../components/ft5406_rt;../../../../../devices/MIMXRT1062/utilities/debug_console_lite;../GeneratedCode;../../../../../middleware/EmbeddedWizard/TargetSpecific/RT;../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RGB565;../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RTE;../../../../../devices/MIMXRT1062;../../../../../components/uart;../../../../../components/lists;../../../../../devices/MIMXRT1062/xip;../../../xip;../../../../../CMSIS/Include
  asm define: DEBUG, __STARTUP_CLEAR_BSS, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RTE/libewrte-m7-keil.lib ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RGB565/libewgfx-m7-keil.lib --remove --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group board
    ../: board.c board.h clock_config.c clock_config.h dcd.c dcd.h ewconfig.h ewdef.h pin_mux.c pin_mux.h
  group source
    ../: main.c ewmain.c ewmain.h DeviceDriver.c DeviceDriver.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_cache.c fsl_cache.h fsl_elcdif.c fsl_elcdif.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_pxp.c fsl_pxp.h fsl_lpi2c.c fsl_lpi2c.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group touchpanel
    ../../../../../components/ft5406_rt/: fsl_ft5406_rt.h fsl_ft5406_rt.c
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group EmbeddedWizard/GeneratedCode
    ../GeneratedCode/: Application.c Templates.c BezierClock.c Effects.c Resources.c Core.c Views.c WidgetSet.c Graphics.c _ViewsRectangle.h _WidgetSetRadioButtonConfig.h _CoreKeyPressHandler.h _EffectsPointEffect.h _CoreSimpleTouchHandler.h _WidgetSetPushButtonConfig.h Resources.h _BezierClockOrange.h _WidgetSetPushButton.h _EffectsFloatEffect.h _ViewsImage.h _CoreLayoutContext.h _ViewsStrokePath.h _GraphicsArcPath.h _BezierClockDark.h _ViewsFillPath.h _BezierClockBackground.h _BezierClockSettingsScreen.h _BezierClockTimerWheel.h _WidgetSetWidgetConfig.h ewlocale.h _CoreLayoutQuadContext.h _EffectsTransition.h Templates.h _CoreEvent.h _TemplatesPickerControl.h Views.h BezierClock.h Core.h _BezierClockDeviceClass.h _BezierClockBezierClock.h _EffectsPositionFader.h _EffectsEffectTimerClass.h _CoreView.h _BezierClockBackgroundPreview.h _CoreTaskQueue.h WidgetSet.h _CoreVerticalList.h _BezierClockClockScreen.h _EffectsVisibilityFader.h _BezierClockBubble.h _EffectsFader.h _EffectsTimingList.h _EffectsInt32Effect.h _EffectsEffect.h _TemplatesRotaryKnob.h _CoreCursorEvent.h _ViewsText.h _CoreRoot.h _BezierClockTimerScreen.h _ResourcesNavigationIconsMedium.h _CoreOutline.h _CoreModalContext.h Application.h _ResourcesWhiteBitmap.h _EffectsShowHideTransition.h _ApplicationApplication.h _BezierClockFontL.h _CorePropertyObserver.h _CoreQuadView.h _CoreDragEvent.h _CoreCursorGrabEvent.h _GraphicsCanvas.h _CoreLineView.h _ViewsLine.h _ResourcesWhiteBitmapStripe.h Effects.h Graphics.h _BezierClockTimePicker.h _CoreRotateTouchHandler.h _CoreKeyEvent.h _CoreTime.h _BezierClockStyleScreen.h _CoreCursorHit.h _BezierClockDatePicker.h _CoreSlideTouchHandler.h _BezierClockFontXXL.h _ResourcesFont.h _BezierClockDigit.h _CoreTask.h _WidgetSetRadioButton.h _CoreLayoutLineContext.h _CoreDialogContext.h _CoreTimer.h _ResourcesBitmap.h _GraphicsPath.h _CoreGroup.h _BezierClockBlue.h _EffectsSlideTransition.h _ViewsFrame.h _CoreResource.h _CoreRectView.h _EffectsFaderTask.h
  group EmbeddedWizard/TargetSpecific/RT
    ../../../../../middleware/EmbeddedWizard/TargetSpecific/RT/: ew_bsp_console.c ew_bsp_system.c ew_bsp_clock.c ew_bsp_event.c ew_bsp_graphics.c ew_bsp_display.c ew_bsp_inout.c ew_bsp_touch.c ew_bsp_console.h ew_bsp_display.h ew_bsp_touch.h ew_bsp_clock.h ew_bsp_inout.h ew_bsp_system.h ew_bsp_event.h ew_bsp_graphics.h
  group EmbeddedWizard/PlatformPackage/RT/RGB565
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RGB565/: ewextgfx.c ewgfxdefs.h ewgfxres.h ewextgfx.h ewgfxdriver.h ewextfnt.h ewgfxcore.h ewextbmp.h ewgfxlinks.h ewgfxtasks.h ewextpxl_RGB565.h ewgfx.h
  group EmbeddedWizard/PlatformPackage/RT/RTE
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RTE/: ewextrte.c ewextrte.h ewrte.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1062/arm/: startup_MIMXRT1062.S
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
target ew_gui_bezier_clock flexspi_nor_release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ew_gui_bezier_clock.out
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1062DVL6A, SKIP_SYSCLK_INIT, XIP_BOOT_HEADER_DCD_ENABLE=1, EW_USE_DOUBLE_BUFFER=1, EW_CPU_LOAD_MEASURING=1, EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565, EW_SURFACE_ROTATION=0, EW_USE_FREE_RTOS=0
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_CLEAR_BSS, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: as above
