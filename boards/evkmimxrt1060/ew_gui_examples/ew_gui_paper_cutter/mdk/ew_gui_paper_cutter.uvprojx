# Keil uVision project ew_gui_paper_cutter.uvprojx, settings and files
target ew_gui_paper_cutter flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ew_gui_paper_cutter.out
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1062DVL6A, SKIP_SYSCLK_INIT, XIP_BOOT_HEADER_DCD_ENABLE=1, EW_USE_DOUBLE_BUFFER=1, EW_CPU_LOAD_MEASURING=1, EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565, EW_SURFACE_ROTATION=0, EW_USE_FREE_RTOS=0
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../devices/MIMXRT1062/drivers;../../../../../components/ft5406_rt;../../../../../devices/MIMXRT1062/utilities/debug_console_lite;../GeneratedCode;../../../../../middleware/EmbeddedWizard/TargetSpecific/RT;../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RGB565;../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RTE;../../../../../devices/MIMXRT1062;../../../../../components/uart;../../../../../components/lists;../../../../../devices/MIMXRT1062/xip;../../../xip;../../../../../CMSIS/Include
  asm define: DEBUG, __STARTUP_CLEAR_BSS, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RTE/libewrte-m7-keil.lib ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RGB565/libewgfx-m7-keil.lib --remove --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group board
    ../: board.c board.h clock_config.c clock_config.h dcd.c dcd.h ewconfig.h ewdef.h pin_mux.c pin_mux.h
  group source
    ../: main.c ewmain.c ewmain.h DeviceDriver.c DeviceDriver.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_cache.c fsl_cache.h fsl_elcdif.c fsl_elcdif.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_pxp.c fsl_pxp.h fsl_lpi2c.c fsl_lpi2c.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group touchpanel
    ../../../../../components/ft5406_rt/: fsl_ft5406_rt.h fsl_ft5406_rt.c
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group EmbeddedWizard/GeneratedCode
    ../GeneratedCode/: Effects.c Application.c Resources.c Cutter.c Core.c Graphics.c Views.c _CoreQuadView.h _CutterMediumDigitFont.h _ApplicationApplication.h _CutterVertSlider.h _CutterThumb.h _ViewsText.h _CutterMainButton.h _CutterCutter.h _EffectsEffect.h _ResourcesFont.h Resources.h _CutterPaperStripe.h _CoreKeyEvent.h _CutterBarGraph.h _CutterStatusBar.h _CutterHorzSlider.h _CutterStatusIcons.h _ViewsRectangle.h _CutterRemainingWindow.h _CoreTask.h _CoreTaskQueue.h _CoreTimer.h _CoreGroup.h _CoreOutline.h _CutterMainButtonFont.h _CoreCursorEvent.h Core.h _CutterBarRaster.h _CoreRoot.h _CutterButtonBig.h _ViewsBorder.h _CoreLayoutContext.h _CutterFeedWindow.h _CutterDeviceClass.h _CoreEvent.h _EffectsEffectTimerClass.h _CutterBatchWindow.h _CoreModalContext.h _EffectsTimingList.h _CutterPaper.h _EffectsRectEffect.h _CutterCancelButton.h _CutterPaperFormat.h _CutterPaperBatch.h _CutterFeedDialog.h _CutterPaperSpeed.h _CoreResource.h _CoreCursorGrabEvent.h _ResourcesBitmap.h _CoreTime.h _CutterButtonFont.h Cutter.h _CoreCursorHit.h Application.h _CutterFormatWindow.h _CutterDescrFont.h _CutterSpeedButton.h Effects.h _CutterSpeedDialog.h _CutterWindow.h _CoreRectView.h _CutterSpeedWindow.h _CutterArrows.h _CutterSmallDigitFont.h _EffectsInt32Effect.h _CutterCaptionFont.h _CutterFeedButton.h _CutterFormatDialog.h _ViewsImage.h _CutterPaperFeed.h ewlocale.h _CutterLargeDigitFont.h _CoreDialogContext.h _CutterButton.h _GraphicsCanvas.h _CoreDragEvent.h Graphics.h Views.h _CoreKeyPressHandler.h _CutterPaperCut.h _CoreView.h _CutterBatchDialog.h _CoreSimpleTouchHandler.h _CoreLayoutQuadContext.h
  group EmbeddedWizard/TargetSpecific/RT
    ../../../../../middleware/EmbeddedWizard/TargetSpecific/RT/: ew_bsp_system.c ew_bsp_display.c ew_bsp_clock.c ew_bsp_event.c ew_bsp_graphics.c ew_bsp_console.c ew_bsp_inout.c ew_bsp_touch.c ew_bsp_graphics.h ew_bsp_event.h ew_bsp_system.h ew_bsp_touch.h ew_bsp_clock.h ew_bsp_console.h ew_bsp_display.h ew_bsp_inout.h
  group EmbeddedWizard/PlatformPackage/RT/RGB565
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RGB565/: ewextgfx.c ewgfxdefs.h ewextfnt.h ewgfx.h ewgfxres.h ewgfxlinks.h ewgfxtasks.h ewextgfx.h ewgfxdriver.h ewgfxcore.h ewextpxl_RGB565.h ewextbmp.h
  group EmbeddedWizard/PlatformPackage/RT/RTE
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RTE/: ewextrte.c ewrte.h ewextrte.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1062/arm/: startup_MIMXRT1062.S
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
target ew_gui_paper_cutter flexspi_nor_release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ew_gui_paper_cutter.out
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1062DVL6A, SKIP_SYSCLK_INIT, XIP_BOOT_HEADER_DCD_ENABLE=1, EW_USE_DOUBLE_BUFFER=1, EW_CPU_LOAD_MEASURING=1, EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565, EW_SURFACE_ROTATION=0, EW_USE_FREE_RTOS=0
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_CLEAR_BSS, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: as above
