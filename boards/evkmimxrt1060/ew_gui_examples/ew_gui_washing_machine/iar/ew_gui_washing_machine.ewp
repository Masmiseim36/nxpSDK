# IAR project ew_gui_washing_machine.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1062DVL6A; SKIP_SYSCLK_INIT; XIP_BOOT_HEADER_DCD_ENABLE=1; EW_USE_DOUBLE_BUFFER=1; EW_CPU_LOAD_MEASURING=1; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565; EW_SURFACE_ROTATION=0; EW_USE_FREE_RTOS=0
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../devices/MIMXRT1062/drivers; ../../../../../components/ft5406_rt; ../../../../../devices/MIMXRT1062/utilities/debug_console_lite; ../GeneratedCode; ../../../../../middleware/EmbeddedWizard/TargetSpecific/RT; ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RGB565; ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RTE; ../../../../../devices/MIMXRT1062; ../../../../../components/uart; ../../../../../components/lists; ../../../../../devices/MIMXRT1062/xip; ../../../xip; ../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_CLEAR_BSS; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: ew_gui_washing_machine.out
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RTE/libewrte-m7-iar.a; ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RGB565/libewgfx-m7-iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1062DVL6A; SKIP_SYSCLK_INIT; XIP_BOOT_HEADER_DCD_ENABLE=1; EW_USE_DOUBLE_BUFFER=1; EW_CPU_LOAD_MEASURING=1; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565; EW_SURFACE_ROTATION=0; EW_USE_FREE_RTOS=0
  AARM.ADefines: NDEBUG; __STARTUP_CLEAR_BSS; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../: board.c board.h clock_config.c clock_config.h dcd.c dcd.h ewconfig.h ewdef.h pin_mux.c pin_mux.h
  group source
    ../: main.c ewmain.c ewmain.h DeviceDriver.c DeviceDriver.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_cache.c fsl_cache.h fsl_elcdif.c fsl_elcdif.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_pxp.c fsl_pxp.h fsl_lpi2c.c fsl_lpi2c.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group touchpanel
    ../../../../../components/ft5406_rt/: fsl_ft5406_rt.h fsl_ft5406_rt.c
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group EmbeddedWizard/GeneratedCode
    ../GeneratedCode/: Effects.c Application.c Resources.c Core.c Graphics.c Washer.c Views.c _CoreQuadView.h _WasherListFontM.h _WasherShadow.h _ApplicationApplication.h _WasherHourItemS.h _ViewsText.h _WasherMinItemS.h _WasherBgEco.h _EffectsEffect.h _ResourcesFont.h _WasherWasher.h Resources.h _WasherSpinItemS.h _CoreKeyEvent.h _WasherDeviceClass.h _ViewsRectangle.h _CoreTask.h _CoreSlideTouchHandler.h _CoreTaskQueue.h _CoreTimer.h _CoreGroup.h _WasherBgSportswear.h _CoreOutline.h _WasherTimeList.h _WasherBgDelicates.h _WasherSpinItemL.h _CoreCursorEvent.h Core.h _CoreRoot.h _CoreVerticalList.h _WasherOptList.h _ViewsBorder.h _CorePropertyObserver.h _CoreLayoutContext.h _WasherStartButton.h _CoreEvent.h _EffectsEffectTimerClass.h _CoreModalContext.h _EffectsTimingList.h _EffectsRectEffect.h _WasherBgEasyCare.h _CoreResource.h _WasherTempList.h _CoreCursorGrabEvent.h _ResourcesBitmap.h _WasherListFontL.h _CoreCursorHit.h Application.h Effects.h _WasherProgItemS.h _WasherMinItemL.h _CoreRectView.h Washer.h _WasherBgHot.h _WasherSpinList.h _WasherOptItemL.h _WasherBgWool.h _WasherListFontXL.h _WasherHourItemL.h _WasherBgSpin.h _WasherBgDrain.h _EffectsInt32Effect.h _WasherTempItemL.h _ViewsImage.h ewlocale.h _WasherListFontS.h _CoreDialogContext.h _WasherDescrFont.h _GraphicsCanvas.h _WasherProgItemL.h _CoreDragEvent.h Graphics.h _WasherTempItemS.h Views.h _CoreKeyPressHandler.h _WasherProgList.h _CoreView.h _ViewsFrame.h _WasherOptItemS.h _CoreSimpleTouchHandler.h _CoreLayoutQuadContext.h
  group EmbeddedWizard/TargetSpecific/RT
    ../../../../../middleware/EmbeddedWizard/TargetSpecific/RT/: ew_bsp_system.c ew_bsp_display.c ew_bsp_clock.c ew_bsp_event.c ew_bsp_graphics.c ew_bsp_console.c ew_bsp_inout.c ew_bsp_touch.c ew_bsp_graphics.h ew_bsp_event.h ew_bsp_system.h ew_bsp_touch.h ew_bsp_clock.h ew_bsp_console.h ew_bsp_display.h ew_bsp_inout.h
  group EmbeddedWizard/PlatformPackage/RT/RGB565
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RGB565/: ewextgfx.c ewgfxdefs.h ewextfnt.h ewgfx.h ewgfxres.h ewgfxlinks.h ewgfxtasks.h ewextgfx.h ewgfxdriver.h ewgfxcore.h ewextpxl_RGB565.h ewextbmp.h
  group EmbeddedWizard/PlatformPackage/RT/RTE
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RTE/: ewextrte.c ewrte.h ewextrte.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
