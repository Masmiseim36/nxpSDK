<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>littlefs_shell</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>littlefs_shell</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>littlefs_shell</project>
        <configuration>sdram_debug</configuration>
      </member>
      <member>
        <project>littlefs_shell</project>
        <configuration>sdram_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>littlefs_shell</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>littlefs_shell</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdram_debug</name>
      <member>
        <project>littlefs_shell</project>
        <configuration>sdram_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdram_release</name>
      <member>
        <project>littlefs_shell</project>
        <configuration>sdram_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/littlefs_shell.ewp</path>
  </project>
</workspace>
