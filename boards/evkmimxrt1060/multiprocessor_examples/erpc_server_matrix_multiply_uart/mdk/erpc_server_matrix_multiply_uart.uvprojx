# Keil uVision project erpc_server_matrix_multiply_uart.uvprojx, settings and files
target erpc_server_matrix_multiply_uart debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: erpc_server_matrix_multiply_uart.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT1062DVL6A, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../erpc_common;../../erpc_common/erpc_matrix_multiply/service;..;../../../../../devices/MIMXRT1062/drivers;../../../../../devices/MIMXRT1062/cmsis_drivers;../../../../../devices/MIMXRT1062/utilities/debug_console_lite;../../../../../middleware/multicore/erpc/erpc_c/infra;../../../../../middleware/multicore/erpc/erpc_c/setup;../../../../../middleware/multicore/erpc/erpc_c/transports;../../../../../middleware/multicore/erpc/erpc_c/port;../../../../../devices/MIMXRT1062;../../../../../components/uart;../../../../../components/lists;../../../../../devices/MIMXRT1062/xip;../../../xip;../../../../../CMSIS/Core/Include;../../../../../CMSIS/Driver/Include;../../../../../middleware/multicore/erpc/erpc_c
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_ram.scf
  link misc: --remove --muldefweak --entry=Reset_Handler --predefine="-D__stack_size__=0x400" --predefine="-D__heap_size__=0x2000"
  group source
    ../../erpc_common/: erpc_error_handler.h erpc_error_handler.cpp
    ../: main_server.c erpc_config.h
  group erpc/service
    ../../erpc_common/erpc_matrix_multiply/service/: erpc_matrix_multiply.erpc erpc_matrix_multiply.h erpc_matrix_multiply_server.h erpc_matrix_multiply_server.cpp
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_lpuart_edma.h fsl_lpuart_edma.c
    ../../../../../devices/MIMXRT1062/cmsis_drivers/: fsl_lpuart_cmsis.h fsl_lpuart_cmsis.c
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group erpc/infra
    ../../../../../middleware/multicore/erpc/erpc_c/infra/: erpc_simple_server.h erpc_simple_server.cpp erpc_server.h erpc_server.cpp erpc_framed_transport.h erpc_framed_transport.cpp erpc_version.h erpc_codec.h erpc_basic_codec.h erpc_transport.h erpc_message_buffer.h erpc_message_loggers.h erpc_common.h erpc_manually_constructed.h erpc_crc16.h erpc_basic_codec.cpp erpc_message_buffer.cpp erpc_message_loggers.cpp erpc_crc16.cpp erpc_client_server_common.h erpc_pre_post_action.h erpc_pre_post_action.cpp
  group erpc/setup
    ../../../../../middleware/multicore/erpc/erpc_c/setup/: erpc_server_setup.h erpc_server_setup.cpp erpc_setup_uart_cmsis.cpp erpc_setup_mbf_dynamic.cpp erpc_transport_setup.h erpc_mbf_setup.h
  group erpc/transports
    ../../../../../middleware/multicore/erpc/erpc_c/transports/: erpc_uart_cmsis_transport.h erpc_uart_cmsis_transport.cpp
  group erpc/port
    ../../../../../middleware/multicore/erpc/erpc_c/port/: erpc_port.h erpc_port_stdlib.cpp erpc_config_internal.h erpc_setup_extensions.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1062/arm/: startup_MIMXRT1062.S
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group CMSIS_driver
    ../../../../../CMSIS/Driver/Include/: Driver_USART.h Driver_Common.h
target erpc_server_matrix_multiply_uart flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: erpc_server_matrix_multiply_uart.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1062DVL6A, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: as above
target erpc_server_matrix_multiply_uart sdram_debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: erpc_server_matrix_multiply_uart.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, DEBUG, CPU_MIMXRT1062DVL6A, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_sdram.scf
  link misc: as above
target erpc_server_matrix_multiply_uart release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: erpc_server_matrix_multiply_uart.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1062DVL6A, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_ram.scf
  link misc: as above
target erpc_server_matrix_multiply_uart flexspi_nor_release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: erpc_server_matrix_multiply_uart.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1062DVL6A, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: as above
target erpc_server_matrix_multiply_uart sdram_release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: erpc_server_matrix_multiply_uart.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, CPU_MIMXRT1062DVL6A, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_sdram.scf
  link misc: as above
