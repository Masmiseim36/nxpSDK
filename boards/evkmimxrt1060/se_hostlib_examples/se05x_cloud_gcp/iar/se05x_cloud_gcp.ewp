# IAR project se05x_cloud_gcp.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1062DVL6A; IMX_RT; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; MBEDTLS_CONFIG_FILE="sss_mbedtls_evkmimxrt1060_config.h"; mqttconfigENABLE_METRICS=0; SDK_DEBUGCONSOLE_UART; FREEDOM; LPC_ENET; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS; T1oI2C; T1oI2C_UM11225; SSS_USE_FTR_FILE; NO_SECURE_CHANNEL_SUPPORT; MBEDTLS; SDK_OS_FREE_RTOS; USE_RTOS; mqttconfigENABLE_METRICS=0; SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe188,Pa089,Pe546,Pe167,Pe144,Pa183
  ICCARM.IExtraOptions: --diag_suppress Pa084
  ICCARM.CCIncludePath2: ../../..; ..; ../../../../../devices/MIMXRT1062/drivers; ../../../../../components/phy; ../../../../../components/phy/device/phyksz8081; ../../../../../components/phy/mdio/enet; ../../../../../middleware/se_hostlib/demos/ksdk/common/freertos/boards/evkmimxrt1060; ../../../../../middleware/lwip/port; ../../../../../middleware/lwip/src; ../../../../../middleware/lwip/src/include; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../devices/MIMXRT1062/utilities/debug_console; ../../../../../middleware/mbedtls/port/ksdk; ../../../../../middleware/se_hostlib/sss/inc; ../../../../../middleware/se_hostlib/sss/ex/inc; ../../../../../middleware/se_hostlib/sss/port/ksdk; ../../../../../middleware/se_hostlib/hostlib/hostLib/se05x_03_xx_xx; ../../../../../middleware/se_hostlib/sss/plugin/mbedtls; ../../../../../middleware/se_hostlib/hostlib/hostLib/tstUtil; ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/infra; ../../../../../middleware/se_hostlib/hostlib/hostLib/mbedtls/inc; ../../../../../middleware/se_hostlib/demos/ksdk/common/https_client; ../../../../../middleware/mbedtls/include; ../../../../../middleware/mbedtls/library; ../../../../../devices/MIMXRT1062; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../devices/MIMXRT1062/xip; ../../../xip; ../../../../../CMSIS/Include; ../../../../../rtos/freertos/freertos_kernel/include; ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F; ../../../../../rtos/freertos/libraries/abstractions/secure_sockets/include; ../../../../../rtos/freertos/libraries/c_sdk/standard/common/include; ../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/private; ../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/types; ../../../../../rtos/freertos/libraries/abstractions/platform/freertos/include/platform; ../../../../../rtos/freertos/libraries/abstractions/platform/include/platform; ../../../../../rtos/freertos/libraries/abstractions/platform/include/types; ../../../../../rtos/freertos/libraries/abstractions/platform/freertos/include; ../../../../../rtos/freertos/libraries/abstractions/platform/include; ../../../../../rtos/freertos/libraries/freertos_plus/standard/tls/include; ../../../../../rtos/freertos/libraries/3rdparty/mbedtls_utils; ../../../../../rtos/freertos/libraries/freertos_plus/standard/crypto/include; ../../../../../rtos/freertos/libraries/abstractions/pkcs11/mbedtls; ../../../../../rtos/freertos/libraries/freertos_plus/standard/pkcs11/include; ../../../../../rtos/freertos/libraries/3rdparty/pkcs11; ../../../../../rtos/freertos/libraries/freertos_plus/standard/utils/include; ../../../../../middleware/se_hostlib/hostlib/hostLib/inc; ../../../../../middleware/se_hostlib/hostlib/hostLib/se05x/src; ../../../../../middleware/se_hostlib; ../../../../../middleware/se_hostlib/platform; ../../../../../middleware/se_hostlib/hostlib/hostLib/platform/inc; ../../../../../middleware/se_hostlib/hostlib/hostLib/platform/ksdk; ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom; ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/T1oI2C; ../../../../../middleware/se_hostlib/sss/ex/src; ../../../../../middleware/se_hostlib/demos/ksdk/common; ../../../../../middleware/se_hostlib/demos/ksdk/common/boards/evkmimxrt1060/se_hostlib_examples/cloud_demo; ../../../../../middleware/se_hostlib/sss/plugin/pkcs11; ../../../../../middleware/se_hostlib/rtos/freertos/libraries/abstractions/pkcs11/mbedtls; ../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/include; ../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/include/types; ../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/src/private; ../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/src; ../../../../../rtos/freertos/libraries/3rdparty/jsmn
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: se05x_cloud_gcp.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x1000; __stack_size__=0x2000; __heap_size__=0x8000
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1062DVL6A; IMX_RT; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; MBEDTLS_CONFIG_FILE="sss_mbedtls_evkmimxrt1060_config.h"; mqttconfigENABLE_METRICS=0; SDK_DEBUGCONSOLE_UART; FREEDOM; LPC_ENET; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS; T1oI2C; T1oI2C_UM11225; SSS_USE_FTR_FILE; NO_SECURE_CHANNEL_SUPPORT; MBEDTLS; SDK_OS_FREE_RTOS; USE_RTOS; mqttconfigENABLE_METRICS=0; SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: fsl_sss_ftr.h gcpJWTDemo.c gcpJWTDemo.h gcpJWTDemo_Main_lwip.c gcpJwtTask_lwip.c gcpNTPGetEpoch_lwip.c gcpPubSub.c gcp_client_credential_keys.h gcp_default_root_certificates.h gcp_iot_config.h FreeRTOSConfig.h
  group board
    ../: board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_trng.c fsl_trng.h fsl_dcp.c fsl_dcp.h fsl_pit.c fsl_pit.h fsl_cache.c fsl_cache.h fsl_flexspi.c fsl_flexspi.h fsl_enet.h fsl_enet.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_lpi2c.c fsl_lpi2c.h
  group drivers/freertos
    ../../../../../devices/MIMXRT1062/drivers/: fsl_lpi2c_freertos.h fsl_lpi2c_freertos.c
  group phy
    ../../../../../components/phy/: fsl_phy.h
    ../../../../../components/phy/device/phyksz8081/: fsl_phyksz8081.h fsl_phyksz8081.c
  group mdio
    ../../../../../components/phy/mdio/enet/: fsl_enet_mdio.h fsl_enet_mdio.c
    ../../../../../components/phy/: fsl_mdio.h
  group se_hostlib/demos/ksdk/common
    ../../../../../middleware/se_hostlib/demos/ksdk/common/: ledHandler.c iot_logging_task.h aws_pkcs11_config.h aws_clientcredential.h iot_config_common.h aws_clientcredential_keys.h iot_config.h aws_demo_config.h iot_pkcs11_config.h
  group se_hostlib/demos/ksdk/common/freertos
    ../../../../../middleware/se_hostlib/demos/ksdk/common/freertos/: FreeRTOSConfig.c
  group se_hostlib/demos/ksdk/common/freertos/boards/evkmimxrt1060
    ../../../../../middleware/se_hostlib/demos/ksdk/common/freertos/boards/evkmimxrt1060/: lwipopts.h FreeRTOSIPConfig.h aws_secure_sockets_config.h aws_mqtt_config.h aws_bufferpool_config.h iot_mqtt_agent_config.h app.h
  group se_hostlib/demos/ksdk/common/boards/evkmimxrt1060/se_hostlib_examples/cloud_demo
    ../../../../../middleware/se_hostlib/demos/ksdk/common/boards/evkmimxrt1060/se_hostlib_examples/cloud_demo/: pin_mux.c pin_mux.h
  group se_hostlib/demos/ksdk/common/https_client
    ../../../../../middleware/se_hostlib/demos/ksdk/common/https_client/: httpsclient.h
  group se_hostlib/sss/port/ksdk
    ../../../../../middleware/se_hostlib/sss/port/ksdk/: fsl_sss_types.h
  group se_hostlib/sss/inc
    ../../../../../middleware/se_hostlib/sss/inc/: fsl_sss_util_asn1_der.h fsl_sss_config.h fsl_sss_mbedtls_types.h fsl_sss_api_ver.h fsl_sss_mbedtls_apis.h fsl_sss_ftr_default.h fsl_sss_sscp_config.h fsl_sscp_a71cl.h fsl_sss_keyid_map.h fsl_sscp_a71ch.h fsl_sss_lpc55s_apis.h fsl_sscp_commands.h fsl_sss_api.h fsl_sss_user_types.h fsl_sss_se05x_scp03.h fsl_sss_se05x_types.h fsl_sss_util_rsa_sign_utils.h fsl_sscp.h fsl_sss_policy.h fsl_sss_openssl_apis.h fsl_sss_se05x_policy.h fsl_sss_se05x_apis.h fsl_sss_openssl_types.h fsl_sss_user_apis.h fsl_sss_lpc55s_types.h fsl_sss_sscp.h fsl_sscp_mu.h
  group se_hostlib/sss/src
    ../../../../../middleware/se_hostlib/sss/src/: fsl_sss_apis.c fsl_sss_util_rsa_sign_utils.c fsl_sss_util_asn1_der.c
  group se_hostlib/sss/src/se05x
    ../../../../../middleware/se_hostlib/sss/src/se05x/: fsl_sss_se05x_policy.c fsl_sss_se05x_eckey.c fsl_sss_se05x_scp03.c fsl_sss_se05x_apis.c fsl_sss_se05x_mw.c
  group se_hostlib/sss/src/mbedtls
    ../../../../../middleware/se_hostlib/sss/src/mbedtls/: fsl_sss_mbedtls_apis.c
  group se_hostlib/sss/ex/inc
    ../../../../../middleware/se_hostlib/sss/ex/inc/: ex_sss_main_inc_lpcxpresso55s.h ex_sss_main_inc.h ex_scp03_puf.h ex_a71ch_scp03.h ex_sss_boot.h ex_sss_main_inc_ksdk.h ex_sss_main_inc_frdmk64f.h ex_sss_ports.h ex_sss_scp03_keys.h ex_sss_main_inc_imx_rt.h ex_sss_main_freeRTOS_inc.h ex_sss.h ex_sss_auth.h ex_sss_main_inc_linux.h ex_sss_tp_scp03_keys.h ex_sss_objid.h
  group se_hostlib/sss/ex/src
    ../../../../../middleware/se_hostlib/sss/ex/src/: ex_sss_boot.c ex_sss_boot_connectstring.c ex_sss_boot_int.h ex_sss_se05x.c ex_sss_se05x_auth.c
  group se_hostlib/sss/plugin/pkcs11
    ../../../../../middleware/se_hostlib/sss/plugin/pkcs11/: aws_pkcs11_pal.c pkcs11_mbedtls_utils.c pkcs11_mbedtls_utils.h
  group se_hostlib/sss/plugin/mbedtls
    ../../../../../middleware/se_hostlib/sss/plugin/mbedtls/: sss_mbedtls.c sss_mbedtls_rsa.c ecp_alt_sss.c ecdh_alt_ax.c sss_mbedtls_lpcxpresso55s69_config.h sss_mbedtls_evkmimxrt1060_config.h sss_mbedtls_frdmk64f_config.h sss_mbedtls_frdmkw41z_config.h sss_mbedtls.h ecp_alt.h rsa_alt.h sss_mbedtls_x86_config.h
  group se_hostlib/hostlib/hostLib/inc
    ../../../../../middleware/se_hostlib/hostlib/hostLib/inc/: sm_const.h ax_common_a71cl.h ax_sss_scp.h ax_common_a71ch.h ax_scp_private.h nxEnsure.h nxScp03_Types.h HLSECrypto.h a71cl_util.h ax_util.h HLSEAPI.h se05x_ecc_curves_inc.h HLSEObjects.h a71cl_api.h scp.h ax_scp.h se05x_ftr.h HLSEMisc.h se05x_enums.h se05x_ecc_curves.h HLSETypes.h PlugAndTrust_HostLib_Ver.h se05x_const.h ax_api.h SE_HAL_Lib.h nxScp03_Const.h ledHandler.h ax_common_private.h PlugAndTrust_Pkg_Ver.h Applet_SE050_Ver.h se05x_ecc_curves_values.h a71ch_util.h se05x_tlv.h a71ch_api.h nxScp03_Apis.h ax_common.h HLSEComm.h ledHandler.h
  group se_hostlib/hostlib/hostLib/se05x/src
    ../../../../../middleware/se_hostlib/hostlib/hostLib/se05x/src/: se05x_ECC_curves.c se05x_mw.c se05x_tlv.c
  group se_hostlib/hostlib/hostLib/platform/inc
    ../../../../../middleware/se_hostlib/hostlib/hostLib/platform/inc/: se_pit_config.h i2c_a7.h ax_reset.h se_reset_config.h se05x_apis.h sm_timer.h sm_printf.h
  group se_hostlib/hostlib/hostLib/platform/ksdk
    ../../../../../middleware/se_hostlib/hostlib/hostLib/platform/ksdk/: ax_reset.c i2c_frdm.c i2c_imxrt10xx.c i2c_lpc54xxx.c i2c_lpc55sxx.c se05x_reset.c timer_kinetis.c timer_kinetis_bm.c timer_kinetis_freertos.c
  group se_hostlib/hostlib/hostLib/libCommon/smCom
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/: apduComm.h sci2c_cfg.h smCom.c smCom.h smComT1oI2C.c smComT1oI2C.h
  group se_hostlib/hostlib/hostLib/libCommon/smCom/T1oI2C
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/T1oI2C/: phNxpEsePal_i2c.h phNxpEse_Internal.h phNxpEse_Api.h phNxpEseProto7816_3.h phEseTypes.h phEseStatus.h phNxpEse_Api.c phNxpEsePal_i2c.c phNxpEseProto7816_3.c
  group se_hostlib/hostlib/hostLib/libCommon/infra
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/infra/: global_platf.c sm_connect.c sm_api.h sm_demo_utils.h sm_apdu.h nxLog_UseCases.h sm_types.h nxLog_VCOM.h nxLog_App.h nxLog_hostLib.h nxLog_smCom.h nxLog_sscp.h nxLog.h app_boot_nfc.h a71_debug.h nxLog_mbedtls.h sm_errors.h global_platf.h app_boot.h nxLog_scp.h nxLog_DefaultConfig.h nxLog_sss.h cm_commands.h nxLog.c sm_apdu.c sm_errors.c sm_printf.c sm_demo_utils.c sm_demo_utils_rtos.c
  group se_hostlib/hostlib/hostLib/libCommon/nxScp
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/nxScp/: nxScp03_Com.c
  group se_hostlib/hostlib/hostLib/libCommon/scp
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/scp/: scp.c
  group se_hostlib/hostlib/hostLib/se05x_03_xx_xx
    ../../../../../middleware/se_hostlib/hostlib/hostLib/se05x_03_xx_xx/: se05x_APDU.c se05x_APDU.h se05x_APDU_apis.h se05x_APDU_impl.h se05x_04_xx_APDU_apis.h se05x_04_xx_APDU_impl.h
  group se_hostlib/hostlib/hostLib/tstUtil
    ../../../../../middleware/se_hostlib/hostlib/hostLib/tstUtil/: tstHostCrypto.h
  group se_hostlib/hostlib/hostLib/mbedtls/inc
    ../../../../../middleware/se_hostlib/hostlib/hostLib/mbedtls/inc/: a71ch_mbedtls_x86_config.h a71ch_mbedtls_lpcxpresso54018_config.h a71ch_mbedtls_lpcxpresso55s69_config.h a71ch_mbedtls_frdm_config.h a71ch_mbedtls_evkmimxrt1060_config.h a71ch_mbedtls_frdmk64f_config.h a71ch_mbedtls_frdmk82f_config.h ax_mbedtls.h ecp_alt.h a71ch_mbedtls_lpc54018iotmodule_config.h a71ch_mbedtls_frdmkw41z_config.h a71ch_mbedtls_pi_config.h
  group se_hostlib/hostlib/hostLib/mbedtls/src
    ../../../../../middleware/se_hostlib/hostlib/hostLib/mbedtls/src/: ecdh_alt.c rsa_alt.c
  group lwip/port
    ../../../../../middleware/lwip/port/: enet_ethernetif.c enet_ethernetif.h enet_ethernetif_priv.h enet_ethernetif_kinetis.c sys_arch.c
  group lwip/port/arch
    ../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src/api
    ../../../../../middleware/lwip/src/api/: api_lib.c tcpip.c netdb.c sockets.c if_api.c netbuf.c netifapi.c api_msg.c err.c
  group lwip/src/core
    ../../../../../middleware/lwip/src/core/: altcp.c sys.c stats.c def.c ip.c netif.c dns.c tcp_out.c pbuf.c timeouts.c init.c tcp_in.c altcp_tcp.c raw.c tcp.c udp.c altcp_alloc.c mem.c inet_chksum.c memp.c
  group lwip/src/core/ipv6
    ../../../../../middleware/lwip/src/core/ipv6/: icmp6.c ethip6.c nd6.c ip6_frag.c inet6.c ip6.c dhcp6.c mld6.c ip6_addr.c
  group lwip/src/core/ipv4
    ../../../../../middleware/lwip/src/core/ipv4/: igmp.c ip4.c dhcp.c etharp.c ip4_frag.c icmp.c autoip.c acd.c ip4_addr.c
  group lwip/src/include/compat/stdc
    ../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/compat/posix
    ../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/sys
    ../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/compat/posix/net
    ../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/lwip
    ../../../../../middleware/lwip/src/include/lwip/: err.h sio.h ip6.h netdb.h altcp_tcp.h arch.h debug.h ip6_addr.h sockets.h if_api.h init.h tcpbase.h tcpip.h def.h inet_chksum.h snmp.h api.h ip4.h inet.h igmp.h altcp_tls.h netif.h opt.h ip.h acd.h tcp.h ip6_frag.h altcp.h ip4_addr.h ip4_frag.h netbuf.h autoip.h dns.h sys.h dhcp.h ip_addr.h icmp6.h mem.h raw.h ip6_zone.h stats.h ethip6.h icmp.h pbuf.h netifapi.h nd6.h etharp.h errno.h mld6.h timeouts.h dhcp6.h udp.h memp.h
  group lwip/src/include/lwip/priv
    ../../../../../middleware/lwip/src/include/lwip/priv/: api_msg.h tcpip_priv.h mem_priv.h altcp_priv.h nd6_priv.h tcp_priv.h memp_std.h sockets_priv.h raw_priv.h memp_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../middleware/lwip/src/include/lwip/prot/: ip6.h ethernet.h ip4.h igmp.h ip.h acd.h tcp.h ieee.h iana.h autoip.h dns.h dhcp.h icmp6.h icmp.h nd6.h etharp.h mld6.h dhcp6.h udp.h
  group lwip/src/include/netif
    ../../../../../middleware/lwip/src/include/netif/: bridgeif_opts.h ethernet.h zepif.h ieee802154.h lowpan6.h lowpan6_common.h lowpan6_ble.h lowpan6_opts.h bridgeif.h slipif.h etharp.h
  group lwip/src/include/netif/ppp
    ../../../../../middleware/lwip/src/include/netif/ppp/: eap.h pppol2tp.h chap-md5.h pppcrypt.h ppp.h upap.h pppapi.h ipv6cp.h pppdebug.h pppoe.h mppe.h pppos.h ppp_opts.h chap-new.h ipcp.h lcp.h ccp.h ppp_impl.h eui64.h vj.h ecp.h magic.h fsm.h chap_ms.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: sha1.h md5.h arc4.h md4.h des.h
  group lwip/src/netif
    ../../../../../middleware/lwip/src/netif/: lowpan6.c lowpan6_ble.c ethernet.c lowpan6_common.c slipif.c bridgeif.c bridgeif_fdb.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../middleware/lwip/src/netif/ppp/: utils.c pppol2tp.c chap_ms.c vj.c pppos.c lwip_ecp.c magic.c eui64.c chap-md5.c auth.c ppp.c ccp.c pppapi.c eap.c mppe.c ipv6cp.c ipcp.c lcp.c pppcrypt.c pppoe.c chap-new.c demand.c upap.c multilink.c fsm.c
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c
  group mbedtls/port/ksdk
    ../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c ecp_alt.h ecp_alt.c ecp_curves_alt.c ecp_alt_ksdk.c
  group mbedtls/include/mbedtls
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/library
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c chacha20.c chachapoly.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group freertos/freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    ../../../../../rtos/freertos/freertos_kernel/include/: croutine.h StackMacros.h atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos_kernel/portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/vendors/nxp/secure_sockets/lwip
    ../../../../../rtos/freertos/vendors/nxp/secure_sockets/lwip/: iot_secure_sockets.c
  group freertos/libraries/abstractions/secure_sockets/include
    ../../../../../rtos/freertos/libraries/abstractions/secure_sockets/include/: iot_secure_sockets.h iot_secure_sockets_config_defaults.h iot_secure_sockets_wrapper_metrics.h
  group freertos/libraries/abstractions/platform/freertos
    ../../../../../rtos/freertos/libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_metrics.c iot_network_freertos.c iot_threads_freertos.c
  group freertos/libraries/abstractions/platform/freertos/include/platform
    ../../../../../rtos/freertos/libraries/abstractions/platform/freertos/include/platform/: iot_network_ble.h iot_network_freertos.h iot_platform_types_freertos.h
  group freertos/libraries/abstractions/platform/include/platform
    ../../../../../rtos/freertos/libraries/abstractions/platform/include/platform/: iot_clock.h iot_metrics.h iot_network.h iot_threads.h
  group freertos/libraries/abstractions/platform/include/types
    ../../../../../rtos/freertos/libraries/abstractions/platform/include/types/: iot_platform_types.h
  group freertos/libraries/abstractions/pkcs11/mbedtls
    ../../../../../rtos/freertos/libraries/abstractions/pkcs11/mbedtls/: threading_alt.h
  group freertos/libraries/c_sdk/standard/common
    ../../../../../rtos/freertos/libraries/c_sdk/standard/common/: iot_device_metrics.c iot_init.c iot_static_memory_common.c
  group freertos/libraries/c_sdk/standard/common/include
    ../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/: iot_linear_containers.h iot_appversion32.h iot_atomic.h iot_init.h iot_logging_setup.h iot_logging_task.h iot_taskpool.h
  group freertos/libraries/c_sdk/standard/common/include/private
    ../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/private/: iot_default_root_certificates.h iot_doubly_linked_list.h iot_error.h iot_lib_init.h iot_logging.h iot_static_memory.h iot_taskpool_internal.h
  group freertos/libraries/c_sdk/standard/common/include/types
    ../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/types/: iot_network_types.h iot_taskpool_types.h
  group freertos/libraries/c_sdk/standard/common/logging
    ../../../../../rtos/freertos/libraries/c_sdk/standard/common/logging/: iot_logging.c iot_logging_task_dynamic_buffers.c
  group freertos/libraries/c_sdk/standard/common/taskpool
    ../../../../../rtos/freertos/libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group freertos/libraries/c_sdk/standard/mqtt/include
    ../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/include/: iot_mqtt.h iot_mqtt_agent.h iot_mqtt_agent_config_defaults.h iot_mqtt_config_defaults.h iot_mqtt_lib.h
  group freertos/libraries/c_sdk/standard/mqtt/include/types
    ../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/include/types/: iot_mqtt_types.h
  group freertos/libraries/c_sdk/standard/mqtt/src
    ../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/src/: iot_mqtt_agent.c iot_mqtt_api.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_serialize.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_validate.c
  group freertos/libraries/c_sdk/standard/mqtt/src/private
    ../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/src/private/: iot_mqtt_internal.h
  group freertos/libraries/freertos_plus/standard/tls/include
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/tls/include/: iot_tls.h
  group freertos/libraries/freertos_plus/standard/tls/src
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group freertos/libraries/freertos_plus/standard/crypto/include
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/crypto/include/: iot_crypto.h
  group freertos/libraries/freertos_plus/standard/crypto/src
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group freertos/libraries/freertos_plus/standard/pkcs11/include
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/pkcs11/include/: iot_pkcs11.h
  group freertos/libraries/freertos_plus/standard/pkcs11/src
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/pkcs11/src/: iot_pkcs11.c
  group freertos/libraries/freertos_plus/standard/utils/include
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/utils/include/: iot_pki_utils.h iot_system_init.h
  group freertos/libraries/freertos_plus/standard/utils/src
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/utils/src/: iot_pki_utils.c iot_system_init.c
  group freertos/libraries/3rdparty/mbedtls_utils
    ../../../../../rtos/freertos/libraries/3rdparty/mbedtls_utils/: mbedtls_error.c mbedtls_error.h mbedtls_utils.c README.md LICENSE-2.0.txt
  group freertos/libraries/3rdparty/pkcs11
    ../../../../../rtos/freertos/libraries/3rdparty/pkcs11/: pkcs11.h pkcs11f.h pkcs11t.h CONTRIBUTING.md LICENSE.md README.md
  group freertos/libraries/3rdparty/jsmn
    ../../../../../rtos/freertos/libraries/3rdparty/jsmn/: jsmn.c jsmn.h LICENSE
