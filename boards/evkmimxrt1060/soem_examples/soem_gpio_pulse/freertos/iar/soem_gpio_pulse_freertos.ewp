# IAR project soem_gpio_pulse_freertos.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1062DVL6A; SDK_DEBUGCONSOLE_UART; SERIAL_PORT_TYPE_UART=1; PRINTF_ADVANCED_ENABLE=1; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; MCUXPRESSO_SDK; SDK_OS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pa039,Pe111
  ICCARM.CCIncludePath2: ../../../../../../middleware/soem/osal/freertos; ..; ../../../../../../devices/MIMXRT1062/drivers; ../../../../../../components/phy/device/phyksz8081; ../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F; ../../../../../../middleware/soem/soem; ../../../../../../middleware/soem/oshw/mcux-sdk; ../../../../../../middleware/soem/oshw/mcux-sdk/enet; ../../../../../../middleware/soem/osal; ../../../../../../devices/MIMXRT1062; ../../../../../../devices/MIMXRT1062/utilities/str; ../../../../../../devices/MIMXRT1062/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1062/xip; ../../../../xip; ../../../../../../components/phy; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: soem_gpio_pulse_freertos.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x1000
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1062DVL6A; SDK_DEBUGCONSOLE_UART; SERIAL_PORT_TYPE_UART=1; PRINTF_ADVANCED_ENABLE=1; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; MCUXPRESSO_SDK; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 2
  OBJCOPY.OOCOutputFile: soem_gpio_pulse_bm.bin
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1062DVL6A; SDK_DEBUGCONSOLE_UART; SERIAL_PORT_TYPE_UART=1; PRINTF_ADVANCED_ENABLE=1; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; MCUXPRESSO_SDK; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1062DVL6A; SDK_DEBUGCONSOLE_UART; SERIAL_PORT_TYPE_UART=1; PRINTF_ADVANCED_ENABLE=1; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; MCUXPRESSO_SDK; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: soem_gpio_pulse_bm.bin
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group source
    ../: soem_gpio_pulse.c FreeRTOSConfig.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MIMXRT1062/drivers/: fsl_enet.h fsl_enet.c fsl_gpt.c fsl_gpt.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group component/phy
    ../../../../../../components/phy/device/phyksz8081/: fsl_phyksz8081.h fsl_phyksz8081.c
    ../../../../../../components/phy/: fsl_phy.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/IAR/ARM_CM4F
    ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url
  group soem/soem
    ../../../../../../middleware/soem/soem/: ethercateoe.c ethercatconfig.c ethercatdc.h ethercatprint.h ethercatconfig.h ethercatsoe.h ethercatcoe.h ethercatbase.h ethercateoe.h ethercat.h ethercatsoe.c ethercatconfiglist.h ethercatcoe.c ethercatprint.c ethercatfoe.c ethercattype.h ethercatmain.h ethercatmain.c ethercatdc.c ethercatfoe.h ethercatbase.c
  group soem/oshw/mcux-sdk
    ../../../../../../middleware/soem/oshw/mcux-sdk/: oshw.h soem_port.h oshw.c soem_port.c nicdrv.h nicdrv.c
  group soem/oshw/mcux-sdk/enet
    ../../../../../../middleware/soem/oshw/mcux-sdk/enet/: enet.h enet.c soem_enet.h
  group soem/osal
    ../../../../../../middleware/soem/osal/: osal.h
  group soem/osal/freertos
    ../../../../../../middleware/soem/osal/freertos/: osal.c osal_defs.h
  group device
    ../../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group utilities
    ../../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c
  group startup
    ../../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group xip
    ../../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
