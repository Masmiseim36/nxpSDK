# Keil uVision project dev_cdc_vnic_lite_bm.uvprojx, settings and files
target dev_cdc_vnic_lite_bm debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: dev_cdc_vnic_lite_bm.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _DEBUG=1, DEBUG, CPU_MIMXRT1062DVL6A, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, USB_STACK_BM, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../..;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../middleware/usb;../../../../../../middleware/usb/include;../../../../../../middleware/usb/device;../../../../../../middleware/usb/device;../../../../../../middleware/usb/include;../../../../../../middleware/usb/phy;../../../../../../devices/MIMXRT1062/drivers;../../../../../../components/phyksz8081;../../../../../../devices/MIMXRT1062/drivers;../../../../../../devices/MIMXRT1062/drivers;../../../../../../devices/MIMXRT1062/drivers;../../../../../../devices/MIMXRT1062/drivers;../../../../../../devices/MIMXRT1062;../../../../../../devices/MIMXRT1062/drivers;../../../../../../devices/MIMXRT1062/drivers;../../../../../../devices/MIMXRT1062/xip;../../../../xip;../../../../xip;../../../../../../devices/MIMXRT1062/utilities/str;../../../../../../devices/MIMXRT1062/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../components/serial_manager;../../../../../../components/osa;../../../../../../devices/MIMXRT1062/utilities
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_ram.scf
  link misc: --remove --predefine="-D__stack_size__=0x1000" --predefine="-D__heap_size__=0x1000"
  group source
    ../: virtual_nic_enet_adapter.c virtual_nic_enet_adapter.h virtual_nic_enetif.c virtual_nic_enetif.h usb_device_descriptor.c usb_device_descriptor.h usb_device_cdc_acm.c usb_device_cdc_acm.h usb_device_cdc_rndis.c usb_device_cdc_rndis.h usb_device_ch9.c usb_device_ch9.h virtual_nic.c virtual_nic.h usb_device_config.h
  group doc
    ../: readme.txt
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
    ../../../../../../components/phyksz8081/: fsl_phy.c fsl_phy.h
  group usb-device-source-ehci
    ../../../../../../middleware/usb/device/: usb_device_ehci.c usb_device_ehci.h
  group usb-include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group usb-phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group drivers
    ../../../../../../devices/MIMXRT1062/drivers/: fsl_cache.c fsl_cache.h fsl_gpio.c fsl_gpio.h fsl_enet.c fsl_enet.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h
  group usb-device-include
    ../../../../../../middleware/usb/device/: usb_device.h
  group usb-device-source
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
  group device
    ../../../../../../devices/MIMXRT1062/: MIMXRT1062.h MIMXRT1062_features.h fsl_device_registers.h system_MIMXRT1062.c system_MIMXRT1062.h
  group startup
    ../../../../../../devices/MIMXRT1062/arm/: startup_MIMXRT1062.s
  group utilities
    ../../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c
    ../../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
  group xip
    ../../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h evkmimxrt1060_sdram_ini_dcd.c evkmimxrt1060_sdram_ini_dcd.h
  group component-uart
    ../../../../../../components/uart/: lpuart_adapter.c uart.h
  group component-serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
target dev_cdc_vnic_lite_bm flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: dev_cdc_vnic_lite_bm.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1062DVL6A, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, USB_STACK_BM, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: --remove --keep=*(.boot_hdr.ivt) --keep=*(.boot_hdr.boot_data) --keep=*(.boot_hdr.conf) --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-D__stack_size__=0x1000" --predefine="-D__heap_size__=0x1000"
target dev_cdc_vnic_lite_bm sdram_debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: dev_cdc_vnic_lite_bm.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, DATA_SECTION_IS_CACHEABLE=1, SKIP_SYSCLK_INIT, DEBUG, CPU_MIMXRT1062DVL6A, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, USB_STACK_BM, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_sdram.scf
  link misc: as above
target dev_cdc_vnic_lite_bm release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: dev_cdc_vnic_lite_bm.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _DEBUG=0, NDEBUG, CPU_MIMXRT1062DVL6A, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, USB_STACK_BM, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_ram.scf
  link misc: as above
target dev_cdc_vnic_lite_bm flexspi_nor_release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: dev_cdc_vnic_lite_bm.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1062DVL6A, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, USB_STACK_BM, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: as above
target dev_cdc_vnic_lite_bm sdram_release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: dev_cdc_vnic_lite_bm.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, DATA_SECTION_IS_CACHEABLE=1, SKIP_SYSCLK_INIT, NDEBUG, CPU_MIMXRT1062DVL6A, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, USB_STACK_BM, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_sdram.scf
  link misc: as above
