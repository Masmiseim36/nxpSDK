# IAR project host_msd_fatfs_bm.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DATA_SECTION_IS_CACHEABLE=0; _DEBUG=1; DEBUG; CPU_MIMXRT1062DVL6A; USB_STACK_BM; PRINTF_ADVANCED_ENABLE=1; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../middleware/usb/host; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/phy; ../../../../../../devices/MIMXRT1062/drivers; ../../../../../../devices/MIMXRT1062/utilities/str; ../../../../../../devices/MIMXRT1062/utilities/debug_console_lite; ../../../../../../middleware/usb/host/class; ../../../../../../middleware/fatfs/source; ../../../../../../middleware/fatfs/source/fsl_usb_disk; ../../../../../../devices/MIMXRT1062; ../../../../../../devices/MIMXRT1062/xip; ../../../../xip; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../../../components/osa; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: host_msd_fatfs_bm.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DATA_SECTION_IS_CACHEABLE=0; DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1062DVL6A; USB_STACK_BM; PRINTF_ADVANCED_ENABLE=1; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DATA_SECTION_IS_CACHEABLE=1; SKIP_SYSCLK_INIT; DEBUG; CPU_MIMXRT1062DVL6A; USB_STACK_BM; PRINTF_ADVANCED_ENABLE=1; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 2
  ILINK.IlinkConfigDefines: __heap_noncacheable__=1; __stack_size__=0x2000; __heap_size__=0x2000
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DATA_SECTION_IS_CACHEABLE=0; _DEBUG=0; NDEBUG; CPU_MIMXRT1062DVL6A; USB_STACK_BM; PRINTF_ADVANCED_ENABLE=1; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DATA_SECTION_IS_CACHEABLE=0; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1062DVL6A; USB_STACK_BM; PRINTF_ADVANCED_ENABLE=1; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DATA_SECTION_IS_CACHEABLE=1; NDEBUG; SKIP_SYSCLK_INIT; CPU_MIMXRT1062DVL6A; USB_STACK_BM; PRINTF_ADVANCED_ENABLE=1; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkConfigDefines: as above
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_sdram.icf
  group doc
    ../: readme.txt
  group source
    ../: app.h app.c host_msd_fatfs.c ffconf.h host_msd_fatfs.h usb_host_config.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h dcd.c dcd.h
  group usb/host
    ../../../../../../middleware/usb/host/: usb_host_ehci.c usb_host_ehci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c usb_host.h usb_host_hci.h usb_host_devices.h usb_host_framework.h
  group usb/host/class
    ../../../../../../middleware/usb/host/class/: usb_host_msd.c usb_host_msd.h usb_host_msd_ufi.c usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h
  group usb/phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group drivers
    ../../../../../../devices/MIMXRT1062/drivers/: fsl_cache.c fsl_cache.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group utilities
    ../../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group fatfs/source
    ../../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_usb_disk
    ../../../../../../middleware/fatfs/source/fsl_usb_disk/: fsl_usb_disk.h fsl_usb_disk_bm.c
  group device
    ../../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group startup
    ../../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group xip
    ../../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
