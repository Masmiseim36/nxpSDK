# IAR project wiced_mfg_test.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1062DVL6A; HIGH_SPEED_SDIO_CLOCK; PRINTF_ADVANCED_ENABLE=1; TARGET_wiced; RWL_SERIAL; WICED_MFG_TEST_APP; WICED_PAYLOAD_MTU=8320; PBUF_POOL_BUFSIZE=8320; FSL_RTOS_FREE_RTOS; WIFI_WICED
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM4F; ..; ../../..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../rtos/amazon-freertos/lib/include; ../../../../../rtos/amazon-freertos/lib/include/private; ../../../../../devices/MIMXRT1062/drivers; ../../../../../middleware/lwip/port; ../../../../../middleware/lwip/src; ../../../../../middleware/lwip/src/include; ../../../../../devices/MIMXRT1062/drivers; ../../../../../middleware/sdmmc/port; ../../../../../middleware/sdmmc/port; ../../../../../middleware/wiced/43xxx_Wi-Fi/platforms/MURATA_TYPE1DX; ../../../../../middleware/wiced/43xxx_Wi-Fi/app; ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool; ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/common/include; ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/include; ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/shared/bcmwifi/include; ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/wl/exe; ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/dummy; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../devices/MIMXRT1062/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/serial_manager; ../../../../../devices/MIMXRT1062/drivers; ../../../../../components/lists; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/xip; ../../../xip; ../../../../../middleware/sdmmc/inc; ../../../../../middleware/sdmmc/src; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/chips/4343W; ../../../../../middleware/wiced/43xxx_Wi-Fi/include; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/network/LwIP/WWD; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/include; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/WWD; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/RTOS/FreeRTOS/WWD; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/network; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/platform; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/RTOS; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/SDIO; ../../../../../middleware/lwip/src/include/lwip
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../../..
  ILINK.IlinkOutputFile: wiced_mfg_test.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x2800
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1062DVL6A; HIGH_SPEED_SDIO_CLOCK; PRINTF_ADVANCED_ENABLE=1; TARGET_wiced; RWL_SERIAL; WICED_MFG_TEST_APP; WICED_PAYLOAD_MTU=8320; PBUF_POOL_BUFSIZE=8320; FSL_RTOS_FREE_RTOS; WIFI_WICED
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source
    ../: lwipopts.h mfg_test.c mfg_test.h FreeRTOSConfig.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_clock.h fsl_clock.c fsl_usdhc.c fsl_usdhc.h fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group drivers/freertos
    ../../../../../devices/MIMXRT1062/drivers/: fsl_lpuart_freertos.h fsl_lpuart_freertos.c
  group amazon-freertos/FreeRTOS
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos/FreeRTOS/portable
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM4F/: fsl_tickless_systick.c fsl_tickless_generic.h port.c portasm.s portmacro.h
  group amazon-freertos/license
    ../../../../../rtos/amazon-freertos/: LICENSE
  group amazon-freertos/include
    ../../../../../rtos/amazon-freertos/lib/include/: event_groups.h FreeRTOS.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
    ../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_wrappers.h mpu_prototypes.h portable.h projdefs.h stack_macros.h threading_alt.h
  group lwip/port
    ../../../../../middleware/lwip/port/: sys_arch.c
  group lwip/port/arch
    ../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src/api
    ../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/core
    ../../../../../middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/src/core/ipv4
    ../../../../../middleware/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/src/core/ipv6
    ../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip/src/include/compat/posix
    ../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/compat/posix/net
    ../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/sys
    ../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/stdc
    ../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/lwip
    ../../../../../middleware/lwip/src/include/lwip/: altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip_addr.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/priv
    ../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../middleware/lwip/src/include/lwip/prot/: autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip/src/include/netif
    ../../../../../middleware/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lwip/src/include/netif/ppp
    ../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap_ms.h chap-md5.h chap-new.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip/src/netif
    ../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group sdmmc/src
    ../../../../../middleware/sdmmc/src/: fsl_sdio.c fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc/inc/: fsl_sdio.h fsl_sdmmc_host.h fsl_sdmmc_common.h fsl_sdmmc_spec.h
  group sdmmc/port
    ../../../../../middleware/sdmmc/port/: fsl_sdmmc_event.h
    ../../../../../middleware/sdmmc/port/usdhc/freertos/: fsl_sdmmc_event.c fsl_sdmmc_host.c
  group 43xxx_wifi/platforms/MURATA_TYPE1DX
    ../../../../../middleware/wiced/43xxx_Wi-Fi/platforms/MURATA_TYPE1DX/: wifi_nvram_image.h
  group 43xxx_wifi/app
    ../../../../../middleware/wiced/43xxx_Wi-Fi/app/: wlanif_add.c test_scan.c
  group 43xxx_wifi/libraries/test/wl_tool
    ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/: wl_tool.h wlu_server.c
  group 43xxx_wifi/libraries/test/wl_tool/4343WA1/common/include/devctrl_if
    ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/common/include/devctrl_if/: phyioctl_defs.h wlioctl_defs.h
  group 43xxx_wifi/libraries/test/wl_tool/4343WA1/common/include/proto
    ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/common/include/proto/: 802.11.h 802.11e.h 802.1d.h bcmeth.h bcmevent.h bcmip.h bcmipv6.h ethernet.h vlan.h wpa.h wps.h
  group 43xxx_wifi/libraries/test/wl_tool/4343WA1/include
    ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/include/: bcm_cfg.h bcm_mpool_pub.h bcmcdc.h bcmdefs.h bcmdevs.h bcmendian.h bcmnvram.h bcmsrom_fmt.h bcmsrom_tbl.h bcmstdlib.h bcmutils.h dhdioctl.h epictrl.h epiioctl.h epivers.h irelay.h miniopt.h packed_section_end.h packed_section_start.h sbpcmcia.h trxhdr.h typedefs.h usbrdl.h wl_drv.h wlioctl.h
  group 43xxx_wifi/libraries/test/wl_tool/4343WA1/shared/bcmwifi/include
    ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/shared/bcmwifi/include/: bcmwifi_channels.h bcmwifi_rates.h
  group 43xxx_wifi/libraries/test/wl_tool/4343WA1/wl/exe
    ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/wl/exe/: wlu.h wlu_client_shared.h wlu_cmd.h wlu_common.h wlu_pipe.c wlu_pipe.h wlu_remote.h wlu_server_shared.c wlu_server_shared.h
  group 43xxx_wifi/libraries/test/wl_tool/dummy
    ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/dummy/: netdb.h ntddndis.h nuiouser.h
  group 43xxx_wifi/libraries/test/wl_tool/dummy/arpa
    ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/dummy/arpa/: inet.h
  group 43xxx_wifi/libraries/test/wl_tool/dummy/net
    ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/dummy/net/: if.h
  group 43xxx_wifi/libraries/test/wl_tool/dummy/sys
    ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/dummy/sys/: socket.h
  group 43xxx_wifi/WICED
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/: generated_mac_address.txt
  group 43xxx_wifi/WICED/WWD
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/: wwd.h wwd_wiced.h
  group 43xxx_wifi/WICED/WWD/internal
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/: tlv.c tlv.h wwd_ap.h wwd_ap_common.c wwd_ap_common.h wwd_bcmendian.h wwd_clm.c wwd_clm.h wwd_debug.c wwd_eapol.c wwd_internal.c wwd_internal.h wwd_logging.h wwd_management.c wwd_rtos_interface.c wwd_sdpcm.c wwd_sdpcm.h wwd_thread.c wwd_thread.h wwd_thread_internal.c wwd_thread_internal.h wwd_wifi.c wwd_wifi_chip_common.c wwd_wifi_chip_common.h wwd_wifi_sleep.c
  group 43xxx_wifi/WICED/WWD/internal/chips/4343W
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/chips/4343W/: 4343WA1.h 4343WA1_clm.h 4343WA1_mfg.h 4343WA1_clm_mfg.h chip_constants.h resources.c resources.h wwd_ap.c wwd_chip_specific_functions.c
  group 43xxx_wifi/WICED/WWD/internal/bus_protocols
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/: wwd_bus_common.c wwd_bus_protocol_interface.h
  group 43xxx_wifi/WICED/WWD/internal/bus_protocols/SDIO
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/SDIO/: wwd_bus_protocol.c wwd_bus_protocol.h
  group 43xxx_wifi/WICED/WWD/include
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/: wwd_assert.h wwd_constants.h wwd_debug.h wwd_eapol.h wwd_events.h wwd_management.h wwd_poll.h wwd_structures.h wwd_wifi.h wwd_wifi_sleep.h wwd_wlioctl.h
  group 43xxx_wifi/WICED/WWD/include/network
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/network/: wwd_buffer_interface.h wwd_network_constants.h wwd_network_interface.h
  group 43xxx_wifi/WICED/WWD/include/platform
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/platform/: wwd_bus_interface.h wwd_platform_interface.h wwd_resource_interface.h wwd_sdio_interface.h wwd_spi_interface.h
  group 43xxx_wifi/WICED/WWD/include/RTOS
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/RTOS/: wwd_rtos_interface.h
  group 43xxx_wifi/WICED/network/LwIP/WWD
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/network/LwIP/WWD/: wwd_buffer.c wwd_buffer.h wwd_network.c wwd_network.h
  group 43xxx_wifi/WICED/platform
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/: platform_toolchain.h
  group 43xxx_wifi/WICED/platform/include
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/include/: platform_cache_def.h platform_peripheral.h
  group 43xxx_wifi/WICED/platform/MCU
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/: wwd_platform_common.h wwd_platform_separate_mcu.c wwd_resources.c
  group 43xxx_wifi/WICED/platform/MCU/LPC
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/: platform_mcu_peripheral.h
  group 43xxx_wifi/WICED/platform/MCU/LPC/WWD
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/WWD/: wwd_platform.c wwd_SDIO.c
  group 43xxx_wifi/WICED/RTOS/FreeRTOS/WWD
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/RTOS/FreeRTOS/WWD/: wwd_FreeRTOS_systick.h wwd_rtos.c wwd_rtos.h
  group 43xxx_wifi/include
    ../../../../../middleware/wiced/43xxx_Wi-Fi/include/: wiced_resource.h
  group 43xxx_wifi/internal
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/internal/: wifi.c
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: uart.h lpuart_adapter.c
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: generic_list.h generic_list.c
  group startup
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h evkmimxrt1060_sdram_ini_dcd.c evkmimxrt1060_sdram_ini_dcd.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
