# IAR project wifi_webconfig.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0; CPU_MIMXRT1062DVL6A; USE_RTOS=1; WIFI_BOARD_PAN9026_SDIO; PRINTF_ADVANCED_ENABLE=1; LWIP_NETIF_API=1; HTTPSRV_CFG_WEBSOCKET_ENABLED=1; HTTPSRV_CFG_DEFAULT_SES_CNT=8; SDK_DEBUGCONSOLE_UART; MFLASH_FILE_BASEADDR=5767168; SDIO_ENABLED; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.PreInclude: ../wifi_config.h
  ICCARM.CCIncludePath2: ..; ../../../../../middleware/lwip/src/apps/httpsrv; ../../..; ../../../../../components/flash/mflash; ../../../../../components/flash/mflash/mimxrt1062; ../../../../../devices/MIMXRT1062/drivers; ../../../../../middleware/lwip/port; ../../../../../middleware/lwip/src; ../../../../../middleware/lwip/src/include; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../devices/MIMXRT1062/utilities/debug_console; ../../../../../middleware/wifi/dhcpd; ../../../../../middleware/wifi/incl; ../../../../../middleware/wifi/incl/wifidriver; ../../../../../middleware/wifi/wifidriver/incl; ../../../../../middleware/wifi/port/lwip; ../../../../../middleware/wifi/wifidriver; ../../../../../middleware/wifi/incl/wlcmgr; ../../../../../middleware/wifi/incl/port/lwip; ../../../../../middleware/wifi/incl/port/os; ../../../../../middleware/wifi/wifi_bt_firmware; ../../../../../middleware/sdmmc/sdio; ../../../../../middleware/sdmmc/common; ../../../../../middleware/sdmmc/host/usdhc; ../../../../../devices/MIMXRT1062; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../devices/MIMXRT1062/xip; ../../../xip; ../../../../../CMSIS/Include; ../../../../../rtos/freertos/freertos_kernel/include; ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F; ../../../../../middleware/sdmmc/osa; ../../../../../components/osa
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ../../../../src/wifi_common/webconfig/nxp; ../../../../src/wifi_common/webconfig; ..; ../../..; ../../common
  ILINK.IlinkOutputFile: wifi_webconfig.out
  ILINK.IlinkConfigDefines: __stack_size__=2048; __heap_size__=90000
  ILINK.IlinkIcfFile: linker/MIMXRT1062xxxxx_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0; CPU_MIMXRT1062DVL6A; USE_RTOS=1; WIFI_BOARD_PAN9026_SDIO; PRINTF_ADVANCED_ENABLE=1; LWIP_NETIF_API=1; HTTPSRV_CFG_WEBSOCKET_ENABLED=1; HTTPSRV_CFG_DEFAULT_SES_CNT=8; SDK_DEBUGCONSOLE_UART; MFLASH_FILE_BASEADDR=5767168; SDIO_ENABLED; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
    ../../../: sdmmc_config.c sdmmc_config.h
  group source
    ../: lwipopts.h lwippools.h webconfig.c webconfig.h cred_flash_storage.c cred_flash_storage.h http_server.c http_server.h FreeRTOSConfig.h wifi_config.h
  group lwip/src/apps/httpsrv
    ../: httpsrv_fs_data.c
    ../../../../../middleware/lwip/src/apps/httpsrv/: httpsrv.c httpsrv.h httpsrv_base64.c httpsrv_base64.h httpsrv_config.h httpsrv_fs.c httpsrv_fs.h httpsrv_port.h httpsrv_prv.h httpsrv_script.c httpsrv_script.h httpsrv_sha1.c httpsrv_sha1.h httpsrv_supp.c httpsrv_supp.h httpsrv_task.c httpsrv_tls.c httpsrv_tls.h httpsrv_utf8.c httpsrv_utf8.h httpsrv_ws.c httpsrv_ws.h httpsrv_ws_api.c httpsrv_ws_prv.h
  group lwip/src/api
    ../../../../../middleware/lwip/src/api/: sockets.c netifapi.c netdb.c netbuf.c tcpip.c api_msg.c err.c if_api.c api_lib.c
  group lwip/src/core
    ../../../../../middleware/lwip/src/core/: memp.c def.c ip.c pbuf.c altcp.c tcp_out.c raw.c altcp_tcp.c sys.c init.c inet_chksum.c timeouts.c tcp_in.c netif.c mem.c udp.c tcp.c stats.c dns.c altcp_alloc.c
  group lwip/src/core/ipv6
    ../../../../../middleware/lwip/src/core/ipv6/: ethip6.c dhcp6.c ip6_addr.c nd6.c mld6.c icmp6.c ip6_frag.c ip6.c inet6.c
  group lwip/src/core/ipv4
    ../../../../../middleware/lwip/src/core/ipv4/: dhcp.c ip4.c autoip.c icmp.c acd.c etharp.c ip4_addr.c igmp.c ip4_frag.c
  group lwip/src/include/compat/stdc
    ../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/compat/posix
    ../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/sys
    ../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/posix/net
    ../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/lwip
    ../../../../../middleware/lwip/src/include/lwip/: inet_chksum.h ip6.h udp.h def.h mld6.h err.h ip4.h opt.h errno.h debug.h icmp.h netif.h sio.h ip6_zone.h igmp.h netdb.h dhcp.h altcp_tls.h altcp_tcp.h ip_addr.h inet.h tcp.h api.h arch.h autoip.h ip4_addr.h altcp.h mem.h sys.h init.h dns.h tcpbase.h stats.h icmp6.h netifapi.h ethip6.h snmp.h raw.h if_api.h tcpip.h ip6_frag.h nd6.h ip.h pbuf.h acd.h ip4_frag.h timeouts.h dhcp6.h sockets.h netbuf.h etharp.h ip6_addr.h memp.h
  group lwip/src/include/lwip/priv
    ../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h mem_priv.h memp_priv.h memp_std.h api_msg.h nd6_priv.h tcpip_priv.h tcp_priv.h raw_priv.h sockets_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../middleware/lwip/src/include/lwip/prot/: ip6.h udp.h mld6.h ip4.h icmp.h igmp.h dhcp.h tcp.h autoip.h iana.h ieee.h dns.h icmp6.h ethernet.h nd6.h ip.h acd.h dhcp6.h etharp.h
  group lwip/src/include/netif
    ../../../../../middleware/lwip/src/include/netif/: bridgeif.h zepif.h lowpan6.h ieee802154.h ethernet.h lowpan6_common.h lowpan6_opts.h bridgeif_opts.h slipif.h lowpan6_ble.h etharp.h
  group lwip/src/include/netif/ppp
    ../../../../../middleware/lwip/src/include/netif/ppp/: ipv6cp.h pppapi.h magic.h ppp.h upap.h mppe.h pppol2tp.h pppoe.h ipcp.h pppdebug.h eap.h pppos.h ppp_opts.h pppcrypt.h vj.h chap-new.h eui64.h chap_ms.h ccp.h ecp.h lcp.h fsm.h ppp_impl.h chap-md5.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: sha1.h des.h md5.h md4.h arc4.h
  group lwip/src/netif
    ../../../../../middleware/lwip/src/netif/: lowpan6.c ethernet.c bridgeif.c bridgeif_fdb.c zepif.c lowpan6_common.c lowpan6_ble.c slipif.c
  group lwip/src/netif/ppp
    ../../../../../middleware/lwip/src/netif/ppp/: pppol2tp.c mppe.c vj.c pppcrypt.c ppp.c eap.c chap-md5.c lcp.c pppos.c ipcp.c fsm.c ccp.c utils.c chap-new.c demand.c pppoe.c ipv6cp.c lwip_ecp.c multilink.c eui64.c magic.c upap.c pppapi.c chap_ms.c auth.c
  group lwip/port
    ../../../../../middleware/lwip/port/: sys_arch.c
  group lwip/port/arch
    ../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group wpl
    ../: wpl.h wpl_nxp.c
  group doc
    ../: readme.txt
  group flash/mflash
    ../../../../../components/flash/mflash/: mflash_file.h mflash_file.c mflash_common.h
  group flash/mflash/mimxrt1062
    ../../../../../components/flash/mflash/mimxrt1062/: mflash_drv.h mflash_drv.c
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_clock.h fsl_clock.c fsl_usdhc.c fsl_usdhc.h fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group freertos/freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_3.c ReadMe.url
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/include
    ../../../../../rtos/freertos/freertos_kernel/include/: croutine.h StackMacros.h atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c
  group wifi/dhcpd
    ../../../../../middleware/wifi/dhcpd/: dhcp-bootp.h dhcp-priv.h dhcp-server.c dhcp-server-main.c dns.h dns-server.c
  group wifi/incl
    ../../../../../middleware/wifi/incl/: dhcp-server.h wm_utils.h wmerrno.h wmlog.h wmtypes.h
  group wifi/incl/wifidriver
    ../../../../../middleware/wifi/incl/wifidriver/: mlan_sdio_api.h wifi.h wifi_events.h wifi-decl.h
  group wifi/incl/wlcmgr
    ../../../../../middleware/wifi/incl/wlcmgr/: wlan.h wlan_11d.h
  group wifi/incl/port/lwip
    ../../../../../middleware/wifi/incl/port/lwip/: wm_net.h
  group wifi/incl/port/os
    ../../../../../middleware/wifi/incl/port/os/: wm_os.h
  group wifi/wifidriver
    ../../../../../middleware/wifi/wifidriver/: mlan_sdio.c mlan_11ac.c mlan_11d.c mlan_11h.c mlan_11n.c mlan_11n_aggr.c mlan_11n_rxreorder.c mlan_cfp.c mlan_cmdevt.c mlan_glue.c mlan_init.c mlan_join.c mlan_misc.c mlan_scan.c mlan_shim.c mlan_sta_cmd.c mlan_sta_cmdresp.c mlan_sta_event.c mlan_sta_ioctl.c mlan_sta_rx.c mlan_txrx.c mlan_uap_cmdevent.c mlan_uap_ioctl.c mlan_wmm.c mlan_api.c wifi.c wifi_common.h wifi_pwrmgr.c wifi-debug.c wifi-debug.h wifi-internal.h wifi-mem.c wifi-sdio.c wifi-sdio.h wifi-uap.c
  group wifi/wifidriver/incl
    ../../../../../middleware/wifi/wifidriver/incl/: mlan.h mlan_11ac.h mlan_11h.h mlan_11n.h mlan_11n_aggr.h mlan_11n_rxreorder.h mlan_decl.h mlan_fw.h mlan_ieee.h mlan_init.h mlan_ioctl.h mlan_join.h mlan_main.h mlan_meas.h mlan_remap_mem_operations.h mlan_sdio.h mlan_uap.h mlan_util.h mlan_wmm.h mlan_api.h
  group wifi/port/lwip
    ../../../../../middleware/wifi/port/lwip/: net.c wifi_netif.c netif_decl.h
  group wifi/port/os
    ../../../../../middleware/wifi/port/os/: os.c
  group wifi/wlcmgr
    ../../../../../middleware/wifi/wlcmgr/: wlan.c wlan_txpwrlimit_cfg.c
  group wifi/wifi_bt_firmware
    ../../../../../middleware/wifi/wifi_bt_firmware/: sd8801_wlan.h sduart8977_wlan_bt.h sduart8978_wlan_bt.h
  group sdmmc/src
    ../../../../../middleware/sdmmc/sdio/: fsl_sdio.c
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc/sdio/: fsl_sdio.h
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sdio
    ../../../../../middleware/sdmmc/sdio/: ChangeLogKSDK.txt
  group sdmmc/host
    ../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt
    ../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group sdmmc/osa
    ../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c
  group startup
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
