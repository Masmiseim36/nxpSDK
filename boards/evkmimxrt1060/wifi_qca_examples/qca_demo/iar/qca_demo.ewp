# IAR project qca_demo.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1062DVL6A; A_LITTLE_ENDIAN; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM4F; ../../..; ..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../rtos/amazon-freertos/lib/include; ../../../../../rtos/amazon-freertos/lib/include/private; ../../../../../middleware/wifi_qca/port/boards/evkmimxrt1060/freertos/silex2401; ../../../../../middleware/wifi_qca; ../../../../../middleware/wifi_qca/include; ../../../../../middleware/wifi_qca/include/AR6002; ../../../../../middleware/wifi_qca/include/AR6002/hw2.0/hw; ../../../../../middleware/wifi_qca/include/AR6002/hw4.0/hw; ../../../../../middleware/wifi_qca/custom_src/stack_custom; ../../../../../middleware/wifi_qca/custom_src/include; ../../../../../middleware/wifi_qca/common_src/include; ../../../../../middleware/wifi_qca/common_src/stack_common; ../../../../../middleware/wifi_qca/common_src/hcd; ../../../../../middleware/wifi_qca/common_src/wmi; ../../../../../middleware/wifi_qca/port; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../devices/MIMXRT1062/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/serial_manager; ../../../../../devices/MIMXRT1062/drivers; ../../../../../components/lists; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/xip; ../../../xip; ../../../../../middleware/wifi_qca/port/boards/evkmimxrt1060/freertos; ../../../../../middleware/wifi_qca/port/env/freertos; ../../../../../middleware/wifi_qca/port/drivers/lpspi_edma_freertos; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ../../..; ..
  ILINK.IlinkOutputFile: qca_demo.out
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1062DVL6A; A_LITTLE_ENDIAN; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; DEBUG; CPU_MIMXRT1062DVL6A; A_LITTLE_ENDIAN; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1062DVL6A; A_LITTLE_ENDIAN; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1062DVL6A; A_LITTLE_ENDIAN; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SKIP_SYSCLK_INIT; CPU_MIMXRT1062DVL6A; A_LITTLE_ENDIAN; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_sdram.icf
  group source
    ../: FreeRTOSConfig.h main.c wlan_qca400x.c wlan_qcom.c wlan_qcom.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group wifi_qca/port
    ../../../../../middleware/wifi_qca/port/: wifi_common.h
  group wifi_qca/port/shields
    ../../../../../middleware/wifi_qca/port/boards/evkmimxrt1060/freertos/: wifi_shield.h wifi_shield.c
  group wifi_qca/port/shields/silex2401
    ../../../../../middleware/wifi_qca/port/boards/evkmimxrt1060/freertos/silex2401/: wifi_shield_silex2401.h
  group wifi_qca/port/env/freertos
    ../../../../../middleware/wifi_qca/port/env/freertos/: wifi_port.h wifi_env_port.h wifi_env.c wifi_env.h
  group wifi_qca/port/drivers/lpspi_edma_freertos
    ../../../../../middleware/wifi_qca/port/drivers/lpspi_edma_freertos/: wifi_spi.h wifi_spi.c
  group wifi_qca/common_src/wmi
    ../../../../../middleware/wifi_qca/common_src/wmi/: wmi.c wmi_host.h
  group wifi_qca/common_src/stack_common
    ../../../../../middleware/wifi_qca/common_src/storerecall/: dset_api.c
    ../../../../../middleware/wifi_qca/common_src/stack_common/: common_stack_offload.h
  group wifi_qca/common_src/qapi
    ../../../../../middleware/wifi_qca/common_src/stack_common/: api_stack_offload.c
    ../../../../../middleware/wifi_qca/common_src/qapi/: qcom_api.c qcom_dns.c qcom_legacy.c
  group wifi_qca/common_src/include
    ../../../../../middleware/wifi_qca/common_src/include/: dset_api.h driver_cxt.h a_drv_api.h wlan_api.h wmi_api.h hif_internal.h dset.h dbglog_api.h common_api.h bmi.h aggr_recv_api.h a_drv.h a_debug.h spi_hcd_if.h netbuf.h ieee80211.h htc_api.h
  group wifi_qca/common_src/htc
    ../../../../../middleware/wifi_qca/common_src/htc/: htc.c
    ../../../../../middleware/wifi_qca/common_src/hcd/: spi_hcd.c
  group wifi_qca/common_src/driver
    ../../../../../middleware/wifi_qca/common_src/driver/: driver_main.c driver_txrx.c driver_netbuf.c driver_init.c driver_diag.c
  group wifi_qca/common_src/api_interface
    ../../../../../middleware/wifi_qca/common_src/api_interface/: api_wmi_rx.c api_ioctl.c api_txrx.c api_init.c
  group wifi_qca/common_src/hw_interface
    ../../../../../middleware/wifi_qca/common_src/hw_interface/: hw_api.c
  group wifi_qca/common_src/storerecall
    ../../../../../middleware/wifi_qca/common_src/storerecall/: dset.c storerecall.c
  group wifi_qca/common_src/hcd
    ../../../../../middleware/wifi_qca/common_src/hcd/: hcd_api.h
  group wifi_qca/common_src/bmi
    ../../../../../middleware/wifi_qca/common_src/bmi/: bmi.c
  group wifi_qca/common_src/util
    ../../../../../middleware/wifi_qca/common_src/util/: util.c
  group wifi_qca/common_src/reorder
    ../../../../../middleware/wifi_qca/common_src/reorder/: rcv_aggr.c
  group wifi_qca/custom_src/stack_custom
    ../../../../../middleware/wifi_qca/custom_src/stack_custom/: cust_api_stack_offload.c qca_structs.h custom_stack_offload.h cust_api_stack_txrx.c
  group wifi_qca/custom_src/qapi
    ../../../../../middleware/wifi_qca/custom_src/qapi/: custom_qcom_api.c
  group wifi_qca/custom_src/include
    ../../../../../middleware/wifi_qca/custom_src/include/: cust_netbuf.h a_osapi.h a_config.h wlan_config.h custom_wlan_api.h a_types.h
  group wifi_qca/custom_src/api_interface
    ../../../../../middleware/wifi_qca/custom_src/api_interface/: cust_api_wmi_rx.c cust_api_ioctl.c cust_api_txrx.c cust_api_init.c
  group wifi_qca/custom_src/driver
    ../../../../../middleware/wifi_qca/custom_src/driver/: cust_driver_netbuf.c cust_driver_main.c
  group wifi_qca/custom_src/hw_interface
    ../../../../../middleware/wifi_qca/custom_src/hw_interface/: cust_spi_hcd.c
  group wifi_qca/include
    ../../../../../middleware/wifi_qca/include/: wmi.h dbglog.h athdefs.h dbglog_id.h bmi_msg.h wlan_defs.h targaddrs.h pmu.h pkt_log.h p2p.h htc_services.h htc.h
    ../../../../../middleware/wifi_qca/: qcom_api.h atheros_stack_offload.h atheros_wifi_internal.h atheros_wifi_api.h atheros_wifi.h
  group wifi_qca/include/AR6002
    ../../../../../middleware/wifi_qca/include/AR6002/: AR6K_version.h
  group wifi_qca/include/AR6002/hw2.0/hw
    ../../../../../middleware/wifi_qca/include/AR6002/hw2.0/hw/: hw20_gpio_reg.h hw20_apb_map.h hw20_vmc_reg.h hw20_uart_reg.h hw20_si_reg.h hw20_rtc_reg.h hw20_mbox_reg.h hw20_mbox_host_reg.h
  group wifi_qca/include/AR6002/hw4.0/hw
    ../../../../../middleware/wifi_qca/include/AR6002/hw4.0/hw/: hw40_rtc_wlan_reg.h hw40_rtc_reg.h
  group amazon-freertos/FreeRTOS
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos/FreeRTOS/portable
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM4F/: fsl_tickless_systick.c fsl_tickless_generic.h port.c portasm.s portmacro.h
  group amazon-freertos/license
    ../../../../../rtos/amazon-freertos/: LICENSE
  group amazon-freertos/include
    ../../../../../rtos/amazon-freertos/lib/include/: event_groups.h FreeRTOS.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
    ../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_wrappers.h portable.h projdefs.h stack_macros.h
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.h fsl_lpspi_edma.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: uart.h lpuart_adapter.c
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: generic_list.h generic_list.c
  group startup
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h evkmimxrt1060_sdram_ini_dcd.c evkmimxrt1060_sdram_ini_dcd.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
