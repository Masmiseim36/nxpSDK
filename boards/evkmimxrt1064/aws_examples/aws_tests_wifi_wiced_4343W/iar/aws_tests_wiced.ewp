# IAR project aws_tests_wiced.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1064xxx6A NXP MIMXRT1064xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0; CPU_MIMXRT1064DVL6A; HIGH_SPEED_SDIO_CLOCK; USE_RTOS=1; MBEDTLS_CONFIG_FILE="aws_mbedtls_config.h"; UNITY_INCLUDE_CONFIG_H; LWIP_NETIF_API=1; AMAZON_FREERTOS_ENABLE_UNIT_TESTS; FSL_RTOS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1; WIFI_WICED; SDK_DEBUGCONSOLE_UART
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.IExtraOptions: --diag_suppress Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/amazon-freertos/freertos_kernel/portable/IAR/ARM_CM4F; ../../..; ../../aws_tests_wifi_wiced; ..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../rtos/amazon-freertos/demos/dev_mode_key_provisioning/include; ../../../../../rtos/amazon-freertos/libraries/3rdparty/unity/extras/fixture/src; ../../../../../rtos/amazon-freertos/libraries/3rdparty/unity/src; ../../../../../rtos/amazon-freertos/libraries/abstractions/wifi/test; ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/mqtt/test/access; ../../../../../rtos/amazon-freertos/libraries/freertos_plus/aws/greengrass/test; ../../../../../rtos/amazon-freertos/tests/include; ../../../../../rtos/amazon-freertos/libraries/abstractions/wifi/include; ../../../../../rtos/amazon-freertos/libraries/freertos_plus/aws/greengrass/include; ../../../../../rtos/amazon-freertos/libraries/freertos_plus/aws/greengrass/src; ../../../../../rtos/amazon-freertos/freertos_kernel/include; ../../../../../rtos/amazon-freertos/libraries/abstractions/platform/freertos/include; ../../../../../rtos/amazon-freertos/libraries/abstractions/platform/include; ../../../../../rtos/amazon-freertos/libraries/c_sdk/aws/shadow/include; ../../../../../rtos/amazon-freertos/libraries/c_sdk/aws/shadow/src; ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/common/include; ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/common/include/private; ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/mqtt/include; ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/mqtt/src; ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/serializer/include; ../../../../../rtos/amazon-freertos/libraries/abstractions/secure_sockets/include; ../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/crypto/include; ../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/pkcs11/include; ../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/utils/include; ../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/tls/include; ../../../../../rtos/amazon-freertos/libraries/abstractions/pkcs11/include; ../../../../../rtos/amazon-freertos/libraries/abstractions/pkcs11/mbedtls; ../../../../../rtos/amazon-freertos/libraries/3rdparty/pkcs11; ../../../../../rtos/amazon-freertos/libraries/3rdparty/jsmn; ../../../../../middleware/mbedtls/include; ../../../../../middleware/mbedtls/port/ksdk; ../config_files; ../../../../../devices/MIMXRT1064/drivers; ../../../../../devices/MIMXRT1064/drivers; ../../../../../devices/MIMXRT1064/drivers; ../../../../../devices/MIMXRT1064/drivers; ../../../../../rtos/amazon-freertos/vendors/nxp/mflash/mimxrt1064; ../../../../../devices/MIMXRT1064/drivers; ../../../../../middleware/sdmmc/port; ../../../../../middleware/sdmmc/port; ../../../../../middleware/lwip/port; ../../../../../middleware/lwip/src; ../../../../../middleware/lwip/src/include; ../../../../../middleware/wiced/43xxx_Wi-Fi/platforms/MURATA_TYPE1DX; ../../../../../devices/MIMXRT1064/drivers; ../../../../../devices/MIMXRT1064/drivers; ../../../../../devices/MIMXRT1064; ../../../../../devices/MIMXRT1064/utilities/str; ../../../../../devices/MIMXRT1064/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../components/serial_manager; ../../../../../devices/MIMXRT1064/drivers; ../../../../../devices/MIMXRT1064/drivers; ../../../../../devices/MIMXRT1064/drivers; ../../../../../devices/MIMXRT1064/xip; ../../../xip; ../../../xip; ../../../../../middleware/sdmmc/inc; ../../../../../middleware/sdmmc/src; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/chips/4343W; ../../../../../middleware/wiced/43xxx_Wi-Fi/include; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/network/LwIP/WWD; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/include; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/WWD; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/RTOS/FreeRTOS/WWD; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/network; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/platform; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/RTOS; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/SDIO; ../../../../../middleware/lwip/src/include/lwip; ../../../../../devices/MIMXRT1064/utilities
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ../../..; ../../aws_tests_wifi_wiced; ../config_files; ..
  ILINK.IlinkOutputFile: aws_tests_wiced.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x2000
  ILINK.IlinkIcfFile: ../linker/MIMXRT1064xxxxx_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0; CPU_MIMXRT1064DVL6A; HIGH_SPEED_SDIO_CLOCK; USE_RTOS=1; MBEDTLS_CONFIG_FILE="aws_mbedtls_config.h"; UNITY_INCLUDE_CONFIG_H; LWIP_NETIF_API=1; AMAZON_FREERTOS_ENABLE_UNIT_TESTS; FSL_RTOS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1; WIFI_WICED; SDK_DEBUGCONSOLE_UART
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source
    ../application_code/: main.c
  group configs
    ../config_files/: aws_bufferpool_config.h aws_ggd_config.h aws_mbedtls_config.h aws_mqtt_config.h aws_secure_sockets_config.h aws_shadow_config.h aws_test_runner_config.h aws_test_tcp_config.h aws_test_wifi_config.h aws_wifi_config.h FreeRTOSConfig.h FreeRTOSIPConfig.h iot_config.h iot_mqtt_agent_config.h iot_pkcs11_config.h iot_test_pkcs11_config.h unity_config.h lwipopts.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1064/drivers/: fsl_trng.c fsl_trng.h fsl_dcp.c fsl_dcp.h fsl_cache.c fsl_cache.h fsl_flexspi.c fsl_flexspi.h fsl_usdhc.c fsl_usdhc.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h fsl_gpio.c fsl_gpio.h
  group amazon-freertos/vendors/nxp/mflash/mimxrt1064
    ../../../../../rtos/amazon-freertos/vendors/nxp/mflash/mimxrt1064/: mflash_drv.c mflash_drv.h mflash_file.c mflash_file.h
  group amazon-freertos/vendors/nxp/wifi/wiced
    ../../../../../rtos/amazon-freertos/vendors/nxp/wifi/wiced/: iot_wifi.c
  group amazon-freertos/vendors/nxp/secure_sockets/lwip
    ../../../../../rtos/amazon-freertos/vendors/nxp/secure_sockets/lwip/: iot_secure_sockets.c
  group amazon-freertos/vendors/nxp/pkcs11/common
    ../../../../../rtos/amazon-freertos/vendors/nxp/pkcs11/common/: iot_pkcs11_pal.c
  group amazon-freertos/demos/dev_mode_key_provisioning/include
    ../../../../../rtos/amazon-freertos/demos/dev_mode_key_provisioning/include/: aws_dev_mode_key_provisioning.h
  group amazon-freertos/demos/dev_mode_key_provisioning/src
    ../../../../../rtos/amazon-freertos/demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c
  group amazon-freertos/libraries/3rdparty/mbedtls/utils
    ../../../../../rtos/amazon-freertos/libraries/3rdparty/mbedtls/utils/: mbedtls_utils.c
  group amazon-freertos/libraries/3rdparty/unity/extras/fixture/src
    ../../../../../rtos/amazon-freertos/libraries/3rdparty/unity/extras/fixture/src/: unity_fixture.c unity_fixture.h unity_fixture_internals.h unity_fixture_malloc_overrides.h
  group amazon-freertos/libraries/3rdparty/unity/src
    ../../../../../rtos/amazon-freertos/libraries/3rdparty/unity/src/: unity.c unity.h unity_internals.h
  group amazon-freertos/libraries/3rdparty/pkcs11
    ../../../../../rtos/amazon-freertos/libraries/3rdparty/pkcs11/: pkcs11.h pkcs11f.h pkcs11t.h
  group amazon-freertos/libraries/3rdparty/jsmn
    ../../../../../rtos/amazon-freertos/libraries/3rdparty/jsmn/: jsmn.c jsmn.h
  group amazon-freertos/libraries/abstractions/pkcs11/test
    ../../../../../rtos/amazon-freertos/libraries/abstractions/pkcs11/test/: iot_test_pkcs11.c
  group amazon-freertos/libraries/abstractions/pkcs11/include
    ../../../../../rtos/amazon-freertos/libraries/abstractions/pkcs11/include/: iot_pkcs11_pal.h
  group amazon-freertos/libraries/abstractions/pkcs11/mbedtls
    ../../../../../rtos/amazon-freertos/libraries/abstractions/pkcs11/mbedtls/: iot_pkcs11_mbedtls.c threading_alt.h
  group amazon-freertos/libraries/abstractions/secure_sockets/test
    ../../../../../rtos/amazon-freertos/libraries/abstractions/secure_sockets/test/: iot_test_tcp.c
  group amazon-freertos/libraries/abstractions/secure_sockets/include
    ../../../../../rtos/amazon-freertos/libraries/abstractions/secure_sockets/include/: iot_secure_sockets.h iot_secure_sockets_config_defaults.h iot_secure_sockets_wrapper_metrics.h
  group amazon-freertos/libraries/abstractions/wifi/test
    ../../../../../rtos/amazon-freertos/libraries/abstractions/wifi/test/: iot_test_wifi.c iot_test_wifi.h
  group amazon-freertos/libraries/abstractions/wifi/include
    ../../../../../rtos/amazon-freertos/libraries/abstractions/wifi/include/: iot_wifi.h
  group amazon-freertos/libraries/abstractions/platform/freertos
    ../../../../../rtos/amazon-freertos/libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_metrics.c iot_network_freertos.c iot_threads_freertos.c
  group amazon-freertos/libraries/abstractions/platform/freertos/include/platform
    ../../../../../rtos/amazon-freertos/libraries/abstractions/platform/freertos/include/platform/: iot_network_ble.h iot_network_freertos.h iot_platform_types_freertos.h
  group amazon-freertos/libraries/abstractions/platform/include/platform
    ../../../../../rtos/amazon-freertos/libraries/abstractions/platform/include/platform/: iot_clock.h iot_metrics.h iot_network.h iot_threads.h
  group amazon-freertos/libraries/abstractions/platform/include/types
    ../../../../../rtos/amazon-freertos/libraries/abstractions/platform/include/types/: iot_platform_types.h
  group amazon-freertos/libraries/c_sdk/aws/shadow/test
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/aws/shadow/test/: aws_test_shadow.c
  group amazon-freertos/libraries/c_sdk/aws/shadow/test/system
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/aws/shadow/test/system/: aws_iot_tests_shadow_system.c
  group amazon-freertos/libraries/c_sdk/aws/shadow/test/unit
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/aws/shadow/test/unit/: aws_iot_tests_shadow_api.c aws_iot_tests_shadow_parser.c
  group amazon-freertos/libraries/c_sdk/aws/shadow/include
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/aws/shadow/include/: aws_iot_shadow.h aws_shadow.h
  group amazon-freertos/libraries/c_sdk/aws/shadow/include/types
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/aws/shadow/include/types/: aws_iot_shadow_types.h
  group amazon-freertos/libraries/c_sdk/aws/shadow/src
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/aws/shadow/src/: aws_iot_shadow_api.c aws_iot_shadow_operation.c aws_iot_shadow_parser.c aws_iot_shadow_static_memory.c aws_iot_shadow_subscription.c aws_shadow.c aws_shadow_config_defaults.h
  group amazon-freertos/libraries/c_sdk/aws/shadow/src/private
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/aws/shadow/src/private/: aws_iot_shadow_internal.h
  group amazon-freertos/libraries/c_sdk/standard/common
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/common/: iot_device_metrics.c iot_init.c iot_static_memory_common.c
  group amazon-freertos/libraries/c_sdk/standard/common/test
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/common/test/: iot_memory_leak.c iot_tests_taskpool.c
  group amazon-freertos/libraries/c_sdk/standard/common/include
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/common/include/: iot_appversion32.h iot_atomic.h iot_init.h iot_linear_containers.h iot_logging_setup.h iot_logging_task.h iot_taskpool.h
  group amazon-freertos/libraries/c_sdk/standard/common/include/private
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/common/include/private/: iot_default_root_certificates.h iot_doubly_linked_list.h iot_error.h iot_lib_init.h iot_logging.h iot_static_memory.h iot_taskpool_internal.h
  group amazon-freertos/libraries/c_sdk/standard/common/include/types
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/common/include/types/: iot_network_types.h iot_taskpool_types.h
  group amazon-freertos/libraries/c_sdk/standard/common/logging
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/common/logging/: iot_logging.c iot_logging_task_dynamic_buffers.c
  group amazon-freertos/libraries/c_sdk/standard/common/taskpool
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group amazon-freertos/libraries/c_sdk/standard/mqtt/test
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/mqtt/test/: iot_test_mqtt_agent.c
  group amazon-freertos/libraries/c_sdk/standard/mqtt/test/access
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/mqtt/test/access/: iot_test_access_mqtt.h
  group amazon-freertos/libraries/c_sdk/standard/mqtt/test/system
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/mqtt/test/system/: iot_tests_mqtt_system.c
  group amazon-freertos/libraries/c_sdk/standard/mqtt/test/unit
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/mqtt/test/unit/: iot_tests_mqtt_api.c iot_tests_mqtt_metrics.c iot_tests_mqtt_receive.c iot_tests_mqtt_subscription.c iot_tests_mqtt_validate.c
  group amazon-freertos/libraries/c_sdk/standard/mqtt/include
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/mqtt/include/: iot_mqtt.h iot_mqtt_agent.h iot_mqtt_agent_config_defaults.h iot_mqtt_config_defaults.h iot_mqtt_lib.h
  group amazon-freertos/libraries/c_sdk/standard/mqtt/include/types
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/mqtt/include/types/: iot_mqtt_types.h
  group amazon-freertos/libraries/c_sdk/standard/mqtt/src
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/mqtt/src/: iot_mqtt_agent.c iot_mqtt_api.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_serialize.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_validate.c
  group amazon-freertos/libraries/c_sdk/standard/mqtt/src/private
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/mqtt/src/private/: iot_mqtt_internal.h
  group amazon-freertos/libraries/c_sdk/standard/serializer/include
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/serializer/include/: iot_json_utils.h iot_serializer.h
  group amazon-freertos/libraries/c_sdk/standard/serializer/src
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/serializer/src/: iot_json_utils.c iot_serializer_static_memory.c
  group amazon-freertos/libraries/c_sdk/standard/serializer/src/json
    ../../../../../rtos/amazon-freertos/libraries/c_sdk/standard/serializer/src/json/: iot_serializer_json_decoder.c iot_serializer_json_encoder.c
  group amazon-freertos/libraries/freertos_plus/aws/greengrass/test
    ../../../../../rtos/amazon-freertos/libraries/freertos_plus/aws/greengrass/test/: aws_greengrass_discovery_test_access_declare.h aws_greengrass_discovery_test_access_define.h aws_test_greengrass_discovery.c aws_test_helper_secure_connect.c
  group amazon-freertos/libraries/freertos_plus/aws/greengrass/include
    ../../../../../rtos/amazon-freertos/libraries/freertos_plus/aws/greengrass/include/: aws_ggd_config_defaults.h aws_greengrass_discovery.h
  group amazon-freertos/libraries/freertos_plus/aws/greengrass/src
    ../../../../../rtos/amazon-freertos/libraries/freertos_plus/aws/greengrass/src/: aws_greengrass_discovery.c aws_helper_secure_connect.c aws_helper_secure_connect.h
  group amazon-freertos/libraries/freertos_plus/standard/crypto/test
    ../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/crypto/test/: iot_test_crypto.c
  group amazon-freertos/libraries/freertos_plus/standard/crypto/include
    ../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/crypto/include/: iot_crypto.h
  group amazon-freertos/libraries/freertos_plus/standard/crypto/src
    ../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group amazon-freertos/libraries/freertos_plus/standard/tls/test
    ../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/tls/test/: iot_test_tls.c iot_test_tls.h
  group amazon-freertos/libraries/freertos_plus/standard/tls/include
    ../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/tls/include/: iot_tls.h
  group amazon-freertos/libraries/freertos_plus/standard/tls/src
    ../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group amazon-freertos/libraries/freertos_plus/standard/pkcs11/include
    ../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/pkcs11/include/: iot_pkcs11.h
  group amazon-freertos/libraries/freertos_plus/standard/pkcs11/src
    ../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/pkcs11/src/: iot_pkcs11.c
  group amazon-freertos/libraries/freertos_plus/standard/utils/include
    ../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/utils/include/: iot_pki_utils.h iot_system_init.h
  group amazon-freertos/libraries/freertos_plus/standard/utils/src
    ../../../../../rtos/amazon-freertos/libraries/freertos_plus/standard/utils/src/: iot_pki_utils.c iot_system_init.c
  group amazon-freertos/tests/common
    ../../../../../rtos/amazon-freertos/tests/common/: aws_test.c aws_test_framework.c aws_test_runner.c iot_test_freertos.c iot_tests_network.c
  group amazon-freertos/tests/include
    ../../../../../rtos/amazon-freertos/tests/include/: aws_application_version.h aws_clientcredential.h aws_clientcredential_keys.h aws_test_framework.h aws_test_runner.h aws_test_tcp.h aws_test_utils.h aws_unity_config.h iot_config_common.h
  group amazon-freertos/freertos_kernel
    ../../../../../rtos/amazon-freertos/freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos/freertos_kernel/include
    ../../../../../rtos/amazon-freertos/freertos_kernel/include/: FreeRTOS.h atomic.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group amazon-freertos/freertos_kernel/portable
    ../../../../../rtos/amazon-freertos/freertos_kernel/portable/: readme.txt
  group amazon-freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../rtos/amazon-freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group amazon-freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/amazon-freertos/freertos_kernel/portable/MemMang/: ReadMe.url heap_4.c
  group sdmmc
    ../../../../../middleware/sdmmc/: ChangeLogKSDK.txt ChangeLogKSDK.txt ChangeLogKSDK.txt
  group sdmmc/inc
    ../../../../../middleware/sdmmc/inc/: fsl_sdio.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
  group sdmmc/src
    ../../../../../middleware/sdmmc/src/: fsl_sdio.c fsl_sdmmc_common.c
  group sdmmc/port
    ../../../../../middleware/sdmmc/port/: fsl_sdmmc_event.h
    ../../../../../middleware/sdmmc/port/usdhc/freertos/: fsl_sdmmc_event.c fsl_sdmmc_host.c
  group lwip/port
    ../../../../../middleware/lwip/port/: sys_arch.c
  group lwip/port/arch
    ../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src/api
    ../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/core
    ../../../../../middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/src/core/ipv4
    ../../../../../middleware/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/src/core/ipv6
    ../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip/src/include/compat/posix
    ../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/compat/posix/net
    ../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/sys
    ../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/stdc
    ../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/lwip
    ../../../../../middleware/lwip/src/include/lwip/: altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/priv
    ../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../middleware/lwip/src/include/lwip/prot/: autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip/src/include/netif
    ../../../../../middleware/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lwip/src/include/netif/ppp
    ../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip/src/netif
    ../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group wiced/43xxx_Wi-Fi
    ../../../../../middleware/wiced/43xxx_Wi-Fi/: generated_mac_address.txt
  group wiced/43xxx_Wi-Fi/platforms/MURATA_TYPE1DX
    ../../../../../middleware/wiced/43xxx_Wi-Fi/platforms/MURATA_TYPE1DX/: wifi_nvram_image.h
  group wiced/43xxx_Wi-Fi/WICED/WWD
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/: wwd.h wwd_wiced.h
  group wiced/43xxx_Wi-Fi/WICED/WWD/internal
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/: tlv.c tlv.h wwd_ap.h wwd_ap_common.c wwd_ap_common.h wwd_bcmendian.h wwd_clm.c wwd_clm.h wwd_debug.c wwd_eapol.c wwd_internal.c wwd_internal.h wwd_logging.h wwd_management.c wwd_rtos_interface.c wwd_sdpcm.c wwd_sdpcm.h wwd_thread.c wwd_thread.h wwd_thread_internal.c wwd_thread_internal.h wwd_wifi.c wwd_wifi_chip_common.c wwd_wifi_chip_common.h wwd_wifi_sleep.c
  group wiced/43xxx_Wi-Fi/WICED/WWD/internal/chips/4343W
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/chips/4343W/: 4343WA1.h 4343WA1_clm.h 4343WA1_clm_mfg.h 4343WA1_mfg.h chip_constants.h resources.c resources.h wwd_ap.c wwd_chip_specific_functions.c
  group wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/: wwd_bus_common.c wwd_bus_protocol_interface.h
  group wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/SDIO
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/SDIO/: wwd_bus_protocol.c wwd_bus_protocol.h
  group wiced/43xxx_Wi-Fi/WICED/WWD/include
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/: wwd_assert.h wwd_constants.h wwd_debug.h wwd_eapol.h wwd_events.h wwd_management.h wwd_poll.h wwd_structures.h wwd_wifi.h wwd_wifi_sleep.h wwd_wlioctl.h
  group wiced/43xxx_Wi-Fi/WICED/WWD/include/RTOS
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/RTOS/: wwd_rtos_interface.h
  group wiced/43xxx_Wi-Fi/WICED/WWD/include/network
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/network/: wwd_buffer_interface.h wwd_network_constants.h wwd_network_interface.h
  group wiced/43xxx_Wi-Fi/WICED/WWD/include/platform
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/platform/: wwd_bus_interface.h wwd_platform_interface.h wwd_resource_interface.h wwd_sdio_interface.h wwd_spi_interface.h
  group wiced/43xxx_Wi-Fi/WICED/RTOS/FreeRTOS/WWD
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/RTOS/FreeRTOS/WWD/: wwd_FreeRTOS_systick.h wwd_rtos.c wwd_rtos.h
  group wiced/43xxx_Wi-Fi/WICED/internal
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/internal/: wifi.c
  group wiced/43xxx_Wi-Fi/WICED/network/LwIP/WWD
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/network/LwIP/WWD/: wwd_buffer.c wwd_buffer.h wwd_network.c wwd_network.h
  group wiced/43xxx_Wi-Fi/WICED/platform
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/: platform_toolchain.h
  group wiced/43xxx_Wi-Fi/WICED/platform/MCU
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/: wwd_platform_common.h wwd_platform_separate_mcu.c wwd_resources.c
  group wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/: platform_mcu_peripheral.h
  group wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/WWD
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/WWD/: wwd_SDIO.c wwd_platform.c
  group wiced/43xxx_Wi-Fi/WICED/platform/include
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/include/: platform_cache_def.h platform_peripheral.h
  group wiced/43xxx_Wi-Fi/include
    ../../../../../middleware/wiced/43xxx_Wi-Fi/include/: wiced_resource.h
  group mbedtls/include/mbedtls
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/library
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/port/ksdk
    ../../../../../middleware/mbedtls/port/ksdk/: aes_alt.c aes_alt.h des_alt.c des_alt.h ecp_alt.c ecp_alt.h ecp_alt_ksdk.c ecp_curves_alt.c ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h
  group device
    ../../../../../devices/MIMXRT1064/: MIMXRT1064.h MIMXRT1064_features.h fsl_device_registers.h system_MIMXRT1064.c system_MIMXRT1064.h
  group utilities
    ../../../../../devices/MIMXRT1064/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1064/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1064/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MIMXRT1064/iar/: startup_MIMXRT1064.s
  group xip
    ../../../../../devices/MIMXRT1064/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../xip/: evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_flexspi_nor_config.h evkmimxrt1064_sdram_ini_dcd.c evkmimxrt1064_sdram_ini_dcd.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
