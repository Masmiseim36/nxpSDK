# IAR project netx_duo_iperf.ewp, settings and files
configuration sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1064xxx6A NXP MIMXRT1064xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; DEBUG; CPU_MIMXRT1064DVL6A; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; TX_INCLUDE_USER_DEFINE_FILE; FX_INCLUDE_USER_DEFINE_FILE; NX_INCLUDE_USER_DEFINE_FILE
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/azure-rtos/netxduo/ports/cortex_m7/iar/inc; ../../../../../rtos/azure-rtos/filex/ports/cortex_m7/iar/inc; ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/iar/inc; ..; ../../..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../rtos/azure-rtos/netxduo/addons/auto_ip; ../../../../../rtos/azure-rtos/netxduo/addons/BSD; ../../../../../rtos/azure-rtos/netxduo/addons/dhcp; ../../../../../rtos/azure-rtos/netxduo/addons/dns; ../../../../../rtos/azure-rtos/netxduo/addons/ftp; ../../../../../rtos/azure-rtos/netxduo/addons/http; ../../../../../rtos/azure-rtos/netxduo/addons/mdns; ../../../../../rtos/azure-rtos/netxduo/addons/mqtt; ../../../../../rtos/azure-rtos/netxduo/addons/nat; ../../../../../rtos/azure-rtos/netxduo/addons/pop3; ../../../../../rtos/azure-rtos/netxduo/addons/ppp; ../../../../../rtos/azure-rtos/netxduo/addons/pppoe; ../../../../../rtos/azure-rtos/netxduo/addons/smtp; ../../../../../rtos/azure-rtos/netxduo/addons/snmp; ../../../../../rtos/azure-rtos/netxduo/addons/sntp; ../../../../../rtos/azure-rtos/netxduo/addons/telnet; ../../../../../rtos/azure-rtos/netxduo/addons/tftp; ../../../../../rtos/azure-rtos/netxduo/addons/web; ../../../../../rtos/azure-rtos/netxduo/common/inc; ../../../../../rtos/azure-rtos/netxduo/crypto_libraries/inc; ../../../../../rtos/azure-rtos/netxduo/nx_secure/inc; ../../../../../rtos/azure-rtos/netxduo/nx_secure/ports; ../../../../../rtos/azure-rtos/filex/common/inc; ../../../../../rtos/azure-rtos/threadx/common/inc; ../../../../../components/phyksz8081; ../../../../../devices/MIMXRT1064/drivers; ../../../../../devices/MIMXRT1064; ../../../../../devices/MIMXRT1064/utilities/str; ../../../../../devices/MIMXRT1064/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../devices/MIMXRT1064/xip; ../../../xip; ../../../../../devices/MIMXRT1064/utilities
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: netx_duo_iperf.out
  ILINK.IlinkIcfFile: MIMXRT1064xxxxx_sdram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../rtos/azure-rtos/binary/netxduo/iar/libnetxduo.a; ../../../../../rtos/azure-rtos/binary/filex/iar/libfilex.a; ../../../../../rtos/azure-rtos/binary/threadx/iar/libthreadx.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1064DVL6A; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; TX_INCLUDE_USER_DEFINE_FILE; FX_INCLUDE_USER_DEFINE_FILE; NX_INCLUDE_USER_DEFINE_FILE
  ILINK.IlinkIcfFile: MIMXRT1064xxxxx_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1064DVL6A; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; TX_INCLUDE_USER_DEFINE_FILE; FX_INCLUDE_USER_DEFINE_FILE; NX_INCLUDE_USER_DEFINE_FILE
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1064DVL6A; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; TX_INCLUDE_USER_DEFINE_FILE; FX_INCLUDE_USER_DEFINE_FILE; NX_INCLUDE_USER_DEFINE_FILE
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1064xxxxx_flexspi_nor.icf
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
    ../../../../../components/phyksz8081/: fsl_phy.c fsl_phy.h
  group source
    ../: netx_duo_iperf.c nx_iperf.c nx_iperf.h
  group ports
    ../: tx_user.h tx_initialize_low_level_iar.s fx_user.h nx_driver_imxrt_irq.c nx_driver_imxrt.c nx_driver_imxrt.h nx_user.h
  group drivers
    ../../../../../devices/MIMXRT1064/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h fsl_gpio.c fsl_gpio.h fsl_enet.c fsl_enet.h
  group device
    ../../../../../devices/MIMXRT1064/: MIMXRT1064.h MIMXRT1064_features.h fsl_device_registers.h system_MIMXRT1064.c system_MIMXRT1064.h
  group utilities
    ../../../../../devices/MIMXRT1064/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1064/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1064/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MIMXRT1064/iar/: startup_MIMXRT1064.s
  group xip
    ../../../../../devices/MIMXRT1064/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../xip/: evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
