# Keil uVision project usbx_device_mass_storage.uvprojx, settings and files
target usbx_device_mass_storage debug (ARM-ADS)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.2.4.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: usbx_device_mass_storage.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: DEBUG, __CLANG_ARM, CPU_MIMXRT1064DVL6A, MIMXRT, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, UX_OTG_SUPPORT, UX_INCLUDE_USER_DEFINE_FILE, NX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../middleware/usb/include;../../../../../middleware/usb/phy;../../../../../components/osa;..;../usbx_device_controllers;../../../../../devices/MIMXRT1064/drivers;../../../../../devices/MIMXRT1064;../../../../../devices/MIMXRT1064/utilities/str;../../../../../devices/MIMXRT1064/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../devices/MIMXRT1064/xip;../../../xip;../../../../../rtos/azure-rtos/usbx/common/core/inc;../../../../../rtos/azure-rtos/usbx/common/usbx_device_classes/inc;../../../../../rtos/azure-rtos/usbx/common/usbx_host_classes/inc;../../../../../rtos/azure-rtos/usbx/common/usbx_host_controllers/inc;../../../../../rtos/azure-rtos/usbx/common/usbx_network/inc;../../../../../rtos/azure-rtos/usbx/common/usbx_pictbridge/inc;../../../../../rtos/azure-rtos/usbx/ports/cortex_m7/ac6/inc;../../../../../rtos/azure-rtos/netxduo/addons/auto_ip;../../../../../rtos/azure-rtos/netxduo/addons/cloud;../../../../../rtos/azure-rtos/netxduo/addons/BSD;../../../../../rtos/azure-rtos/netxduo/addons/dhcp;../../../../../rtos/azure-rtos/netxduo/addons/dns;../../../../../rtos/azure-rtos/netxduo/addons/ftp;../../../../../rtos/azure-rtos/netxduo/addons/http;../../../../../rtos/azure-rtos/netxduo/addons/mdns;../../../../../rtos/azure-rtos/netxduo/addons/mqtt;../../../../../rtos/azure-rtos/netxduo/addons/nat;../../../../../rtos/azure-rtos/netxduo/addons/pop3;../../../../../rtos/azure-rtos/netxduo/addons/ppp;../../../../../rtos/azure-rtos/netxduo/addons/pppoe;../../../../../rtos/azure-rtos/netxduo/addons/smtp;../../../../../rtos/azure-rtos/netxduo/addons/snmp;../../../../../rtos/azure-rtos/netxduo/addons/sntp;../../../../../rtos/azure-rtos/netxduo/addons/telnet;../../../../../rtos/azure-rtos/netxduo/addons/tftp;../../../../../rtos/azure-rtos/netxduo/addons/web;../../../../../rtos/azure-rtos/netxduo/common/inc;../../../../../rtos/azure-rtos/netxduo/crypto_libraries/inc;../../../../../rtos/azure-rtos/netxduo/nx_secure/inc;../../../../../rtos/azure-rtos/netxduo/nx_secure/ports;../../../../../rtos/azure-rtos/netxduo/ports/cortex_m7/ac6/inc;../../../../../rtos/azure-rtos/filex/common/inc;../../../../../rtos/azure-rtos/filex/ports/cortex_m7/ac6/inc;../../../../../rtos/azure-rtos/threadx/common/inc;../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc;../../../../../CMSIS/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA, TX_ENABLE_FPU_SUPPORT
  library: MicroLIB
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1064xxxxx_ram.scf
  link misc: ../../../../../rtos/azure-rtos/binary/usbx/mdk/libusbx.lib ../../../../../rtos/azure-rtos/binary/netxduo/mdk/libnetxduo.lib ../../../../../rtos/azure-rtos/binary/filex/mdk/libfilex.lib ../../../../../rtos/azure-rtos/binary/threadx/mdk/libthreadx.lib --remove
  group board
    ../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
    ../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
    ../: pin_mux.c pin_mux.h board_setup.c board_setup.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group source
    ../: usbx_device_mass_storage.c
  group ports
    ../: tx_user.h fx_user.h nx_user.h ux_dcd_interrupt_handler.c ux_user.h
  group ports/usbx
    ../usbx_device_controllers/: ux_dcd_mcimx6.h ux_dcd_mcimx6_address_set.c ux_dcd_mcimx6_endpoint_address_get.c ux_dcd_mcimx6_endpoint_create.c ux_dcd_mcimx6_endpoint_destroy.c ux_dcd_mcimx6_endpoint_flush.c ux_dcd_mcimx6_endpoint_reset.c ux_dcd_mcimx6_endpoint_stall.c ux_dcd_mcimx6_endpoint_stall_clear.c ux_dcd_mcimx6_endpoint_status.c ux_dcd_mcimx6_frame_number_get.c ux_dcd_mcimx6_function.c ux_dcd_mcimx6_initialize.c ux_dcd_mcimx6_initialize_complete.c ux_dcd_mcimx6_interrupt_handler.c ux_dcd_mcimx6_interrupt_thread.c ux_dcd_mcimx6_qtd_get.c ux_dcd_mcimx6_register_clear.c ux_dcd_mcimx6_register_read.c ux_dcd_mcimx6_register_set.c ux_dcd_mcimx6_register_write.c ux_dcd_mcimx6_state_change.c ux_dcd_mcimx6_status_phase_hook.c ux_dcd_mcimx6_transfer_abort.c ux_dcd_mcimx6_transfer_callback.c ux_dcd_mcimx6_transfer_request.c
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1064/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group device
    ../../../../../devices/MIMXRT1064/: fsl_device_registers.h MIMXRT1064.h MIMXRT1064_features.h system_MIMXRT1064.c system_MIMXRT1064.h
  group utilities
    ../../../../../devices/MIMXRT1064/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1064/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1064/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1064/arm/: startup_MIMXRT1064.S
  group xip
    ../../../../../devices/MIMXRT1064/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_flexspi_nor_config.h
  group azure-rtos/usbx/common/core/inc
    ../../../../../rtos/azure-rtos/usbx/common/core/inc/: ux_host_class_dpump.h ux_device_class_dpump.h ux_utility.h ux_hcd_sim_host.h ux_dcd_sim_slave.h ux_device_stack.h ux_host_stack.h ux_system.h ux_api.h ux_user_sample.h
  group azure-rtos/usbx/common/usbx_device_classes/inc
    ../../../../../rtos/azure-rtos/usbx/common/usbx_device_classes/inc/: ux_device_class_rndis.h ux_device_class_storage.h ux_device_class_audio.h ux_device_class_cdc_ecm.h ux_device_class_pima.h ux_device_class_cdc_acm.h ux_device_class_audio20.h ux_device_class_audio10.h ux_device_class_hid.h ux_device_class_dfu.h
  group azure-rtos/usbx/common/usbx_host_classes/inc
    ../../../../../rtos/azure-rtos/usbx/common/usbx_host_classes/inc/: ux_host_class_pima.h ux_host_class_cdc_acm.h ux_host_class_hub.h ux_host_class_cdc_ecm.h ux_host_class_hid_keyboard.h ux_host_class_audio.h ux_host_class_hid.h ux_host_class_hid_mouse.h ux_host_class_printer.h ux_host_class_swar.h ux_host_class_asix.h ux_host_class_video.h ux_host_class_prolific.h ux_host_class_gser.h ux_host_class_storage.h ux_host_class_hid_remote_control.h
  group azure-rtos/usbx/common/usbx_host_controllers/inc
    ../../../../../rtos/azure-rtos/usbx/common/usbx_host_controllers/inc/: ux_hcd_ohci.h ux_hcd_ehci.h
  group azure-rtos/usbx/common/usbx_network/inc
    ../../../../../rtos/azure-rtos/usbx/common/usbx_network/inc/: ux_network_driver.h
  group azure-rtos/usbx/common/usbx_pictbridge/inc
    ../../../../../rtos/azure-rtos/usbx/common/usbx_pictbridge/inc/: ux_pictbridge.h
  group azure-rtos/usbx/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/usbx/ports/cortex_m7/ac6/inc/: ux_port.h
  group azure-rtos/netxduo/addons/auto_ip
    ../../../../../rtos/azure-rtos/netxduo/addons/auto_ip/: nx_auto_ip.h
  group azure-rtos/netxduo/addons/cloud
    ../../../../../rtos/azure-rtos/netxduo/addons/cloud/: nx_cloud.h
  group azure-rtos/netxduo/addons/BSD
    ../../../../../rtos/azure-rtos/netxduo/addons/BSD/: nxd_bsd.h
  group azure-rtos/netxduo/addons/dhcp
    ../../../../../rtos/azure-rtos/netxduo/addons/dhcp/: nxd_dhcp_server.h nxd_dhcpv6_server.h nxd_dhcpv6_client.h nxd_dhcp_client.h
  group azure-rtos/netxduo/addons/dns
    ../../../../../rtos/azure-rtos/netxduo/addons/dns/: nxd_dns.h
  group azure-rtos/netxduo/addons/ftp
    ../../../../../rtos/azure-rtos/netxduo/addons/ftp/: nxd_ftp_client.h nxd_ftp_server.h
  group azure-rtos/netxduo/addons/http
    ../../../../../rtos/azure-rtos/netxduo/addons/http/: nxd_http_server.h nxd_http_client.h
  group azure-rtos/netxduo/addons/mdns
    ../../../../../rtos/azure-rtos/netxduo/addons/mdns/: nxd_mdns.h
  group azure-rtos/netxduo/addons/mqtt
    ../../../../../rtos/azure-rtos/netxduo/addons/mqtt/: nxd_mqtt_client.h
  group azure-rtos/netxduo/addons/nat
    ../../../../../rtos/azure-rtos/netxduo/addons/nat/: nx_nat.h
  group azure-rtos/netxduo/addons/pop3
    ../../../../../rtos/azure-rtos/netxduo/addons/pop3/: nxd_pop3_client.h
  group azure-rtos/netxduo/addons/ppp
    ../../../../../rtos/azure-rtos/netxduo/addons/ppp/: nx_ppp.h
  group azure-rtos/netxduo/addons/pppoe
    ../../../../../rtos/azure-rtos/netxduo/addons/pppoe/: nx_pppoe_server.h nx_pppoe_client.h
  group azure-rtos/netxduo/addons/smtp
    ../../../../../rtos/azure-rtos/netxduo/addons/smtp/: nxd_smtp_client.h
  group azure-rtos/netxduo/addons/snmp
    ../../../../../rtos/azure-rtos/netxduo/addons/snmp/: nxd_snmp.h nx_des.h nx_sha1.h
  group azure-rtos/netxduo/addons/sntp
    ../../../../../rtos/azure-rtos/netxduo/addons/sntp/: nxd_sntp_client.h
  group azure-rtos/netxduo/addons/telnet
    ../../../../../rtos/azure-rtos/netxduo/addons/telnet/: nxd_telnet_server.h nxd_telnet_client.h
  group azure-rtos/netxduo/addons/tftp
    ../../../../../rtos/azure-rtos/netxduo/addons/tftp/: nxd_tftp_server.h nxd_tftp_client.h
  group azure-rtos/netxduo/addons/web
    ../../../../../rtos/azure-rtos/netxduo/addons/web/: nx_web_http_server.h nx_tcpserver.h nx_web_http_common.h nx_web_http_client.h
  group azure-rtos/netxduo/common/inc
    ../../../../../rtos/azure-rtos/netxduo/common/inc/: nx_igmp.h nx_ipv4.h nx_packet.h nx_nd_cache.h nx_md5.h nx_icmpv6.h nx_icmp.h nx_user_sample.h nx_tcp.h nx_icmpv4.h nx_arp.h nx_ipv6.h nx_system.h nx_api.h nx_rarp.h nx_mld.h nx_ip.h nx_udp.h
  group azure-rtos/netxduo/crypto_libraries/inc
    ../../../../../rtos/azure-rtos/netxduo/crypto_libraries/inc/: nx_crypto_sha1.h nx_crypto_hmac_md5.h nx_crypto_xcbc_mac.h nx_crypto_hmac.h nx_crypto_ccm.h nx_crypto_dh.h nx_crypto_tls_prf_1.h nx_crypto_const.h nx_crypto_cbc.h nx_crypto_ec.h nx_crypto_md5.h nx_crypto_tls_prf_sha384.h nx_crypto.h nx_crypto_sha5.h nx_crypto_rsa.h nx_crypto_ecdh.h nx_crypto_ecdsa.h nx_crypto_hmac_sha2.h nx_crypto_3des.h nx_crypto_null.h nx_crypto_drbg.h nx_crypto_phash.h nx_crypto_hmac_sha1.h nx_crypto_gcm.h nx_crypto_tls_prf_sha256.h nx_crypto_sha2.h nx_crypto_pkcs1_v1.5.h nx_crypto_tls_prf_sha512.h nx_crypto_huge_number.h nx_crypto_hmac_sha5.h nx_crypto_ecjpake.h nx_crypto_des.h nx_crypto_ctr.h nx_crypto_aes.h nx_crypto_method_self_test.h nx_crypto_hkdf.h
  group azure-rtos/netxduo/nx_secure/inc
    ../../../../../rtos/azure-rtos/netxduo/nx_secure/inc/: nx_secure_tls_api.h nx_secure_dtls_api.h nx_secure_user_sample.h nx_secure_x509.h nx_secure_dtls.h nx_secure_crypto_table_self_test.h nx_secure_tls.h
  group azure-rtos/netxduo/nx_secure/ports
    ../../../../../rtos/azure-rtos/netxduo/nx_secure/ports/: nx_secure_port.h
  group azure-rtos/netxduo/samples
    ../../../../../rtos/azure-rtos/netxduo/samples/: demo_snmp_helper.h
  group azure-rtos/netxduo/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/netxduo/ports/cortex_m7/ac6/inc/: nx_port.h
  group azure-rtos/filex/common/inc
    ../../../../../rtos/azure-rtos/filex/common/inc/: fx_media.h fx_unicode.h fx_api.h fx_directory_exFAT.h fx_utility.h fx_file.h fx_system.h fx_directory.h fx_user_sample.h fx_fault_tolerant.h
  group azure-rtos/filex/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/filex/ports/cortex_m7/ac6/inc/: fx_port.h
  group azure-rtos/threadx/common/inc
    ../../../../../rtos/azure-rtos/threadx/common/inc/: tx_byte_pool.h tx_event_flags.h tx_timer.h tx_queue.h tx_thread.h tx_mutex.h tx_trace.h tx_initialize.h tx_api.h tx_user_sample.h tx_block_pool.h tx_semaphore.h
  group azure-rtos/threadx/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc/: tx_port.h
  group azure-rtos/threadx/ports/cortex_m7/ac6/src
    ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/src/: tx_initialize_low_level.S
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
target usbx_device_mass_storage flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.2.4.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: usbx_device_mass_storage.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, __CLANG_ARM, CPU_MIMXRT1064DVL6A, MIMXRT, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, UX_OTG_SUPPORT, UX_INCLUDE_USER_DEFINE_FILE, NX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE
  c misc: as above
  c include: as above
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1064xxxxx_flexspi_nor.scf
  link misc: ../../../../../rtos/azure-rtos/binary/usbx/mdk/libusbx.lib ../../../../../rtos/azure-rtos/binary/netxduo/mdk/libnetxduo.lib ../../../../../rtos/azure-rtos/binary/filex/mdk/libfilex.lib ../../../../../rtos/azure-rtos/binary/threadx/mdk/libthreadx.lib --remove --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
target usbx_device_mass_storage release (ARM-ADS)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.2.4.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: usbx_device_mass_storage.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: NDEBUG, __CLANG_ARM, CPU_MIMXRT1064DVL6A, MIMXRT, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, UX_OTG_SUPPORT, UX_INCLUDE_USER_DEFINE_FILE, NX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA, TX_ENABLE_FPU_SUPPORT
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1064xxxxx_ram.scf
  link misc: as above
target usbx_device_mass_storage flexspi_nor_release (ARM-ADS)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.2.4.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: usbx_device_mass_storage.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, __CLANG_ARM, CPU_MIMXRT1064DVL6A, MIMXRT, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, UX_OTG_SUPPORT, UX_INCLUDE_USER_DEFINE_FILE, NX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE
  c misc: as above
  c include: as above
  asm define: as above
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1064xxxxx_flexspi_nor.scf
  link misc: as above
