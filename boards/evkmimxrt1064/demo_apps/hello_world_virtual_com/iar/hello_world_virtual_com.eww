<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>hello_world_virtual_com</project>
        <configuration>sdram_debug</configuration>
      </member>
      <member>
        <project>hello_world_virtual_com</project>
        <configuration>sdram_release</configuration>
      </member>
      <member>
        <project>hello_world_virtual_com</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>hello_world_virtual_com</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>hello_world_virtual_com</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
      <member>
        <project>hello_world_virtual_com</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdram_debug</name>
      <member>
        <project>hello_world_virtual_com</project>
        <configuration>sdram_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdram_release</name>
      <member>
        <project>hello_world_virtual_com</project>
        <configuration>sdram_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>hello_world_virtual_com</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>hello_world_virtual_com</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_debug</name>
      <member>
        <project>hello_world_virtual_com</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_release</name>
      <member>
        <project>hello_world_virtual_com</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/hello_world_virtual_com.ewp</path>
  </project>
</workspace>
