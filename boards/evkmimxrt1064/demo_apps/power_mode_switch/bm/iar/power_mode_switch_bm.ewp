# IAR project power_mode_switch_bm.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1064xxx6A NXP MIMXRT1064xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1064DVL6A; HAL_UART_ADAPTER_FIFO=0; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MIMXRT1064/drivers; ../../../../../../devices/MIMXRT1064; ../../../../../../devices/MIMXRT1064/utilities/str; ../../../../../../devices/MIMXRT1064/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1064/utilities; ../../../../../../devices/MIMXRT1064/xip; ../../../../xip; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: power_mode_switch_bm.out
  ILINK.IlinkIcfFile: MIMXRT1064xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1064DVL6A; HAL_UART_ADAPTER_FIFO=0; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1064xxxxx_flexspi_nor.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1064DVL6A; HAL_UART_ADAPTER_FIFO=0; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1064DVL6A; HAL_UART_ADAPTER_FIFO=0; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1064xxxxx_flexspi_nor.icf
  group source
    ../: power_mode_switch.c power_mode_switch.h lpm.c lpm.h specific.c specific.h
  group board
    ../: pin_mux.c pin_mux.h peripherals.c peripherals.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.md
  group drivers
    ../../../../../../devices/MIMXRT1064/drivers/: fsl_gpc.c fsl_gpc.h fsl_gpt.c fsl_gpt.h fsl_gpio.h fsl_gpio.c fsl_dcdc.c fsl_dcdc.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h
  group device
    ../../../../../../devices/MIMXRT1064/: fsl_device_registers.h MIMXRT1064.h MIMXRT1064_features.h system_MIMXRT1064.c system_MIMXRT1064.h
  group utilities
    ../../../../../../devices/MIMXRT1064/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1064/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1064/utilities/: fsl_assert.c fsl_assert.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMXRT1064/iar/: startup_MIMXRT1064.s
  group xip
    ../../../../../../devices/MIMXRT1064/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_flexspi_nor_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
