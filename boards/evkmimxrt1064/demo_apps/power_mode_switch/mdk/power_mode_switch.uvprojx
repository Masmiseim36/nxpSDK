# Keil uVision project power_mode_switch.uvprojx, settings and files
target power_mode_switch debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.2.4.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: power_mode_switch.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_MIMXRT1064DVL6A, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F;..;../../../../../CMSIS/Include;../../../../../devices;../../..;../../../../../rtos/amazon-freertos/lib/include;../../../../../rtos/amazon-freertos/lib/include/private;../../../../../devices/MIMXRT1064/drivers;../../../../../devices/MIMXRT1064;../../../../../devices/MIMXRT1064/utilities/io;../../../../../devices/MIMXRT1064/utilities/str;../../../../../devices/MIMXRT1064/utilities/log;../../../../../devices/MIMXRT1064/utilities;../../../../../devices/MIMXRT1064/xip
  asm define: DEBUG, NO_CRP, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1064xxxxx_ram.scf
  link misc: --remove
  group source
    ../: power_mode_switch.c power_mode_switch.h FreeRTOSConfig.h lpm.c lpm.h
  group board
    ../: pin_mux.c pin_mux.h
  group board-src
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group amazon-freertos-FreeRTOS-portable
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F/: fsl_tickless_systick.c fsl_tickless_generic.h port.c portmacro.h
  group amazon-freertos-license
    ../../../../../rtos/amazon-freertos/: LICENSE
  group amazon-freertos-include
    ../../../../../rtos/amazon-freertos/lib/include/: event_groups.h FreeRTOS.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
    ../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_wrappers.h portable.h projdefs.h stack_macros.h
  group amazon-freertos-FreeRTOS
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group drivers
    ../../../../../devices/MIMXRT1064/drivers/: fsl_gpc.c fsl_gpc.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_gpt.c fsl_gpt.h fsl_gpio.h fsl_gpio.c fsl_dcdc.c fsl_dcdc.h fsl_semc.h fsl_semc.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h
  group startup
    ../../../../../devices/MIMXRT1064/: system_MIMXRT1064.c system_MIMXRT1064.h
    ../../../../../devices/MIMXRT1064/arm/: startup_MIMXRT1064.s
  group utilities
    ../../../../../devices/MIMXRT1064/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MIMXRT1064/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MIMXRT1064/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1064/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group xip
    ../../../../../devices/MIMXRT1064/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_flexspi_nor_config.h evkmimxrt1064_sdram_ini_dcd.c evkmimxrt1064_sdram_ini_dcd.h
target power_mode_switch flexspi_nor_debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.2.4.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: power_mode_switch.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, CPU_MIMXRT1064DVL6A, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: NO_CRP, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: evkmimxrt1064_power_mode_switch_ca.scf
  link misc: --remove 
--keep=*(.boot_hdr.ivt) 
--keep=*(.boot_hdr.boot_data) 
--keep=*(.boot_hdr.conf) 
--predefine="-DXIP_BOOT_HEADER_ENABLE=1"
target power_mode_switch release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.2.4.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: power_mode_switch.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG, CPU_MIMXRT1064DVL6A, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: NDEBUG, NO_CRP, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1064xxxxx_ram.scf
  link misc: --remove
target power_mode_switch flexspi_nor_release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.2.4.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: power_mode_switch.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1064DVL6A, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: NDEBUG, NO_CRP, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: evkmimxrt1064_power_mode_switch_ca.scf
  link misc: as above
