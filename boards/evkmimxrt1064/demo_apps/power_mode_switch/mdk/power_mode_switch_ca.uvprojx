# Keil uVision project power_mode_switch_ca.uvprojx, settings and files
target power_mode_switch_ca debug (ARM-ADS)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.2.4.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: power_mode_switch_ca.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: DEBUG, CPU_MIMXRT1064DVL6A, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../rtos/amazon-freertos/freertos_kernel/portable/GCC/ARM_CM4F;..;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../rtos/amazon-freertos/freertos_kernel/include;../../../../../devices/MIMXRT1064/drivers;../../../../../devices/MIMXRT1064/drivers;../../../../../devices/MIMXRT1064/drivers;../../../../../devices/MIMXRT1064/drivers;../../../../../devices/MIMXRT1064/drivers;../../../../../devices/MIMXRT1064/drivers;../../../../../devices/MIMXRT1064;../../../../../devices/MIMXRT1064/utilities/str;../../../../../devices/MIMXRT1064/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../components/serial_manager;../../../../../devices/MIMXRT1064/drivers;../../../../../devices/MIMXRT1064/drivers;../../../../../devices/MIMXRT1064/xip;../../../xip;../../../xip;../../../../../devices/MIMXRT1064/utilities
  asm define: DEBUG, NO_CRP, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1064xxxxx_ram.scf
  link misc: --remove
  group source
    ../: FreeRTOSConfig.h lpm.c lpm.h specific.c specific.h power_mode_switch.c power_mode_switch.h
  group board
    ../: pin_mux.c pin_mux.h peripherals.c peripherals.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group amazon-freertos-freertos_kernel-portable-MemMang
    ../../../../../rtos/amazon-freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group drivers
    ../../../../../devices/MIMXRT1064/drivers/: fsl_gpt.c fsl_gpt.h fsl_gpc.c fsl_gpc.h fsl_gpio.c fsl_gpio.h fsl_dcdc.c fsl_dcdc.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h
  group device
    ../../../../../devices/MIMXRT1064/: MIMXRT1064.h MIMXRT1064_features.h fsl_device_registers.h system_MIMXRT1064.c system_MIMXRT1064.h
  group utilities
    ../../../../../devices/MIMXRT1064/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1064/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1064/utilities/: fsl_assert.c
  group component-uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MIMXRT1064/arm/: startup_MIMXRT1064.s
  group xip
    ../../../../../devices/MIMXRT1064/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../xip/: evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_flexspi_nor_config.h evkmimxrt1064_sdram_ini_dcd.c evkmimxrt1064_sdram_ini_dcd.h
  group amazon-freertos-freertos_kernel
    ../../../../../rtos/amazon-freertos/freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos-freertos_kernel-include
    ../../../../../rtos/amazon-freertos/freertos_kernel/include/: FreeRTOS.h atomic.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group amazon-freertos-freertos_kernel-portable-GCC-ARM_CM4F
    ../../../../../rtos/amazon-freertos/freertos_kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group amazon-freertos-freertos_kernel-portable
    ../../../../../rtos/amazon-freertos/freertos_kernel/portable/: readme.txt
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
target power_mode_switch_ca flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.2.4.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: power_mode_switch_ca.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1064DVL6A, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: DEBUG, NO_CRP, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1064xxxxx_flexspi_nor_ramfunc.scf
  link misc: --remove --keep=*(.boot_hdr.ivt) --keep=*(.boot_hdr.boot_data) --keep=*(.boot_hdr.conf) --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
target power_mode_switch_ca release (ARM-ADS)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.2.4.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: power_mode_switch_ca.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1064DVL6A, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: NDEBUG, NO_CRP, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1064xxxxx_ram.scf
  link misc: --remove
target power_mode_switch_ca flexspi_nor_release (ARM-ADS)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.2.4.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: power_mode_switch_ca.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1064DVL6A, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: NDEBUG, NO_CRP, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1064xxxxx_flexspi_nor_ramfunc.scf
  link misc: as above
