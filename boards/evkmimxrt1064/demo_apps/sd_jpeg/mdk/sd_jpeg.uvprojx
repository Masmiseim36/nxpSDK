# Keil uVision project sd_jpeg.uvprojx, settings and files
target sd_jpeg sdram_debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.2.4.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: sd_jpeg.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SKIP_SYSCLK_INIT, DEBUG, CPU_MIMXRT1064DVL6A, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;..;../../..;../../../../../devices/MIMXRT1064/drivers;../../../../../devices/MIMXRT1064;../../../../../devices/MIMXRT1064/utilities/io;../../../../../devices/MIMXRT1064/utilities/str;../../../../../devices/MIMXRT1064/utilities/log;../../../../../devices/MIMXRT1064/utilities;../../../../../devices/MIMXRT1064/xip;../../../../../middleware/libjpeg/inc;../../../../../middleware/sdmmc/src;../../../../../middleware/sdmmc/inc;../../../../../middleware/sdmmc/port;../../../../../middleware/fatfs/source/fsl_sd_disk;../../../../../middleware/fatfs/source
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1064xxxxx_sdram.scf
  link misc: --remove
  group source
    ../: sd_jpeg.c jconfig.h ffconf.h
  group sdmmc-port
    ../: fsl_sdmmc_host.c fsl_sdmmc_event.c fsl_sdmmc_event.h
  group board
    ../: pin_mux.c pin_mux.h
  group board-src
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1064/drivers/: fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_usdhc.c fsl_usdhc.h fsl_elcdif.c fsl_elcdif.h
  group startup
    ../../../../../devices/MIMXRT1064/: system_MIMXRT1064.c system_MIMXRT1064.h
    ../../../../../devices/MIMXRT1064/arm/: startup_MIMXRT1064.s
  group utilities
    ../../../../../devices/MIMXRT1064/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MIMXRT1064/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MIMXRT1064/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1064/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group xip
    ../../../../../devices/MIMXRT1064/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_flexspi_nor_config.h evkmimxrt1064_sdram_ini_dcd.c evkmimxrt1064_sdram_ini_dcd.h
  group libjpeg-src
    ../../../../../middleware/libjpeg/src/: jaricom.c jcapimin.c jcapistd.c jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcprepct.c jcsample.c jctrans.c jdapimin.c jdapistd.c jdarith.c jdatadst.c jdatasrc.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jdtrans.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jmemmgr.c jmemnobs.c jquant1.c jquant2.c jutils.c
  group libjpeg-inc
    ../../../../../middleware/libjpeg/inc/: jerror.h jdct.h transupp.h jpeglib.h cdjpeg.h jversion.h jinclude.h jpegint.h jmemsys.h cderror.h jmorecfg.h
  group sdmmc-src
    ../../../../../middleware/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group sdmmc-inc
    ../../../../../middleware/sdmmc/inc/: fsl_sd.h fsl_sdmmc_host.h fsl_sdmmc_common.h fsl_sdmmc_spec.h
  group fatfs-fatfs_include
    ../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.h
    ../../../../../middleware/fatfs/source/: diskio.h ff.h integer.h
  group fatfs-fatfs_source
    ../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c
    ../../../../../middleware/fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c
target sd_jpeg flexspi_nor_debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.2.4.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: sd_jpeg.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SKIP_SYSCLK_INIT, XIP_BOOT_HEADER_DCD_ENABLE=1, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, CPU_MIMXRT1064DVL6A, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1064xxxxx_flexspi_nor_sdram.scf
  link misc: --remove 
--keep=*(.boot_hdr.dcd_data) 
--keep=*(.boot_hdr.ivt) 
--keep=*(.boot_hdr.boot_data) 
--keep=*(.boot_hdr.conf) 
--predefine="-DXIP_BOOT_HEADER_ENABLE=1"
target sd_jpeg sdram_release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.2.4.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: sd_jpeg.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SKIP_SYSCLK_INIT, NDEBUG, CPU_MIMXRT1064DVL6A, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1064xxxxx_sdram.scf
  link misc: --remove
target sd_jpeg flexspi_nor_release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.2.4.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: sd_jpeg.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SKIP_SYSCLK_INIT, XIP_BOOT_HEADER_DCD_ENABLE=1, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1064DVL6A, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1064xxxxx_flexspi_nor_sdram.scf
  link misc: as above
