# IAR project ew_gui_graphics_accelerator.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1064xxx6A NXP MIMXRT1064xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1064DVL6A; SKIP_SYSCLK_INIT; XIP_BOOT_HEADER_DCD_ENABLE=1; EW_USE_DOUBLE_BUFFER=1; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565; EW_SURFACE_ROTATION=0; EW_USE_FREE_RTOS=0; SDK_I2C_BASED_COMPONENT_USED=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../devices/MIMXRT1064/drivers; ../../../../../components/ft5406_rt; ../../../../../components/gt911; ../../../../../components/video; ../../../../../devices/MIMXRT1064/utilities/debug_console_lite; ../GeneratedCode; ../../../../../middleware/EmbeddedWizard/TargetSpecific/evkmimxrt1064; ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1064/RGB565; ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1064/RTE; ../../../../../devices/MIMXRT1064; ../../../../../components/uart; ../../../../../components/lists; ../../../../../devices/MIMXRT1064/xip; ../../../xip; ../../../../../components/silicon_id; ../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_CLEAR_BSS; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: ew_gui_graphics_accelerator.out
  ILINK.IlinkIcfFile: MIMXRT1064xxxxx_flexspi_nor.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1010/RTE/libewrte-m7-iar.a; ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1010/RGB565/libewgfx-m7-iar.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1064DVL6A; SKIP_SYSCLK_INIT; XIP_BOOT_HEADER_DCD_ENABLE=1; EW_USE_DOUBLE_BUFFER=1; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565; EW_SURFACE_ROTATION=0; EW_USE_FREE_RTOS=0; SDK_I2C_BASED_COMPONENT_USED=1; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG; __STARTUP_CLEAR_BSS; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../: board.c board.h clock_config.c clock_config.h dcd.c dcd.h ewconfig.h ewdef.h pin_mux.c pin_mux.h
  group source
    ../: main.c ewmain.c ewmain.h DeviceDriver.c DeviceDriver.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1064/drivers/: fsl_cache.c fsl_cache.h fsl_elcdif.c fsl_elcdif.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_pxp.c fsl_pxp.h fsl_lpi2c.c fsl_lpi2c.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group touchpanel
    ../../../../../components/ft5406_rt/: fsl_ft5406_rt.h fsl_ft5406_rt.c
    ../../../../../components/gt911/: fsl_gt911.h fsl_gt911.c
  group video
    ../../../../../components/video/: fsl_video_common.h fsl_video_common.c
  group utilities
    ../../../../../devices/MIMXRT1064/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group EmbeddedWizard/GeneratedCode
    ../GeneratedCode/: Accelerator.c Application.c Core.c Effects.c Graphics.c GraphicsSystem.c Resources.c Templates.c Views.c WidgetSet.c Accelerator.h Application.h Core.h Effects.h Graphics.h GraphicsSystem.h Resources.h Templates.h Views.h WidgetSet.h _AcceleratorAccelerator.h _AcceleratorFontLarge.h _AcceleratorFontMedium.h _AcceleratorFontSmall.h _AcceleratorGraphicsFactory.h _AcceleratorImgBlend1.h _AcceleratorImgBlend2.h _AcceleratorImgBlend3.h _AcceleratorImgBlend4.h _AcceleratorImgBlend5.h _AcceleratorImgBlend6.h _AcceleratorImgBlend7.h _AcceleratorImgCopy1.h _AcceleratorImgCopy2.h _AcceleratorImgCopy3.h _AcceleratorImgCopy4.h _AcceleratorImgCopy5.h _AcceleratorLogo.h _ApplicationApplication.h _CoreCursorEvent.h _CoreCursorGrabEvent.h _CoreCursorHit.h _CoreDialogContext.h _CoreDragEvent.h _CoreEvent.h _CoreGroup.h _CoreKeyEvent.h _CoreKeyPressHandler.h _CoreLayoutContext.h _CoreLayoutQuadContext.h _CoreModalContext.h _CoreOutline.h _CoreQuadView.h _CoreRectView.h _CoreResource.h _CoreRoot.h _CoreSimpleTouchHandler.h _CoreTask.h _CoreTaskQueue.h _CoreTimer.h _CoreView.h _EffectsEffectTimerClass.h _GraphicsCanvas.h _GraphicsSystemDeviceClass.h _ResourcesBitmap.h _ResourcesFont.h _ResourcesFontMedium.h _TemplatesDeviceClass.h _ViewsFrame.h _ViewsImage.h _ViewsRectangle.h _ViewsText.h _WidgetSetPushButton.h _WidgetSetPushButtonConfig.h _WidgetSetPushButtonMedium.h _WidgetSetSwitchMedium.h _WidgetSetToggleButton.h _WidgetSetToggleButtonConfig.h _WidgetSetWidgetConfig.h ewlocale.h
  group EmbeddedWizard/TargetSpecific/evkmimxrt1064
    ../../../../../middleware/EmbeddedWizard/TargetSpecific/evkmimxrt1064/: ew_bsp_clock.c ew_bsp_console.c ew_bsp_display.c ew_bsp_event.c ew_bsp_graphics.c ew_bsp_inout.c ew_bsp_system.c ew_bsp_touch.c ew_bsp_clock.h ew_bsp_console.h ew_bsp_display.h ew_bsp_event.h ew_bsp_graphics.h ew_bsp_inout.h ew_bsp_system.h ew_bsp_touch.h
  group EmbeddedWizard/PlatformPackage/evkmimxrt1064/RGB565
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1064/RGB565/: ewextgfx.c ewextbmp.h ewextfnt.h ewextgfx.h ewextpxl_RGB565.h ewgfx.h ewgfxcore.h ewgfxdefs.h ewgfxdriver.h ewgfxlinks.h ewgfxres.h ewgfxtasks.h
  group EmbeddedWizard/PlatformPackage/evkmimxrt1064/RTE
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1064/RTE/: ewextrte.c ewextrte.h ewrte.h
  group device
    ../../../../../devices/MIMXRT1064/: fsl_device_registers.h MIMXRT1064.h MIMXRT1064_features.h system_MIMXRT1064.c system_MIMXRT1064.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/silicon_id
    ../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group startup
    ../../../../../devices/MIMXRT1064/iar/: startup_MIMXRT1064.s
  group xip
    ../../../../../devices/MIMXRT1064/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
