# Keil uVision project ew_gui_smart_thermostat.uvprojx, settings and files
target ew_gui_smart_thermostat flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.2.4.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ew_gui_smart_thermostat.out
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1064DVL6A, SKIP_SYSCLK_INIT, XIP_BOOT_HEADER_DCD_ENABLE=1, EW_USE_DOUBLE_BUFFER=1, EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565, EW_SURFACE_ROTATION=0, EW_USE_FREE_RTOS=0, SDK_I2C_BASED_COMPONENT_USED=1, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../devices/MIMXRT1064/drivers;../../../../../components/ft5406_rt;../../../../../components/gt911;../../../../../components/video;../../../../../devices/MIMXRT1064/utilities/debug_console_lite;../GeneratedCode;../../../../../middleware/EmbeddedWizard/TargetSpecific/evkmimxrt1064;../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1064/RGB565;../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1064/RTE;../../../../../devices/MIMXRT1064;../../../../../components/uart;../../../../../components/lists;../../../../../devices/MIMXRT1064/xip;../../../xip;../../../../../components/silicon_id;../../../../../CMSIS/Core/Include
  asm define: DEBUG, __STARTUP_CLEAR_BSS, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1064xxxxx_flexspi_nor.scf
  link misc: ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1010/RTE/libewrte-m7-keil.lib ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1010/RGB565/libewgfx-m7-keil.lib --remove --entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group board
    ../: board.c board.h clock_config.c clock_config.h dcd.c dcd.h ewconfig.h ewdef.h pin_mux.c pin_mux.h
  group source
    ../: main.c ewmain.c ewmain.h DeviceDriver.c DeviceDriver.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1064/drivers/: fsl_cache.c fsl_cache.h fsl_elcdif.c fsl_elcdif.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_pxp.c fsl_pxp.h fsl_lpi2c.c fsl_lpi2c.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c
  group touchpanel
    ../../../../../components/ft5406_rt/: fsl_ft5406_rt.h fsl_ft5406_rt.c
    ../../../../../components/gt911/: fsl_gt911.h fsl_gt911.c
  group video
    ../../../../../components/video/: fsl_video_common.h fsl_video_common.c
  group utilities
    ../../../../../devices/MIMXRT1064/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group EmbeddedWizard/GeneratedCode
    ../GeneratedCode/: Application.c Core.c Effects.c Graphics.c Resources.c Templates.c Thermostat.c Views.c WidgetSet.c Application.h Core.h Effects.h Graphics.h Resources.h Templates.h Thermostat.h Views.h WidgetSet.h _ApplicationApplication.h _CoreCursorEvent.h _CoreCursorGrabEvent.h _CoreCursorHit.h _CoreDialogContext.h _CoreDragEvent.h _CoreEvent.h _CoreGroup.h _CoreKeyEvent.h _CoreKeyPressHandler.h _CoreLayoutContext.h _CoreLayoutQuadContext.h _CoreModalContext.h _CoreOutline.h _CorePropertyObserver.h _CoreQuadView.h _CoreRectView.h _CoreResource.h _CoreRoot.h _CoreRotateTouchHandler.h _CoreSimpleTouchHandler.h _CoreTask.h _CoreTaskQueue.h _CoreTimer.h _CoreView.h _EffectsEffect.h _EffectsEffectTimerClass.h _EffectsInt32Effect.h _EffectsTimingList.h _GraphicsCanvas.h _GraphicsPath.h _GraphicsWarpMatrix.h _ResourcesBitmap.h _ResourcesFont.h _TemplatesDeviceClass.h _ThermostatBackgroundDay.h _ThermostatBackgroundDefault.h _ThermostatBackgroundNight.h _ThermostatButtonDay.h _ThermostatButtonNight.h _ThermostatButtonVacation.h _ThermostatController.h _ThermostatDeviceClass.h _ThermostatErgosign.h _ThermostatFontL.h _ThermostatFontM.h _ThermostatFontXXL.h _ThermostatNeedle.h _ThermostatSwingSwitch.h _ThermostatSymbolFan.h _ThermostatSymbolHeadCool.h _ThermostatTemperatureController.h _ThermostatThermostat.h _ThermostatVertBar.h _ThermostatWheels.h _ViewsFrame.h _ViewsImage.h _ViewsStrokePath.h _ViewsText.h _ViewsWallpaper.h _ViewsWarpImage.h _ViewsWarpView.h _WidgetSetRadioButton.h _WidgetSetRadioButtonConfig.h _WidgetSetToggleButton.h _WidgetSetToggleButtonConfig.h _WidgetSetVerticalSlider.h _WidgetSetVerticalSliderConfig.h _WidgetSetWidgetConfig.h ewlocale.h
  group EmbeddedWizard/TargetSpecific/evkmimxrt1064
    ../../../../../middleware/EmbeddedWizard/TargetSpecific/evkmimxrt1064/: ew_bsp_clock.c ew_bsp_console.c ew_bsp_display.c ew_bsp_event.c ew_bsp_graphics.c ew_bsp_inout.c ew_bsp_system.c ew_bsp_touch.c ew_bsp_clock.h ew_bsp_console.h ew_bsp_display.h ew_bsp_event.h ew_bsp_graphics.h ew_bsp_inout.h ew_bsp_system.h ew_bsp_touch.h
  group EmbeddedWizard/PlatformPackage/evkmimxrt1064/RGB565
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1064/RGB565/: ewextgfx.c ewextbmp.h ewextfnt.h ewextgfx.h ewextpxl_RGB565.h ewgfx.h ewgfxcore.h ewgfxdefs.h ewgfxdriver.h ewgfxlinks.h ewgfxres.h ewgfxtasks.h
  group EmbeddedWizard/PlatformPackage/evkmimxrt1064/RTE
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1064/RTE/: ewextrte.c ewextrte.h ewrte.h
  group device
    ../../../../../devices/MIMXRT1064/: fsl_device_registers.h MIMXRT1064.h MIMXRT1064_features.h system_MIMXRT1064.c system_MIMXRT1064.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1064/arm/: startup_MIMXRT1064.S
  group xip
    ../../../../../devices/MIMXRT1064/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_flexspi_nor_config.h
  group component/silicon_id
    ../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
target ew_gui_smart_thermostat flexspi_nor_release (ARM-ADS)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.2.4.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ew_gui_smart_thermostat.out
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1064DVL6A, SKIP_SYSCLK_INIT, XIP_BOOT_HEADER_DCD_ENABLE=1, EW_USE_DOUBLE_BUFFER=1, EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565, EW_SURFACE_ROTATION=0, EW_USE_FREE_RTOS=0, SDK_I2C_BASED_COMPONENT_USED=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_CLEAR_BSS, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1064xxxxx_flexspi_nor.scf
  link misc: as above
