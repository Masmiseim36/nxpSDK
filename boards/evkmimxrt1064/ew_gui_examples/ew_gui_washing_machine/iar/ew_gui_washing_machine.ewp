# IAR project ew_gui_washing_machine.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1064xxx6A NXP MIMXRT1064xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1064DVL6A; SKIP_SYSCLK_INIT; XIP_BOOT_HEADER_DCD_ENABLE=1; EW_MAX_SURFACE_CACHE_SIZE=0x200000; EW_MAX_GLYPH_SURFACE_WIDTH=256; EW_MAX_GLYPH_SURFACE_HEIGHT=256; EW_USE_DOUBLE_BUFFER=1; EW_CPU_LOAD_MEASURING=1; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565; EW_SURFACE_ROTATION=0; EW_USE_FREE_RTOS=0; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../..; ../../../../../CMSIS/Include; ../../../../../devices; ../GeneratedCode; ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RTE; ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RGB565; ../../../../../middleware/EmbeddedWizard/TargetSpecific/evkmimxrt1064; ../../../../../middleware/EmbeddedWizard/ThirdParty/TLSF; ../../../../../devices/MIMXRT1064/drivers; ../../../../../devices/MIMXRT1064/drivers; ../../../../../devices/MIMXRT1064/drivers; ../../../../../devices/MIMXRT1064/drivers; ../../../../../devices/MIMXRT1064/drivers; ../../../../../components/ft5406_rt; ../../../../../devices/MIMXRT1064/drivers; ../../../../../devices/MIMXRT1064/drivers; ../../../../../devices/MIMXRT1064; ../../../../../devices/MIMXRT1064/utilities/str; ../../../../../devices/MIMXRT1064/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../components/serial_manager; ../../../../../devices/MIMXRT1064/drivers; ../../../../../devices/MIMXRT1064/drivers; ../../../../../devices/MIMXRT1064/drivers; ../../../../../devices/MIMXRT1064/xip; ../../../xip; ../../../xip; ../../../../../devices/MIMXRT1064/utilities
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_CLEAR_BSS; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: ew_gui_washing_machine.out
  ILINK.IlinkIcfFile: MIMXRT1064xxxxx_flexspi_nor.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RGB565/libewgfx-m7-iar.a; ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RTE/libewrte-m7-iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1064DVL6A; SKIP_SYSCLK_INIT; XIP_BOOT_HEADER_DCD_ENABLE=1; EW_MAX_SURFACE_CACHE_SIZE=0x200000; EW_MAX_GLYPH_SURFACE_WIDTH=256; EW_MAX_GLYPH_SURFACE_HEIGHT=256; EW_USE_DOUBLE_BUFFER=1; EW_CPU_LOAD_MEASURING=1; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565; EW_SURFACE_ROTATION=0; EW_USE_FREE_RTOS=0; SERIAL_PORT_TYPE_UART=1
  AARM.ADefines: NDEBUG; __STARTUP_CLEAR_BSS; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group source
    ../: main.c ewmain.c ewmain.h DeviceDriver.c DeviceDriver.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1064/drivers/: fsl_cache.c fsl_cache.h fsl_elcdif.c fsl_elcdif.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_pxp.c fsl_pxp.h fsl_lpi2c.c fsl_lpi2c.h fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h fsl_gpio.c fsl_gpio.h
  group touchpanel
    ../../../../../components/ft5406_rt/: fsl_ft5406_rt.c fsl_ft5406_rt.h
  group EmbeddedWizard/GeneratedCode
    ../GeneratedCode/: Application.c Application.h Core.c Core.h Effects.c Effects.h Graphics.c Graphics.h Resources.c Resources.h Views.c Views.h Washer.c Washer.h _ApplicationApplication.h _CoreCursorEvent.h _CoreCursorGrabEvent.h _CoreCursorHit.h _CoreDialogContext.h _CoreDragEvent.h _CoreEvent.h _CoreGroup.h _CoreKeyEvent.h _CoreKeyPressHandler.h _CoreLayoutContext.h _CoreLayoutQuadContext.h _CoreModalContext.h _CoreOutline.h _CorePropertyObserver.h _CoreQuadView.h _CoreRectView.h _CoreResource.h _CoreRoot.h _CoreSimpleTouchHandler.h _CoreSlideTouchHandler.h _CoreTask.h _CoreTaskQueue.h _CoreTimer.h _CoreVerticalList.h _CoreView.h _EffectsEffect.h _EffectsEffectTimerClass.h _EffectsInt32Effect.h _EffectsRectEffect.h _EffectsTimingList.h _GraphicsCanvas.h _ResourcesBitmap.h _ResourcesFont.h _ViewsBorder.h _ViewsFrame.h _ViewsImage.h _ViewsRectangle.h _ViewsText.h _WasherDeviceClass.h _WasherHourItemL.h _WasherHourItemS.h _WasherMinItemL.h _WasherMinItemS.h _WasherOptItemL.h _WasherOptItemS.h _WasherOptList.h _WasherProgItemL.h _WasherProgItemS.h _WasherProgList.h _WasherSpinItemL.h _WasherSpinItemS.h _WasherSpinList.h _WasherStartButton.h _WasherTempItemL.h _WasherTempItemS.h _WasherTempList.h _WasherTimeList.h _WasherWasher.h ewlocale.h
  group EmbeddedWizard/PlatformPackage/RT/RGB565
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RGB565/: ewextbmp.h ewextfnt.h ewextgfx.c ewextgfx.h ewextpxl_RGB565.h ewgfx.h ewgfxcore.h ewgfxdefs.h ewgfxdriver.h ewgfxlinks.h ewgfxres.h ewgfxtasks.h
  group EmbeddedWizard/PlatformPackage/RT/RTE
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/RT/RTE/: ewextrte.c ewextrte.h ewrte.h
  group EmbeddedWizard/TargetSpecific/evkmimxrt1064
    ../../../../../middleware/EmbeddedWizard/TargetSpecific/evkmimxrt1064/: ew_bsp_clock.c ew_bsp_clock.h ew_bsp_display.c ew_bsp_display.h ew_bsp_event.c ew_bsp_event.h ew_bsp_graphics.c ew_bsp_graphics.h ew_bsp_inout.c ew_bsp_inout.h ew_bsp_serial.c ew_bsp_serial.h ew_bsp_system.c ew_bsp_system.h ew_bsp_touch.c ew_bsp_touch.h
  group EmbeddedWizard/ThirdParty/TLSF
    ../../../../../middleware/EmbeddedWizard/ThirdParty/TLSF/: tlsf.c tlsf.h tlsfbits.h
  group device
    ../../../../../devices/MIMXRT1064/: MIMXRT1064.h MIMXRT1064_features.h fsl_device_registers.h system_MIMXRT1064.c system_MIMXRT1064.h
  group utilities
    ../../../../../devices/MIMXRT1064/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1064/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1064/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MIMXRT1064/iar/: startup_MIMXRT1064.s
  group xip
    ../../../../../devices/MIMXRT1064/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../xip/: evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_flexspi_nor_config.h evkmimxrt1064_sdram_ini_dcd.c evkmimxrt1064_sdram_ini_dcd.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
