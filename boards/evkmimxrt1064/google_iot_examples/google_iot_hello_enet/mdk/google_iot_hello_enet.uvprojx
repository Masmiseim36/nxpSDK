# Keil uVision project google_iot_hello_enet.uvprojx, settings and files
target google_iot_hello_enet flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.2.4.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: google_iot_hello_enet.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1064DVL6A, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, PRINTF_ADVANCED_ENABLE=1, USE_RTOS=1, MBEDTLS_CONFIG_FILE='\"google_mbedtls_config.h\"', IOTC_CROSS_TARGET, IOTC_FS_DUMMY, SDK_DEBUGCONSOLE_UART, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../rtos/amazon-freertos/freertos_kernel/portable/GCC/ARM_CM4F;..;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../middleware/mbedtls/include;../../../../../middleware/mbedtls/port/ksdk;../../../../../middleware/google_iot/include;../../../../../middleware/google_iot/include/bsp;../../../../../middleware/google_iot/src/bsp;../../../../../middleware/google_iot/src/libiotc;../../../../../middleware/google_iot/src/libiotc/control_topic;../../../../../middleware/google_iot/src/libiotc/datastructures;../../../../../middleware/google_iot/src/libiotc/event_dispatcher;../../../../../middleware/google_iot/src/libiotc/event_loop;../../../../../middleware/google_iot/src/libiotc/io;../../../../../middleware/google_iot/src/libiotc/io/fs;../../../../../middleware/google_iot/src/libiotc/io/net;../../../../../middleware/google_iot/src/libiotc/memory;../../../../../middleware/google_iot/src/libiotc/mqtt/codec;../../../../../middleware/google_iot/src/libiotc/mqtt/logic;../../../../../middleware/google_iot/src/libiotc/platform/iotc_thread;../../../../../middleware/google_iot/src/libiotc/platform/dummy/iotc_thread;../../../../../middleware/google_iot/src/libiotc/tls;../../../../../middleware/google_iot/src/libiotc/tls/certs;../../../../../middleware/google_iot/third_party/mqtt-protocol-c;../../../../../rtos/amazon-freertos/freertos_kernel/include;../../../../../components/phyksz8081;../../../../../devices/MIMXRT1064/drivers;../../../../../devices/MIMXRT1064/drivers;../../../../../devices/MIMXRT1064/drivers;../../../../../devices/MIMXRT1064/drivers;../../../../../middleware/lwip/port;../../../../../middleware/lwip/src;../../../../../middleware/lwip/src/include;../../../../../middleware/lwip/src/include;../../../../../devices/MIMXRT1064/drivers;../../../../../devices/MIMXRT1064/drivers;../../../../../devices/MIMXRT1064;../../../../../devices/MIMXRT1064/utilities/str;../../../../../devices/MIMXRT1064/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../components/serial_manager;../../../../../devices/MIMXRT1064/drivers;../../../../../devices/MIMXRT1064/drivers;../../../../../devices/MIMXRT1064/drivers;../../../../../devices/MIMXRT1064/xip;../../../xip;../../../xip;../../../../../devices/MIMXRT1064/drivers;../../../../../devices/MIMXRT1064/utilities
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1064xxxxx_flexspi_nor.scf
  link misc: --remove --keep=*(.boot_hdr.ivt) --keep=*(.boot_hdr.boot_data) --keep=*(.boot_hdr.conf) --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-D__stack_size__=0x200" --predefine="-D__heap_size__=0x200"
  group source
    ../: main.c commandline.c example_utils.c
  group include
    ../: commandline.h example_utils.h
  group config
    ../: lwipopts.h google_mbedtls_config.h google_iot_config.h FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
    ../../../../../components/phyksz8081/: fsl_phy.c fsl_phy.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1064/drivers/: fsl_trng.c fsl_trng.h fsl_dcp.c fsl_dcp.h fsl_cache.c fsl_cache.h fsl_flexspi.c fsl_flexspi.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h fsl_gpio.c fsl_gpio.h fsl_enet.c fsl_enet.h
  group lwip-port-arch
    ../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip-port
    ../../../../../middleware/lwip/port/: sys_arch.c enet_ethernetif_kinetis.c enet_ethernetif.c enet_ethernetif.h enet_ethernetif_priv.h
  group lwip-src-api
    ../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-src-core
    ../../../../../middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip-src-core-ipv4
    ../../../../../middleware/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip-src-core-ipv6
    ../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip-src-include-compat-posix-arpa
    ../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip-src-include-compat-posix-net
    ../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip-src-include-compat-posix
    ../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip-src-include-compat-posix-sys
    ../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip-src-include-compat-stdc
    ../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip-src-include-lwip
    ../../../../../middleware/lwip/src/include/lwip/: altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip-src-include-lwip-priv
    ../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group lwip-src-include-lwip-prot
    ../../../../../middleware/lwip/src/include/lwip/prot/: autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip-src-include-netif
    ../../../../../middleware/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lwip-src-include-netif-ppp
    ../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip-src-include-netif-ppp-polarssl
    ../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip-src-netif
    ../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip-src-netif-ppp
    ../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group amazon-freertos-freertos_kernel-portable-MemMang
    ../../../../../rtos/amazon-freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group mbedtls-include-mbedtls
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls-library
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls-port-ksdk
    ../../../../../middleware/mbedtls/port/ksdk/: aes_alt.c aes_alt.h des_alt.c des_alt.h ecp_alt.c ecp_alt.h ecp_alt_ksdk.c ecp_curves_alt.c ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h
  group lwip-src-apps-sntp
    ../../../../../middleware/lwip/src/apps/sntp/: sntp.c
  group lwip-src-include-lwip-apps
    ../../../../../middleware/lwip/src/include/lwip/apps/: sntp.h sntp_opts.h
  group google_iot-include-bsp
    ../../../../../middleware/google_iot/include/bsp/: iotc_bsp_crypto.h iotc_bsp_io_fs.h iotc_bsp_io_net.h iotc_bsp_mem.h iotc_bsp_rng.h iotc_bsp_time.h iotc_bsp_tls.h
  group google_iot-include
    ../../../../../middleware/google_iot/include/: iotc.h iotc_connection_data.h iotc_error.h iotc_jwt.h iotc_mqtt.h iotc_time.h iotc_types.h
  group google_iot-src-bsp-crypto-mbedtls
    ../../../../../middleware/google_iot/src/bsp/crypto/mbedtls/: iotc_bsp_crypto_mbedtls.c
  group google_iot-src-bsp
    ../../../../../middleware/google_iot/src/bsp/: iotc_bsp_debug.h
  group google_iot-src-bsp-platform-freertos
    ../../../../../middleware/google_iot/src/bsp/platform/freertos/: iotc_bsp_io_fs_freertos.c iotc_bsp_io_net_freertos.c iotc_bsp_mem_freertos.c iotc_bsp_rng_freertos.c iotc_bsp_time_freertos.c
  group google_iot-src-bsp-tls-mbedtls
    ../../../../../middleware/google_iot/src/bsp/tls/mbedtls/: iotc_bsp_tls_mbedtls.c
  group google_iot-src-libiotc-control_topic
    ../../../../../middleware/google_iot/src/libiotc/control_topic/: iotc_control_topic_layer.c iotc_control_topic_layer.h
  group google_iot-src-libiotc-datastructures
    ../../../../../middleware/google_iot/src/libiotc/datastructures/: iotc_list.h iotc_memory_type.h iotc_vector.c iotc_vector.h
  group google_iot-src-libiotc-event_dispatcher
    ../../../../../middleware/google_iot/src/libiotc/event_dispatcher/: iotc_event_dispatcher.c iotc_event_dispatcher_api.h iotc_event_dispatcher_macros.h iotc_event_handle.c iotc_event_handle.h iotc_event_handle_queue.h iotc_event_handle_typedef.h iotc_event_thread_dispatcher.c iotc_event_thread_dispatcher.h iotc_time_event.c iotc_time_event.h
  group google_iot-src-libiotc-event_loop
    ../../../../../middleware/google_iot/src/libiotc/event_loop/: iotc_event_loop.c iotc_event_loop.h
  group google_iot-src-libiotc-io-fs-dummy
    ../../../../../middleware/google_iot/src/libiotc/io/fs/dummy/: iotc_fs_dummy.c
  group google_iot-src-libiotc-io-fs
    ../../../../../middleware/google_iot/src/libiotc/io/fs/: iotc_fs_api.h iotc_fs_bsp_to_iotc_mapping.c iotc_fs_bsp_to_iotc_mapping.h iotc_fs_filename_defs.h iotc_fs_filenames.c iotc_fs_filenames.h iotc_fs_header.h iotc_resource_manager.c iotc_resource_manager.h
  group google_iot-src-libiotc-io-net
    ../../../../../middleware/google_iot/src/libiotc/io/net/: iotc_io_net_layer.c iotc_io_net_layer.h iotc_io_net_layer_state.h
  group google_iot-src-libiotc
    ../../../../../middleware/google_iot/src/libiotc/: iotc.c iotc_backoff_lut_config.h iotc_backoff_status_api.c iotc_backoff_status_api.h iotc_common.h iotc_config.h iotc_connection_data.c iotc_connection_data_internal.h iotc_coroutine.h iotc_data_desc.c iotc_data_desc.h iotc_debug.c iotc_debug.h iotc_error.c iotc_globals.c iotc_globals.h iotc_handle.c iotc_handle.h iotc_helpers.c iotc_helpers.h iotc_internals.c iotc_internals.h iotc_io_timeouts.c iotc_io_timeouts.h iotc_jwt.c iotc_layer.h iotc_layer_api.c iotc_layer_api.h iotc_layer_chain.h iotc_layer_default_allocators.c iotc_layer_default_allocators.h iotc_layer_default_functions.c iotc_layer_default_functions.h iotc_layer_factory.h iotc_layer_macros.h iotc_layer_stack.h iotc_layers_ids.h iotc_macros.h iotc_timed_task.c iotc_timed_task.h iotc_tuple.h iotc_tuples.c iotc_tuples.h iotc_types_internal.h iotc_user_sub_call_wrapper.c iotc_user_sub_call_wrapper.h iotc_version.h
  group google_iot-src-libiotc-memory
    ../../../../../middleware/google_iot/src/libiotc/memory/: iotc_allocator.c iotc_allocator.h
  group google_iot-src-libiotc-mqtt-codec
    ../../../../../middleware/google_iot/src/libiotc/mqtt/codec/: iotc_mqtt_codec_layer.c iotc_mqtt_codec_layer.h iotc_mqtt_codec_layer_data.c iotc_mqtt_codec_layer_data.h
  group google_iot-src-libiotc-mqtt-logic
    ../../../../../middleware/google_iot/src/libiotc/mqtt/logic/: iotc_mqtt_logic_layer.c iotc_mqtt_logic_layer.h iotc_mqtt_logic_layer_commands.h iotc_mqtt_logic_layer_connect_command.h iotc_mqtt_logic_layer_connection_helpers.h iotc_mqtt_logic_layer_data.c iotc_mqtt_logic_layer_data.h iotc_mqtt_logic_layer_data_helpers.h iotc_mqtt_logic_layer_handlers.h iotc_mqtt_logic_layer_helpers.h iotc_mqtt_logic_layer_keepalive_handler.c iotc_mqtt_logic_layer_keepalive_handler.h iotc_mqtt_logic_layer_publish_handler.h iotc_mqtt_logic_layer_publish_q0_command.h iotc_mqtt_logic_layer_publish_q1_command.h iotc_mqtt_logic_layer_subscribe_command.h iotc_mqtt_logic_layer_task_helpers.c iotc_mqtt_logic_layer_task_helpers.h
  group google_iot-src-libiotc-platform-dummy-iotc_thread
    ../../../../../middleware/google_iot/src/libiotc/platform/dummy/iotc_thread/: iotc_critical_section_def.h
  group google_iot-src-libiotc-platform-iotc_thread
    ../../../../../middleware/google_iot/src/libiotc/platform/iotc_thread/: iotc_critical_section.h iotc_thread_ids.h iotc_thread_threadpool.h iotc_thread_workerthread.h
  group google_iot-src-libiotc-tls-certs
    ../../../../../middleware/google_iot/src/libiotc/tls/certs/: iotc_RootCA_list.c iotc_RootCA_list.h
  group google_iot-src-libiotc-tls
    ../../../../../middleware/google_iot/src/libiotc/tls/: iotc_tls_layer.c iotc_tls_layer.h iotc_tls_layer_state.h
  group google_iot-third_party-mqtt-protocol-c
    ../../../../../middleware/google_iot/third_party/mqtt-protocol-c/: iotc_debug_data_desc_dump.c iotc_debug_data_desc_dump.h iotc_mqtt_errors.h iotc_mqtt_message.c iotc_mqtt_message.h iotc_mqtt_parser.c iotc_mqtt_parser.h iotc_mqtt_serialiser.c iotc_mqtt_serialiser.h
  group device
    ../../../../../devices/MIMXRT1064/: MIMXRT1064.h MIMXRT1064_features.h fsl_device_registers.h system_MIMXRT1064.c system_MIMXRT1064.h
  group utilities
    ../../../../../devices/MIMXRT1064/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1064/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1064/utilities/: fsl_assert.c
  group component-uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MIMXRT1064/arm/: startup_MIMXRT1064.s
  group xip
    ../../../../../devices/MIMXRT1064/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../xip/: evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_flexspi_nor_config.h evkmimxrt1064_sdram_ini_dcd.c evkmimxrt1064_sdram_ini_dcd.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
  group amazon-freertos-freertos_kernel
    ../../../../../rtos/amazon-freertos/freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos-freertos_kernel-include
    ../../../../../rtos/amazon-freertos/freertos_kernel/include/: FreeRTOS.h atomic.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group amazon-freertos-freertos_kernel-portable-GCC-ARM_CM4F
    ../../../../../rtos/amazon-freertos/freertos_kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group amazon-freertos-freertos_kernel-portable
    ../../../../../rtos/amazon-freertos/freertos_kernel/portable/: readme.txt
target google_iot_hello_enet flexspi_nor_release (ARM-ADS)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.2.4.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: google_iot_hello_enet.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1064DVL6A, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, PRINTF_ADVANCED_ENABLE=1, USE_RTOS=1, MBEDTLS_CONFIG_FILE='\"google_mbedtls_config.h\"', IOTC_CROSS_TARGET, IOTC_FS_DUMMY, SDK_DEBUGCONSOLE_UART, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../..
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1064xxxxx_flexspi_nor.scf
  link misc: as above
