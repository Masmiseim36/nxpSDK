# Keil uVision project aws_tests_wifi_nxp_cm4.uvprojx, settings and files
target aws_tests_wifi_nxp_cm4 flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1166DVM6A:cm4 NXP
  pack: NXP.MIMXRT1166_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: aws_tests_wifi_nxp_cm4.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=0, DEBUG, CPU_MIMXRT1166DVM6A_cm4, XIP_BOOT_HEADER_DCD_ENABLE=1, USE_SDRAM, USE_RTOS=1, MBEDTLS_CONFIG_FILE='\"aws_mbedtls_config.h\"', UNITY_INCLUDE_CONFIG_H, AMAZON_FREERTOS_ENABLE_UNIT_TESTS, CRYPTO_USE_DRIVER_CAAM, MFLASH_FILE_BASEADDR=14221312, SDIO_ENABLED, SDK_OS_FREE_RTOS, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: -include ../app_config.h -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../src/aws_examples/common/config_files_wifi_nxp;../../../..;../config_files;../../../common/cm4;../../../../../../devices/MIMXRT1166/drivers;../../../../../../components/flash/mflash;../../../../../../components/flash/mflash/mimxrt1160;../../../../../../devices/MIMXRT1166/drivers/cm4;../../../../../../middleware/mbedtls/include;../../../../../../middleware/mbedtls/library;../../../../../../middleware/mbedtls/port/ksdk;../../../../../../rtos/freertos/demos/dev_mode_key_provisioning/include;../../../../../../rtos/freertos/libraries/3rdparty/unity/extras/fixture/src;../../../../../../rtos/freertos/libraries/3rdparty/unity/src;../../../../../../rtos/freertos/libraries/abstractions/pkcs11/test;../../../../../../rtos/freertos/libraries/abstractions/wifi/test;../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/test/access;../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/test/mock;../../../../../../rtos/freertos/libraries/freertos_plus/aws/greengrass/test;../../../../../../rtos/freertos/libraries/freertos_plus/standard/tls/test;../../../../../../rtos/freertos/tests/include;../../../../../../rtos/freertos/libraries/freertos_plus/aws/greengrass/include;../../../../../../rtos/freertos/libraries/freertos_plus/aws/greengrass/src;../../../../../../middleware/lwip/port;../../../../../../middleware/lwip/src;../../../../../../middleware/lwip/src/include;../../../../../../devices/MIMXRT1166/utilities/str;../../../../../../devices/MIMXRT1166/utilities/debug_console;../../../../../../middleware/wifi/dhcpd;../../../../../../middleware/wifi/incl/port/lwip;../../../../../../middleware/wifi/port/lwip;../../../../../../middleware/sdmmc/sdio;../../../../../../middleware/sdmmc/common;../../../../../../middleware/sdmmc/host/usdhc;../../../../../../rtos/freertos/freertos_kernel/include;../../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM4F;../../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/include;../../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/include/types;../../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/src;../../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/src/private;../../../../../../rtos/freertos/libraries/c_sdk/standard/serializer/include;../../../../../../rtos/freertos/libraries/3rdparty/pkcs11;../../../../../../rtos/freertos/libraries/abstractions/pkcs11/corePKCS11/source/include;../../../../../../rtos/freertos/libraries/logging/include;../../../../../../rtos/freertos/libraries/3rdparty/mbedtls_config;../../../../../../devices/MIMXRT1166;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../devices/MIMXRT1166/xip;../../../../xip;../../../../../../CMSIS/Core/Include;../../../../../../rtos/freertos/libraries/c_sdk/standard/common/include;../../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/private;../../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/types;../../../../../../rtos/freertos/libraries/abstractions/platform/freertos/include/platform;../../../../../../rtos/freertos/libraries/abstractions/platform/include/platform;../../../../../../rtos/freertos/libraries/abstractions/platform/include/types;../../../../../../rtos/freertos/libraries/abstractions/platform/freertos/include;../../../../../../rtos/freertos/libraries/abstractions/platform/include;../../../../../../rtos/freertos/libraries/abstractions/secure_sockets/include;../../../../../../rtos/freertos/libraries/freertos_plus/standard/utils/include;../../../../../../rtos/freertos/libraries/freertos_plus/standard/crypto/include;../../../../../../rtos/freertos/libraries/abstractions/wifi/include;../../../../../../middleware/wifi/incl;../../../../../../middleware/wifi/incl/port/os;../../../../../../middleware/wifi/incl/wifidriver;../../../../../../middleware/wifi/incl/wlcmgr;../../../../../../middleware/wifi/wifi_bt_firmware;../../../../../../middleware/wifi/wifidriver;../../../../../../middleware/wifi/wifidriver/incl;../../../../../../rtos/freertos/libraries/freertos_plus/standard/tls/include;../../../../../../rtos/freertos/libraries/3rdparty/mbedtls_utils;../../../../../../rtos/freertos/libraries/3rdparty/jsmn;../../../../../../middleware/sdmmc/osa;../../../../../../components/osa;../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/include;../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/include/types;../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/src/private;../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/src;../../../../../../rtos/freertos/libraries/coreMQTT/source/include;../../../../../../rtos/freertos/libraries/coreMQTT/source/interface
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../../../..;../config_files
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1166xxxxx_cm4_flexspi_nor_sdram.scf
  link misc: --remove --entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=0" --predefine="-D__stack_size__=0x400" --predefine="-D__heap_size__=0x200"
  group board
    ../: pin_mux.c pin_mux.h sdmmc_config.c sdmmc_config.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group source
    ../../application_code/cm4/: main.c
    ../: app_config.h wifi_config.h
  group configs
    ../config_files/: aws_bufferpool_config.h aws_ggd_config.h aws_mbedtls_config.h aws_mqtt_config.h aws_secure_sockets_config.h aws_shadow_config.h aws_test_runner_config.h aws_test_tcp_config.h aws_test_wifi_config.h aws_wifi_config.h FreeRTOSConfig.h FreeRTOSIPConfig.h iot_config.h iot_mqtt_agent_config.h core_pkcs11_config.h core_test_pkcs11_config.h unity_config.h aws_ota_agent_config.h aws_test_ota_config.h core_http_config.h core_mqtt_config.h defender_config.h shadow_config.h lwipopts.h
  group doc
    ../: readme.txt
  group evkmimxrt1160
    ../: evkmimxrt1160_connect_cm4_cm4side.jlinkscript
  group drivers
    ../../../../../../devices/MIMXRT1166/drivers/: fsl_caam.c fsl_caam.h fsl_flexspi.c fsl_flexspi.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_memory.h fsl_anatop_ai.h fsl_anatop_ai.c fsl_usdhc.c fsl_usdhc.h
    ../../../../../../devices/MIMXRT1166/drivers/cm4/: fsl_cache.c fsl_cache.h
  group flash/mflash
    ../../../../../../components/flash/mflash/: mflash_file.h mflash_file.c mflash_common.h
  group flash/mflash/mimxrt1160
    ../../../../../../components/flash/mflash/mimxrt1160/: mflash_drv.h mflash_drv.c
  group mbedtls/include/mbedtls
    ../../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h config_psa.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h psa_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/include/psa
    ../../../../../../middleware/mbedtls/include/psa/: crypto.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_extra.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group mbedtls/library
    ../../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c chacha20.c chachapoly.c check_crypto_config.h cmac.c common.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_client.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_service_integration.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_invasive.h ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c ssl_tls13_keys.h threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/port/ksdk
    ../../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c ecp_alt.h ecp_alt.c ecp_curves_alt.c ecp_alt_ksdk.c threading_alt.h
  group freertos/demos/dev_mode_key_provisioning/include
    ../../../../../../rtos/freertos/demos/dev_mode_key_provisioning/include/: aws_dev_mode_key_provisioning.h
  group freertos/demos/dev_mode_key_provisioning/src
    ../../../../../../rtos/freertos/demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c
  group freertos/vendors/nxp/wifi/nxp
    ../../../../../../rtos/freertos/vendors/nxp/wifi/nxp/: iot_wifi.c
  group freertos/libraries/3rdparty/unity/extras/fixture/src
    ../../../../../../rtos/freertos/libraries/3rdparty/unity/extras/fixture/src/: unity_fixture.c unity_fixture.h unity_fixture_internals.h unity_fixture_malloc_overrides.h
  group freertos/libraries/3rdparty/unity/src
    ../../../../../../rtos/freertos/libraries/3rdparty/unity/src/: unity.c unity.h unity_internals.h
  group freertos/libraries/abstractions/pkcs11/test
    ../../../../../../rtos/freertos/libraries/abstractions/pkcs11/test/: iot_test_pkcs11.c iot_test_pkcs11_globals.h
  group freertos/libraries/abstractions/secure_sockets/test
    ../../../../../../rtos/freertos/libraries/abstractions/secure_sockets/test/: iot_test_tcp.c
  group freertos/libraries/abstractions/wifi/test
    ../../../../../../rtos/freertos/libraries/abstractions/wifi/test/: iot_test_wifi.c iot_test_wifi.h
  group freertos/libraries/c_sdk/aws/shadow/test
    ../../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/test/: aws_test_shadow.c
  group freertos/libraries/c_sdk/aws/shadow/test/system
    ../../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/test/system/: aws_iot_tests_shadow_system.c
  group freertos/libraries/c_sdk/aws/shadow/test/unit
    ../../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/test/unit/: aws_iot_tests_shadow_api.c aws_iot_tests_shadow_parser.c
  group freertos/libraries/c_sdk/standard/common/test
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/common/test/: iot_memory_leak.c iot_tests_taskpool.c
  group freertos/libraries/c_sdk/standard/mqtt/test/access
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/test/access/: iot_test_access_mqtt.h
  group freertos/libraries/c_sdk/standard/mqtt/test
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/test/: iot_test_mqtt_agent.c
  group freertos/libraries/c_sdk/standard/mqtt/test/mock
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/test/mock/: iot_tests_mqtt_mock.c iot_tests_mqtt_mock.h
  group freertos/libraries/c_sdk/standard/mqtt/test/system
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/test/system/: iot_tests_mqtt_system.c
  group freertos/libraries/c_sdk/standard/mqtt/test/unit
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/test/unit/: iot_tests_mqtt_api.c iot_tests_mqtt_metrics.c iot_tests_mqtt_receive.c iot_tests_mqtt_subscription.c iot_tests_mqtt_validate.c
  group freertos/libraries/freertos_plus/aws/greengrass/test
    ../../../../../../rtos/freertos/libraries/freertos_plus/aws/greengrass/test/: aws_greengrass_discovery_test_access_declare.h aws_greengrass_discovery_test_access_define.h aws_test_helper_secure_connect.c
  group freertos/libraries/freertos_plus/standard/crypto/test
    ../../../../../../rtos/freertos/libraries/freertos_plus/standard/crypto/test/: iot_test_crypto.c
  group freertos/libraries/freertos_plus/standard/tls/test
    ../../../../../../rtos/freertos/libraries/freertos_plus/standard/tls/test/: iot_test_tls.c iot_test_tls.h
  group freertos/tests/common
    ../../../../../../rtos/freertos/tests/common/: aws_test.c aws_test_framework.c aws_test_runner.c iot_test_freertos.c iot_tests_network.c
  group freertos/tests/include
    ../../../../../../rtos/freertos/tests/include/: aws_application_version.h aws_clientcredential.h aws_clientcredential_keys.h aws_test_framework.h aws_test_runner.h aws_test_tcp.h aws_test_utils.h aws_unity_config.h iot_config_common.h
  group freertos/vendors/nxp/secure_sockets/lwip
    ../../../../../../rtos/freertos/vendors/nxp/secure_sockets/lwip/: iot_secure_sockets.c
  group freertos/libraries/freertos_plus/aws/greengrass/include
    ../../../../../../rtos/freertos/libraries/freertos_plus/aws/greengrass/include/: aws_ggd_config_defaults.h aws_greengrass_discovery.h
  group freertos/libraries/freertos_plus/aws/greengrass/src
    ../../../../../../rtos/freertos/libraries/freertos_plus/aws/greengrass/src/: aws_greengrass_discovery.c aws_helper_secure_connect.c aws_helper_secure_connect.h
  group lwip/port
    ../../../../../../middleware/lwip/port/: sys_arch.c
  group lwip/port/arch
    ../../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src/api
    ../../../../../../middleware/lwip/src/api/: sockets.c netifapi.c netdb.c netbuf.c tcpip.c api_msg.c err.c if_api.c api_lib.c
  group lwip/src/core
    ../../../../../../middleware/lwip/src/core/: memp.c def.c ip.c pbuf.c altcp.c tcp_out.c raw.c altcp_tcp.c sys.c init.c inet_chksum.c timeouts.c tcp_in.c netif.c mem.c udp.c tcp.c stats.c dns.c altcp_alloc.c
  group lwip/src/core/ipv6
    ../../../../../../middleware/lwip/src/core/ipv6/: ethip6.c dhcp6.c ip6_addr.c nd6.c mld6.c icmp6.c ip6_frag.c ip6.c inet6.c
  group lwip/src/core/ipv4
    ../../../../../../middleware/lwip/src/core/ipv4/: dhcp.c ip4.c autoip.c icmp.c acd.c etharp.c ip4_addr.c igmp.c ip4_frag.c
  group lwip/src/include/compat/stdc
    ../../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/compat/posix
    ../../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/sys
    ../../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/posix/net
    ../../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/lwip
    ../../../../../../middleware/lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/priv
    ../../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h mem_priv.h memp_priv.h memp_std.h api_msg.h nd6_priv.h tcpip_priv.h tcp_priv.h raw_priv.h sockets_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../../middleware/lwip/src/include/lwip/prot/: ip6.h udp.h mld6.h ip4.h icmp.h igmp.h dhcp.h tcp.h autoip.h iana.h ieee.h dns.h icmp6.h ethernet.h nd6.h ip.h acd.h dhcp6.h etharp.h
  group lwip/src/include/netif
    ../../../../../../middleware/lwip/src/include/netif/: bridgeif.h zepif.h lowpan6.h ieee802154.h ethernet.h lowpan6_common.h lowpan6_opts.h bridgeif_opts.h slipif.h lowpan6_ble.h etharp.h
  group lwip/src/include/netif/ppp
    ../../../../../../middleware/lwip/src/include/netif/ppp/: ipv6cp.h pppapi.h magic.h ppp.h upap.h mppe.h pppol2tp.h pppoe.h ipcp.h pppdebug.h eap.h pppos.h ppp_opts.h pppcrypt.h vj.h chap-new.h eui64.h chap_ms.h ccp.h ecp.h lcp.h fsm.h ppp_impl.h chap-md5.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: sha1.h des.h md5.h md4.h arc4.h
  group lwip/src/netif
    ../../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group utilities
    ../../../../../../devices/MIMXRT1166/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1166/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1166/utilities/: fsl_assert.c
  group wifi/dhcpd
    ../../../../../../middleware/wifi/dhcpd/: dhcp-bootp.h dhcp-priv.h dhcp-server-main.c dhcp-server.c dns-server.c dns.h
  group wifi/incl/port/lwip
    ../../../../../../middleware/wifi/incl/port/lwip/: wm_net.h
  group wifi/port/lwip
    ../../../../../../middleware/wifi/port/lwip/: net.c netif_decl.h wifi_netif.c
  group wifi/wlcmgr
    ../../../../../../middleware/wifi/wlcmgr/: wlan.c wlan_txpwrlimit_cfg.c
  group sdmmc/src
    ../../../../../../middleware/sdmmc/sdio/: fsl_sdio.c
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../../middleware/sdmmc/sdio/: fsl_sdio.h
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sdio
    ../../../../../../middleware/sdmmc/sdio/: ChangeLogKSDK.txt
  group sdmmc/host
    ../../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt
    ../../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group freertos/freertos_kernel
    ../../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    ../../../../../../rtos/freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos_kernel/portable/GCC/ARM_CM4F
    ../../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos_kernel/portable
    ../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/libraries/c_sdk/aws/shadow/include
    ../../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/include/: aws_iot_shadow.h aws_shadow.h
  group freertos/libraries/c_sdk/aws/shadow/include/types
    ../../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/include/types/: aws_iot_shadow_types.h
  group freertos/libraries/c_sdk/aws/shadow/src
    ../../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/src/: aws_iot_shadow_api.c aws_iot_shadow_operation.c aws_iot_shadow_parser.c aws_iot_shadow_static_memory.c aws_iot_shadow_subscription.c aws_shadow.c aws_shadow_config_defaults.h
  group freertos/libraries/c_sdk/aws/shadow/src/private
    ../../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/src/private/: aws_iot_shadow_internal.h
  group freertos/libraries/c_sdk/standard/serializer/include
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/serializer/include/: iot_json_utils.h iot_serializer.h
  group freertos/libraries/c_sdk/standard/serializer/src
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/serializer/src/: iot_json_utils.c iot_serializer_static_memory.c
  group freertos/libraries/c_sdk/standard/serializer/src/json
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/serializer/src/json/: iot_serializer_json_decoder.c iot_serializer_json_encoder.c
  group freertos/libraries/3rdparty/pkcs11
    ../../../../../../rtos/freertos/libraries/3rdparty/pkcs11/: CONTRIBUTING.md LICENSE.md pkcs11.h pkcs11f.h pkcs11t.h README.md
  group freertos/vendors/nxp/pkcs11/common
    ../../../../../../rtos/freertos/vendors/nxp/pkcs11/common/: iot_pkcs11_pal.c
  group freertos/libraries/abstractions/pkcs11/corePKCS11/source
    ../../../../../../rtos/freertos/libraries/abstractions/pkcs11/corePKCS11/source/: core_pkcs11.c core_pki_utils.c
  group freertos/libraries/abstractions/pkcs11/corePKCS11/source/include
    ../../../../../../rtos/freertos/libraries/abstractions/pkcs11/corePKCS11/source/include/: core_pkcs11.h core_pkcs11_pal.h core_pki_utils.h
  group freertos/libraries/abstractions/pkcs11/corePKCS11/source/portable/mbedtls
    ../../../../../../rtos/freertos/libraries/abstractions/pkcs11/corePKCS11/source/portable/mbedtls/: core_pkcs11_mbedtls.c
  group freertos/libraries/logging/include
    ../../../../../../rtos/freertos/libraries/logging/include/: iot_logging_task.h logging_levels.h logging_stack.h
  group freertos/libraries/logging
    ../../../../../../rtos/freertos/libraries/logging/: iot_logging.c iot_logging_task_dynamic_buffers.c
  group freertos/libraries/3rdparty/mbedtls_config
    ../../../../../../rtos/freertos/libraries/3rdparty/mbedtls_config/: threading_alt.h
  group device
    ../../../../../../devices/MIMXRT1166/: fsl_device_registers.h MIMXRT1166_cm4.h MIMXRT1166_cm4_features.h system_MIMXRT1166_cm4.c system_MIMXRT1166_cm4.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMXRT1166/arm/: startup_MIMXRT1166_cm4.S
  group xip
    ../../../../../../devices/MIMXRT1166/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1160_flexspi_nor_config.c evkmimxrt1160_flexspi_nor_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
  group freertos/libraries/c_sdk/standard/common/include
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/: iot_appversion32.h iot_atomic.h iot_init.h iot_linear_containers.h iot_logging_setup.h iot_taskpool.h
  group freertos/libraries/c_sdk/standard/common/include/private
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/private/: iot_default_root_certificates.h iot_doubly_linked_list.h iot_error.h iot_lib_init.h iot_logging.h iot_static_memory.h iot_taskpool_internal.h
  group freertos/libraries/c_sdk/standard/common/include/types
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/types/: iot_network_types.h iot_taskpool_types.h
  group freertos/libraries/c_sdk/standard/common
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/common/: iot_device_metrics.c iot_init.c iot_static_memory_common.c
  group freertos/libraries/c_sdk/standard/common/taskpool
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group freertos/libraries/abstractions/platform/freertos/include/platform
    ../../../../../../rtos/freertos/libraries/abstractions/platform/freertos/include/platform/: iot_network_ble.h iot_network_freertos.h iot_platform_types_freertos.h
  group freertos/libraries/abstractions/platform/freertos
    ../../../../../../rtos/freertos/libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_metrics.c iot_network_freertos.c iot_threads_freertos.c
  group freertos/libraries/abstractions/platform/include/platform
    ../../../../../../rtos/freertos/libraries/abstractions/platform/include/platform/: iot_clock.h iot_metrics.h iot_network.h iot_threads.h
  group freertos/libraries/abstractions/platform/include/types
    ../../../../../../rtos/freertos/libraries/abstractions/platform/include/types/: iot_platform_types.h
  group freertos/libraries/abstractions/secure_sockets/include
    ../../../../../../rtos/freertos/libraries/abstractions/secure_sockets/include/: iot_secure_sockets.h iot_secure_sockets_config_defaults.h iot_secure_sockets_wrapper_metrics.h
  group freertos/libraries/freertos_plus/standard/utils/include
    ../../../../../../rtos/freertos/libraries/freertos_plus/standard/utils/include/: iot_system_init.h
  group freertos/libraries/freertos_plus/standard/utils/src
    ../../../../../../rtos/freertos/libraries/freertos_plus/standard/utils/src/: iot_system_init.c
  group freertos/libraries/freertos_plus/standard/crypto/include
    ../../../../../../rtos/freertos/libraries/freertos_plus/standard/crypto/include/: iot_crypto.h
  group freertos/libraries/freertos_plus/standard/crypto/src
    ../../../../../../rtos/freertos/libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group freertos/libraries/abstractions/wifi/include
    ../../../../../../rtos/freertos/libraries/abstractions/wifi/include/: iot_wifi.h
  group wifi/incl
    ../../../../../../middleware/wifi/incl/: dhcp-server.h wifi_cal_data_ext.h wm_utils.h wmerrno.h wmlog.h wmtypes.h
  group wifi/incl/port/os
    ../../../../../../middleware/wifi/incl/port/os/: wm_os.h
  group wifi/incl/wifidriver
    ../../../../../../middleware/wifi/incl/wifidriver/: mlan_sdio_api.h wifi-decl.h wifi.h wifi_events.h
  group wifi/incl/wlcmgr
    ../../../../../../middleware/wifi/incl/wlcmgr/: wlan.h wlan_11d.h
  group wifi/port/os
    ../../../../../../middleware/wifi/port/os/: os.c
  group wifi/wifi_bt_firmware
    ../../../../../../middleware/wifi/wifi_bt_firmware/: sd8801_wlan.h sduart8977_wlan_bt.h sduartIW416_wlan_bt.h sduart8987_wlan_bt.h
  group wifi/wifidriver/incl
    ../../../../../../middleware/wifi/wifidriver/incl/: mlan.h mlan_11ac.h mlan_11h.h mlan_11n.h mlan_11n_aggr.h mlan_11n_rxreorder.h mlan_api.h mlan_decl.h mlan_fw.h mlan_ieee.h mlan_init.h mlan_ioctl.h mlan_join.h mlan_main.h mlan_meas.h mlan_remap_mem_operations.h mlan_sdio.h mlan_uap.h mlan_util.h mlan_wmm.h
  group wifi/wifidriver
    ../../../../../../middleware/wifi/wifidriver/: mlan_11ac.c mlan_11d.c mlan_11h.c mlan_11n.c mlan_11n_aggr.c mlan_11n_rxreorder.c mlan_api.c mlan_cfp.c mlan_cmdevt.c mlan_glue.c mlan_init.c mlan_join.c mlan_misc.c mlan_scan.c mlan_sdio.c mlan_shim.c mlan_sta_cmd.c mlan_sta_cmdresp.c mlan_sta_event.c mlan_sta_ioctl.c mlan_sta_rx.c mlan_txrx.c mlan_uap_cmdevent.c mlan_uap_ioctl.c mlan_wmm.c wifi-debug.c wifi-debug.h wifi-internal.h wifi-mem.c wifi-sdio.c wifi-sdio.h wifi-uap.c wifi.c wifi_common.h wifi_pwrmgr.c
  group freertos/libraries/freertos_plus/standard/tls/include
    ../../../../../../rtos/freertos/libraries/freertos_plus/standard/tls/include/: iot_tls.h
  group freertos/libraries/freertos_plus/standard/tls/src
    ../../../../../../rtos/freertos/libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group freertos/libraries/3rdparty/mbedtls_utils
    ../../../../../../rtos/freertos/libraries/3rdparty/mbedtls_utils/: LICENSE-2.0.txt mbedtls_error.c mbedtls_error.h mbedtls_utils.c README.md
  group freertos/libraries/3rdparty/jsmn
    ../../../../../../rtos/freertos/libraries/3rdparty/jsmn/: jsmn.c jsmn.h LICENSE
  group sdmmc/osa
    ../../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c
  group freertos/libraries/c_sdk/standard/mqtt
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/: CODESIZE.md README.md
  group freertos/libraries/c_sdk/standard/mqtt/include
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/include/: iot_mqtt.h iot_mqtt_agent.h iot_mqtt_agent_config_defaults.h iot_mqtt_config_defaults.h iot_mqtt_lib.h
  group freertos/libraries/c_sdk/standard/mqtt/include/types
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/include/types/: iot_mqtt_types.h
  group freertos/libraries/c_sdk/standard/mqtt/src
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/src/: iot_mqtt_agent.c iot_mqtt_api.c iot_mqtt_context_connection.c iot_mqtt_managed_function_wrapper.c iot_mqtt_mutex_wrapper.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_publish_duplicates.c iot_mqtt_serializer_deserializer_wrapper.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_subscription_container.c iot_mqtt_validate.c
  group freertos/libraries/c_sdk/standard/mqtt/src/private
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/src/private/: iot_mqtt_internal.h
  group freertos/libraries/coreMQTT/source
    ../../../../../../rtos/freertos/libraries/coreMQTT/source/: core_mqtt.c core_mqtt_serializer.c core_mqtt_state.c
  group freertos/libraries/coreMQTT/source/include
    ../../../../../../rtos/freertos/libraries/coreMQTT/source/include/: core_mqtt.h core_mqtt_config_defaults.h core_mqtt_serializer.h core_mqtt_state.h
  group freertos/libraries/coreMQTT/source/interface
    ../../../../../../rtos/freertos/libraries/coreMQTT/source/interface/: transport_interface.h
target aws_tests_wifi_nxp_cm4 flexspi_nor_release (ARM-ADS)
  device: MIMXRT1166DVM6A:cm4 NXP
  pack: NXP.MIMXRT1166_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: aws_tests_wifi_nxp_cm4.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=0, NDEBUG, CPU_MIMXRT1166DVM6A_cm4, XIP_BOOT_HEADER_DCD_ENABLE=1, USE_SDRAM, USE_RTOS=1, MBEDTLS_CONFIG_FILE='\"aws_mbedtls_config.h\"', UNITY_INCLUDE_CONFIG_H, AMAZON_FREERTOS_ENABLE_UNIT_TESTS, CRYPTO_USE_DRIVER_CAAM, MFLASH_FILE_BASEADDR=14221312, SDIO_ENABLED, SDK_OS_FREE_RTOS, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../../../..;../config_files
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1166xxxxx_cm4_flexspi_nor_sdram.scf
  link misc: as above
