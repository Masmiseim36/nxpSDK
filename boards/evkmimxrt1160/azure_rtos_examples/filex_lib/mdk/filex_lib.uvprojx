# Keil uVision project filex_lib.uvprojx, settings and files
target filex_lib Debug (ARM-ADS)
  device: MIMXRT1166DVM6A:cm7 NXP
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: libfilex.lib (library)
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: DEBUG, CPU_MIMXRT1166DVM6A_cm7, TX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../rtos/azure-rtos/binary/threadx;../../../../../rtos/azure-rtos/binary/filex;../../../../../rtos/azure-rtos/threadx/common/inc;../../../../../rtos/azure-rtos/filex/common/inc;../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc;../../../../../rtos/azure-rtos/filex/ports/cortex_m7/ac6/inc
  asm define: DEBUG, DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group doc
    ../: readme.txt
  group azure-rtos/config
    ../../../../../rtos/azure-rtos/binary/threadx/: tx_user.h
    ../../../../../rtos/azure-rtos/binary/filex/: fx_user.h
  group azure-rtos/threadx/common/inc
    ../../../../../rtos/azure-rtos/threadx/common/inc/: tx_byte_pool.h tx_event_flags.h tx_timer.h tx_queue.h tx_thread.h tx_mutex.h tx_trace.h tx_initialize.h tx_api.h tx_user_sample.h tx_block_pool.h tx_semaphore.h
  group azure-rtos/filex/common/inc
    ../../../../../rtos/azure-rtos/filex/common/inc/: fx_media.h fx_unicode.h fx_api.h fx_directory_exFAT.h fx_utility.h fx_file.h fx_system.h fx_directory.h fx_user_sample.h fx_fault_tolerant.h
  group azure-rtos/filex/common/src
    ../../../../../rtos/azure-rtos/filex/common/src/: fx_utility_logical_sector_read.c fx_file_read.c fx_directory_attributes_set.c fx_utility_FAT_flush.c fx_file_create.c fx_utility_memory_set.c fxe_file_extended_truncate.c fx_media_read.c fx_unicode_file_create.c fx_directory_name_test.c fxe_media_open.c fx_utility_exFAT_system_sector_write.c fxe_media_volume_get.c fx_media_open.c fx_fault_tolerant_recover.c fx_fault_tolerant_read_FAT.c fx_file_delete.c fxe_unicode_file_rename.c fx_unicode_length_get_extended.c fxe_media_check.c fx_directory_long_name_get.c fxe_directory_long_name_get.c fx_fault_tolerant_reset_log_file.c fxe_file_write.c fxe_file_truncate.c fx_media_extended_space_available.c fxe_directory_first_entry_find.c fx_utility_logical_sector_cache_entry_read.c fx_utility_memory_copy.c fx_file_extended_allocate.c fx_directory_first_full_entry_find.c fxe_media_read.c fxe_media_close_notify_set.c fx_directory_local_path_get.c fx_unicode_file_rename.c fx_utility_exFAT_size_calculate.c fxe_system_time_set.c fx_file_close.c fx_directory_local_path_restore.c fx_utility_FAT_sector_get.c fxe_media_space_available.c fx_utility_exFAT_unicode_name_hash_get.c fx_trace_object_register.c fx_media_close.c fxe_directory_next_entry_find.c fx_fault_tolerant_transaction_end.c fx_directory_short_name_get.c fx_directory_entry_read.c fxe_directory_local_path_set.c fx_utility_32_unsigned_write.c fxe_unicode_directory_create.c fx_utility_string_length_get.c fx_media_cache_invalidate.c fxe_directory_short_name_get_extended.c fxe_directory_delete.c fx_directory_default_get_copy.c fxe_media_extended_space_available.c fx_media_check.c fx_utility_FAT_entry_write.c fx_fault_tolerant_create_log_file.c fxe_unicode_short_name_get.c fx_fault_tolerant_transaction_start.c fx_system_time_get.c fx_utility_exFAT_system_area_format.c fx_unicode_directory_rename.c fx_unicode_short_name_get_extended.c fx_utility_FAT_entry_read.c fx_fault_tolerant_write_log_file.c fx_utility_exFAT_geometry_check.c fx_directory_local_path_set.c fx_fault_tolerant_enable.c fx_utility_16_unsigned_read.c fxe_directory_information_get.c fx_utility_exFAT_bitmap_cache_prepare.c fxe_file_date_time_set.c fx_unicode_directory_search.c fx_unicode_length_get.c fxe_media_close.c fxe_directory_short_name_get.c fxe_unicode_name_get.c fx_directory_next_entry_find.c fx_file_seek.c fx_fault_tolerant_read_directory_sector.c fx_utility_exFAT_bitmap_cache_update.c fx_file_write_notify_set.c fx_utility_logical_sector_flush.c fx_utility_32_unsigned_read.c fx_directory_exFAT_entry_write.c fx_file_open.c fx_fault_tolerant_add_FAT_log.c fxe_directory_attributes_set.c fx_unicode_directory_create.c fxe_directory_default_set.c fx_trace_event_insert.c fx_file_extended_truncate.c fx_system_date_set.c fx_media_format_oem_name_set.c fxe_file_rename.c fxe_file_extended_best_effort_allocate.c fxe_file_read.c fx_file_truncate_release.c fx_directory_default_set.c fx_utility_token_length_get.c fx_media_format_type_set.c fx_directory_next_full_entry_find.c fx_directory_default_get.c fxe_directory_create.c fx_media_volume_get_extended.c fx_partition_offset_calculate.c fxe_directory_default_get.c fxe_file_delete.c fx_utility_exFAT_system_area_checksum_write.c fxe_unicode_directory_rename.c fx_utility_16_unsigned_write.c fx_file_write.c fx_utility_exFAT_bitmap_initialize.c fx_utility_FAT_map_flush.c fxe_unicode_short_name_get_extended.c fxe_directory_rename.c fxe_system_date_set.c fxe_file_best_effort_allocate.c fx_media_format_volume_id_set.c fxe_system_time_get.c fx_directory_attributes_read.c fx_media_open_notify_set.c fxe_directory_local_path_restore.c fx_file_extended_truncate_release.c fxe_file_open.c fxe_directory_local_path_clear.c fx_media_abort.c fx_media_check_FAT_chain_check.c fxe_file_write_notify_set.c fx_fault_tolerant_apply_logs.c fx_system_time_set.c fx_unicode_name_get_extended.c fx_directory_create.c fx_directory_entry_write.c fx_utility_exFAT_upcase_table.c fx_media_space_available.c fx_directory_short_name_get_extended.c fx_fault_tolerant_set_FAT_chain.c fx_fault_tolerant_calculate_checksum.c fx_directory_first_entry_find.c fx_system_date_get.c fxe_file_attributes_read.c fx_media_volume_get.c fx_fault_tolerant_add_bitmap_log.c fx_file_extended_relative_seek.c fx_utility_exFAT_bitmap_start_sector_get.c fx_ram_driver.c fx_directory_exFAT_free_search.c fx_utility_exFAT_bitmap_free_cluster_find.c fx_fault_tolerant_transaction_fail.c fx_fault_tolerant_read_log_file.c fx_media_volume_set.c fx_file_attributes_read.c fx_directory_search.c fxe_directory_first_full_entry_find.c fx_file_truncate.c fx_directory_delete.c fxe_directory_local_path_get_copy.c fx_directory_exFAT_entry_read.c fx_utility_exFAT_bitmap_flush.c fxe_directory_next_full_entry_find.c fxe_file_attributes_set.c fx_file_extended_seek.c fx_utility_absolute_path_get.c fxe_media_write.c fx_unicode_name_get.c fx_media_write.c fx_utility_logical_sector_write.c fx_media_close_notify_set.c fx_file_allocate.c fx_directory_free_search.c fxe_file_seek.c fx_fault_tolerant_add_checksum_log.c fxe_media_exFAT_format.c fxe_file_create.c fx_directory_local_path_clear.c fx_directory_rename.c fx_utility_exFAT_system_area_checksum_verify.c fxe_media_format.c fx_directory_long_name_get_extended.c fxe_unicode_name_get_extended.c fxe_file_extended_allocate.c fx_file_attributes_set.c fx_directory_local_path_get_copy.c fx_file_extended_best_effort_allocate.c fxe_directory_default_get_copy.c fx_utility_exFAT_allocate_new_cluster.c fx_utility_exFAT_cluster_state_set.c fx_utility_exFAT_cluster_free.c fx_trace_object_unregister.c fxe_directory_attributes_read.c fx_media_flush.c fxe_unicode_file_create.c fxe_media_volume_set.c fxe_file_close.c fx_media_boot_info_extract.c fx_fault_tolerant_cleanup_FAT_chain.c fx_utility_exFAT_name_hash_get.c fx_media_exFAT_format.c fx_unicode_directory_entry_change.c fxe_fault_tolerant_enable.c fxe_directory_long_name_get_extended.c fxe_media_open_notify_set.c fx_system_timer_entry.c fx_unicode_directory_entry_read.c fxe_file_relative_seek.c fx_directory_exFAT_unicode_entry_write.c fx_media_check_lost_cluster_check.c fx_utility_exFAT_cluster_state_get.c fxe_media_flush.c fx_directory_name_extract.c fxe_system_date_get.c fxe_file_extended_truncate_release.c fxe_directory_name_test.c fxe_media_abort.c fx_utility_64_unsigned_read.c fx_fault_tolerant_add_dir_log.c fx_file_date_time_set.c fx_file_best_effort_allocate.c fxe_media_volume_get_extended.c fx_utility_64_unsigned_write.c fx_unicode_short_name_get.c fxe_file_extended_relative_seek.c fxe_file_truncate_release.c fx_directory_information_get.c fx_system_initialize.c fx_file_relative_seek.c fx_trace_event_update.c fxe_file_allocate.c fxe_directory_local_path_get.c fxe_file_extended_seek.c fxe_media_cache_invalidate.c fx_file_rename.c fx_media_format.c
  group azure-rtos/threadx/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc/: tx_port.h
  group azure-rtos/filex/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/filex/ports/cortex_m7/ac6/inc/: fx_port.h
target filex_lib Release (ARM-ADS)
  device: MIMXRT1166DVM6A:cm7 NXP
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: libfilex.lib (library)
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1166DVM6A_cm7, TX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE
  c misc: as above
  c include: as above
  asm define: NDEBUG, NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
