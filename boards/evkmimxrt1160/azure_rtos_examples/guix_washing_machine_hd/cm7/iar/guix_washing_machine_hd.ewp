# IAR project guix_washing_machine_hd.ewp, settings and files
configuration flexspi_nor_sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1166xxx6_M7 NXP MIMXRT1166xxx6_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1166DVM6A_cm7; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; GX_INCLUDE_USER_DEFINE_FILE; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; TX_INCLUDE_USER_DEFINE_FILE
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../rtos/azure-rtos/guix/common/inc; ../../../../../../rtos/azure-rtos/guix/ports/cortex_m7/iar/inc; ../../../../../../components/video; ../../../../../../components/video/display; ../../../../../../components/video/display/rm68200; ../../../../../../components/video/display/rm68191; ../../../../../../devices/MIMXRT1166/drivers; ../../../../../../components/video/display/mipi_dsi_cmd; ../../../../../../components/video/display/dc/lcdifv2; ../../../../../../components/video/display/dc/elcdif; ../../../../../../components/gt911; ../../../../../../components/lists; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../devices/MIMXRT1166; ../../../../../../CMSIS/Include; ../../../../../../devices/MIMXRT1166/drivers/cm7; ../../../../xip; ../../../../../../devices/MIMXRT1166/xip; ../../../../../../devices/MIMXRT1166/utilities/str; ../../../../../../devices/MIMXRT1166/utilities/debug_console; ../../../../../../rtos/azure-rtos/threadx/common/inc; ../../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/iar/inc; ../../../../../../components/video/display/dc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA; TX_ENABLE_FPU_SUPPORT
  ILINK.IlinkOutputFile: guix_washing_machine_hd.out
  ILINK.IlinkIcfFile: MIMXRT1166xxxxx_cm7_flexspi_nor_sdram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../rtos/azure-rtos/binary/guix/cortex_m7/iar/libguix.a; ../../../../../../rtos/azure-rtos/binary/threadx/cortex_m7/iar/libthreadx.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1166DVM6A_cm7; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; GX_INCLUDE_USER_DEFINE_FILE; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; TX_INCLUDE_USER_DEFINE_FILE
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA; TX_ENABLE_FPU_SUPPORT
  group board
    ../: display_support.h display_support.c pin_mux.c pin_mux.h touch_support.c touch_support.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group source
    ../: gx_display_driver_imxrt11xx_565rgb.c demo_guix_washing_machine.c demo_guix_washing_machine.h garments.c demo_guix_washing_machine_resources.c demo_guix_washing_machine_resources.h demo_guix_washing_machine_specifications.c demo_guix_washing_machine_specifications.h temperature.c washer_on.c water_level.c
  group azure-rtos/config
    ../: tx_user.h gx_user.h
  group azure-rtos/guix/common/inc
    ../../../../../../rtos/azure-rtos/guix/common/inc/: gx_utility.h gx_multi_line_text_input.h gx_sprite.h gx_radial_slider.h gx_menu.h gx_animation.h gx_text_input_cursor.h gx_canvas.h gx_line_chart.h gx_button.h gx_radial_progress_bar.h gx_numeric_prompt.h gx_scroll_wheel.h gx_context.h gx_icon.h gx_window.h gx_system.h gx_numeric_pixelmap_prompt.h gx_image_reader.h gx_progress_bar.h gx_tree_view.h gx_user_sample.h gx_prompt.h gx_api.h gx_rich_text_view.h gx_slider.h gx_display.h gx_single_line_text_input.h gx_binres_loader.h gx_pixelmap_prompt.h gx_widget.h gx_scrollbar.h gx_screen_stack.h gx_system_rtos_bind.h gx_multi_line_text_view.h gx_circular_gauge.h gx_drop_list.h
  group azure-rtos/guix/ports/cortex_m7/iar/inc
    ../../../../../../rtos/azure-rtos/guix/ports/cortex_m7/iar/inc/: gx_port.h
  group azure-rtos/threadx/common/inc
    ../../../../../../rtos/azure-rtos/threadx/common/inc/: tx_byte_pool.h tx_event_flags.h tx_timer.h tx_queue.h tx_thread.h tx_mutex.h tx_trace.h tx_initialize.h tx_api.h tx_user_sample.h tx_block_pool.h tx_semaphore.h
  group azure-rtos/threadx/ports/cortex_m7/iar/inc
    ../../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/iar/inc/: tx_port.h
  group azure-rtos/threadx/ports/cortex_m7/iar/src
    ../../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/iar/src/: tx_thread_interrupt_control.s tx_timer_interrupt.s tx_thread_interrupt_restore.s tx_iar.c tx_thread_schedule.s tx_initialize_low_level.s tx_thread_stack_build.s tx_thread_system_return.s tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_disable.s
  group doc
    ../: readme.txt
  group video
    ../../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../../components/video/display/: fsl_display.h
    ../../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
    ../../../../../../components/video/display/dc/lcdifv2/: fsl_dc_fb_lcdifv2.h fsl_dc_fb_lcdifv2.c
    ../../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.h fsl_dc_fb_elcdif.c
    ../../../../../../components/video/display/dc/: fsl_dc_fb.h
  group drivers
    ../../../../../../devices/MIMXRT1166/drivers/: fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_common.h fsl_common.c fsl_elcdif.c fsl_elcdif.h fsl_lpi2c.c fsl_lpi2c.h fsl_soc_src.h fsl_soc_src.c fsl_lpuart.h fsl_lpuart.c fsl_clock.h fsl_clock.c fsl_dcdc.h fsl_dcdc.c fsl_gpio.h fsl_gpio.c fsl_iomuxc.h fsl_pmu.h fsl_pmu.c fsl_anatop_ai.h fsl_anatop_ai.c fsl_soc_mipi_csi2rx.h fsl_soc_mipi_csi2rx.c fsl_lcdifv2.c fsl_lcdifv2.h
    ../../../../../../devices/MIMXRT1166/drivers/cm7/: fsl_cache.c fsl_cache.h
  group touchpanel
    ../../../../../../components/gt911/: fsl_gt911.h fsl_gt911.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group device
    ../../../../../../devices/MIMXRT1166/: fsl_device_registers.h MIMXRT1166_cm7.h MIMXRT1166_cm7_features.h system_MIMXRT1166_cm7.c system_MIMXRT1166_cm7.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group startup
    ../../../../../../devices/MIMXRT1166/iar/: startup_MIMXRT1166_cm7.s
  group xip
    ../../../../xip/: evkmimxrt1160_flexspi_nor_config.c evkmimxrt1160_flexspi_nor_config.h
    ../../../../../../devices/MIMXRT1166/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
  group utilities
    ../../../../../../devices/MIMXRT1166/utilities/: fsl_assert.c
    ../../../../../../devices/MIMXRT1166/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1166/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
