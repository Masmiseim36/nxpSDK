# Keil uVision project pnp_temperature_controller.uvprojx, settings and files
target pnp_temperature_controller sdram_txt_debug (ARM-ADS)
  device: MIMXRT1166DVM6A:cm7 NXP
  pack: NXP.MIMXRT1166_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: pnp_temperature_controller.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_SDRAM, DATA_SECTION_IS_CACHEABLE, DEBUG, __CLANG_ARM, CPU_MIMXRT1166DVM6A_cm7, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, ASC_SERIALIZER_USE_CUSTOM_ALLOCATOR, AZ_NO_PRECONDITION_CHECKING, CRYPTO_USE_DRIVER_CAAM, NX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE
  c misc: -Wno-tautological-pointer-compare  -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../azure_iot/azure-sdk-for-c/sdk/inc;../azure_iot;../azure_iot/azure_iot_security_module;../azure_iot/azure_iot_security_module/inc;../azure_iot/azure_iot_security_module/iot-security-module-core/inc;../azure_iot/azure_iot_security_module/iot-security-module-core/deps/flatcc/src/runtime;../azure_iot/azure_iot_security_module/iot-security-module-core/deps/flatcc/include;..;../../../../../../components/phy/mdio/enet;../../../../../../components/phy/device/phyksz8081;../../../../../../components/phy/device/phyrtl8211f;../../../../../../devices/MIMXRT1166/drivers;../../../../../../components/lists;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../devices/MIMXRT1166;../../../../../../CMSIS/Include;../../../../../../devices/MIMXRT1166/drivers/cm7;../../../../xip;../../../../../../devices/MIMXRT1166/xip;../../../../../../devices/MIMXRT1166/utilities/str;../../../../../../devices/MIMXRT1166/utilities/debug_console;../../../../../../rtos/azure-rtos/netxduo/addons/auto_ip;../../../../../../rtos/azure-rtos/netxduo/addons/cloud;../../../../../../rtos/azure-rtos/netxduo/addons/BSD;../../../../../../rtos/azure-rtos/netxduo/addons/dhcp;../../../../../../rtos/azure-rtos/netxduo/addons/dns;../../../../../../rtos/azure-rtos/netxduo/addons/ftp;../../../../../../rtos/azure-rtos/netxduo/addons/http;../../../../../../rtos/azure-rtos/netxduo/addons/mdns;../../../../../../rtos/azure-rtos/netxduo/addons/mqtt;../../../../../../rtos/azure-rtos/netxduo/addons/nat;../../../../../../rtos/azure-rtos/netxduo/addons/pop3;../../../../../../rtos/azure-rtos/netxduo/addons/ppp;../../../../../../rtos/azure-rtos/netxduo/addons/pppoe;../../../../../../rtos/azure-rtos/netxduo/addons/smtp;../../../../../../rtos/azure-rtos/netxduo/addons/snmp;../../../../../../rtos/azure-rtos/netxduo/addons/sntp;../../../../../../rtos/azure-rtos/netxduo/addons/telnet;../../../../../../rtos/azure-rtos/netxduo/addons/tftp;../../../../../../rtos/azure-rtos/netxduo/addons/web;../../../../../../rtos/azure-rtos/netxduo/common/inc;../../../../../../rtos/azure-rtos/netxduo/crypto_libraries/inc;../../../../../../rtos/azure-rtos/netxduo/nx_secure/inc;../../../../../../rtos/azure-rtos/netxduo/nx_secure/ports;../../../../../../rtos/azure-rtos/netxduo/ports/cortex_m7/ac6/inc;../../../../../../rtos/azure-rtos/filex/common/inc;../../../../../../rtos/azure-rtos/filex/ports/cortex_m7/ac6/inc;../../../../../../rtos/azure-rtos/threadx/common/inc;../../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc;../../../../../../components/phy
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA, TX_ENABLE_FPU_SUPPORT
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1166xxxxx_cm7_sdram_txt.scf
  link misc: ../../../../../../rtos/azure-rtos/binary/netxduo/cortex_m7/mdk/libnetxduo.lib ../../../../../../rtos/azure-rtos/binary/filex/cortex_m7/mdk/libfilex.lib ../../../../../../rtos/azure-rtos/binary/threadx/cortex_m7/mdk/libthreadx.lib --remove
  group azure_iot/azure-sdk-for-c/sdk/inc/azure/core
    ../azure_iot/azure-sdk-for-c/sdk/inc/azure/core/: az_result.h az_http_transport.h az_credentials.h az_span.h az_json.h _az_cfg_suffix.h az_precondition.h az_platform.h _az_cfg_prefix.h az_log.h az_version.h az_config.h az_http.h _az_cfg.h az_context.h
  group azure_iot/azure-sdk-for-c/sdk/inc/azure/core/internal
    ../azure_iot/azure-sdk-for-c/sdk/inc/azure/core/internal/: az_span_internal.h az_result_internal.h az_config_internal.h az_log_internal.h az_precondition_internal.h az_credentials_internal.h az_http_internal.h az_retry_internal.h
  group azure_iot/azure-sdk-for-c/sdk/inc/azure/iot/internal
    ../azure_iot/azure-sdk-for-c/sdk/inc/azure/iot/internal/: az_iot_common_internal.h
  group azure_iot/azure-sdk-for-c/sdk/inc/azure/iot
    ../azure_iot/azure-sdk-for-c/sdk/inc/azure/iot/: az_iot_provisioning_client.h az_iot_common.h az_iot_hub_client.h
  group azure_iot/azure-sdk-for-c/sdk/src/azure/core
    ../azure_iot/azure-sdk-for-c/sdk/src/azure/core/: az_http_header_validation_private.h az_hex_private.h az_json_private.h az_span_private.h az_http_policy_logging_private.h az_http_private.h az_precondition.c az_http_request.c az_http_pipeline.c az_http_policy.c az_context.c az_json_writer.c az_json_token.c az_log.c az_http_policy_retry.c az_span.c az_http_policy_logging.c az_json_reader.c az_http_response.c
  group azure_iot
    ../azure_iot/: nx_azure_iot_hub_client.h nx_azure_iot.h nx_azure_iot_json_writer.h nx_azure_iot_provisioning_client.h nx_azure_iot_json_reader.h nx_azure_iot_json_reader.c nx_azure_iot_provisioning_client.c nx_azure_iot_json_writer.c nx_azure_iot_hub_client.c nx_azure_iot.c
  group azure_iot/azure_iot_security_module/inc
    ../azure_iot/azure_iot_security_module/inc/: asc_version.h asc_port.h
  group azure_iot/azure_iot_security_module/inc/iot_security_module/model/objects
    ../azure_iot/azure_iot_security_module/inc/iot_security_module/model/objects/: object_network_activity_ext.h
  group azure_iot/azure_iot_security_module/inc/iot_security_module
    ../azure_iot/azure_iot_security_module/inc/iot_security_module/: mti.h
  group azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/model/objects
    ../azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/model/objects/: objects.h network_activity.h system_information.h transport_protocol.h
  group azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/model
    ../azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/model/: security_message.h mti.h
  group azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/model/schema
    ../azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/model/schema/: protocol_json_parser.h uuid_json_parser.h heartbeat_builder.h system_information_reader.h system_information_builder.h baseline_builder.h uuid_reader.h heartbeat_json_parser.h listening_ports_builder.h network_activity_json_parser.h message_json_parser.h heartbeat_reader.h system_information_json_parser.h heartbeat_json_printer.h uuid_builder.h flatbuffers_common_reader.h uuid_json_printer.h event_builder.h flatbuffers_common_builder.h protocol_reader.h event_json_parser.h protocol_json_printer.h network_activity_reader.h payload_json_parser.h payload_reader.h event_json_printer.h protocol_builder.h event_reader.h message_builder.h payload_json_printer.h listening_ports_reader.h message_reader.h baseline_reader.h network_activity_builder.h network_activity_json_printer.h system_information_json_printer.h payload_builder.h message_json_printer.h
  group azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/collectors
    ../azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/collectors/: heartbeat.h network_activity.h system_information.h
  group azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core
    ../azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/: collector_collection_internal.h collector_collection.h object_pool_dynamic.h collectors_headers.h core.h collectors_info.h configuration.h object_pool_static.h object_pool.h logger.h asc_result.h collector_collection_factory.h collector.h serializer.h collector_enums.h version.h
  group azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/utils/collection
    ../azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/utils/collection/: collection.h linked_list.h hashset.h stack.h
  group azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/utils
    ../azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/utils/: os_utils.h event_loop_be.h ifile.h string_utils.h containerof.h notifier.h iuuid.h itime.h ievent_loop.h macros.h irand.h async.h notifier_topics.h
  group azure_iot/azure_iot_security_module/iot-security-module-core/src/serializer
    ../azure_iot/azure_iot_security_module/iot-security-module-core/src/serializer/: serializer_private.h protocol_serialize_enum.h serializer_private.c serializer.c heartbeat.c system_information.c network_activity.c
  group azure_iot/azure_iot_security_module/iot-security-module-core/src/serializer/extensions
    ../azure_iot/azure_iot_security_module/iot-security-module-core/src/serializer/extensions/: page_allocator.h custom_builder_allocator.h custom_emitter.c page_allocator.c custom_builder_allocator.c
  group azure_iot/azure_iot_security_module/iot-security-module-core/deps/flatcc/include/flatcc
    ../azure_iot/azure_iot_security_module/iot-security-module-core/deps/flatcc/include/flatcc/: flatcc_rtconfig.h flatcc_accessors.h flatcc_iov.h flatcc_identifier.h flatcc_epilogue.h flatcc_refmap.h flatcc_prologue.h flatcc_assert.h flatcc_types.h flatcc_flatbuffers.h flatcc_emitter.h flatcc_endian.h flatcc_alloc.h flatcc_builder.h
  group azure_iot/azure_iot_security_module/iot-security-module-core/deps/flatcc/include/flatcc/portable
    ../azure_iot/azure_iot_security_module/iot-security-module-core/deps/flatcc/include/flatcc/portable/: pwarnings.h pendian.h pstatic_assert.h pdiagnostic.h pstdalign.h pdiagnostic_push.h pstdint.h pendian_detect.h pdiagnostic_pop.h paligned_alloc.h
  group azure_iot/azure_iot_security_module
    ../azure_iot/azure_iot_security_module/: nx_azure_iot_security_module.h nx_azure_iot_security_module.c
  group azure_iot/azure-sdk-for-c/sdk/src/azure/iot
    ../azure_iot/azure-sdk-for-c/sdk/src/azure/iot/: az_iot_provisioning_client.c az_iot_hub_client_telemetry.c az_iot_provisioning_client_sas.c az_iot_common.c az_iot_hub_client.c az_iot_hub_client_c2d.c az_iot_hub_client_sas.c az_iot_hub_client_methods.c az_iot_hub_client_twin.c
  group azure_iot/azure-sdk-for-c/sdk/src/azure/platform
    ../azure_iot/azure-sdk-for-c/sdk/src/azure/platform/: az_noplatform.c az_nohttp.c
  group azure_iot/azure_iot_security_module/src/model/objects
    ../azure_iot/azure_iot_security_module/src/model/objects/: object_network_activity_ext.c
  group azure_iot/azure_iot_security_module/src/collectors
    ../azure_iot/azure_iot_security_module/src/collectors/: collector_system_information.c collector_network_activity.c
  group azure_iot/azure_iot_security_module/src/utils
    ../azure_iot/azure_iot_security_module/src/utils/: os_utils.c iuuid.c itime.c irand.c
  group azure_iot/azure_iot_security_module/iot-security-module-core/src
    ../azure_iot/azure_iot_security_module/iot-security-module-core/src/: collector_collection_internal.c collector_collection.c collectors_info.c collector_collection_factory.c core.c logger.c
  group azure_iot/azure_iot_security_module/iot-security-module-core/src/model
    ../azure_iot/azure_iot_security_module/iot-security-module-core/src/model/: security_message.c collector.c
  group azure_iot/azure_iot_security_module/iot-security-module-core/src/collectors
    ../azure_iot/azure_iot_security_module/iot-security-module-core/src/collectors/: collector_heartbeat.c
  group azure_iot/azure_iot_security_module/iot-security-module-core/src/utils
    ../azure_iot/azure_iot_security_module/iot-security-module-core/src/utils/: notifier.c event_loop_be.c string_utils.c
  group azure_iot/azure_iot_security_module/iot-security-module-core/deps/flatcc/src/runtime
    ../azure_iot/azure_iot_security_module/iot-security-module-core/deps/flatcc/src/runtime/: builder.c refmap.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group source
    ../: main.c pnp_temperature_controller.c pnp_deviceinfo_component.c pnp_deviceinfo_component.h pnp_thermostat_component.c pnp_thermostat_component.h nx_azure_iot_pnp_helpers.c nx_azure_iot_pnp_helpers.h get_seed.c sample_config.h nx_azure_iot_cert.c nx_azure_iot_cert.h nx_azure_iot_ciphersuites.c nx_azure_iot_ciphersuites.h sample_device_identity.c
  group azure-rtos/config
    ../: tx_user.h nx_user.h fx_user.h
  group ports
    ../: nx_driver_imxrt_irq.c nx_driver_imxrt.c nx_driver_imxrt.h
  group doc
    ../: readme.txt
  group mdio
    ../../../../../../components/phy/mdio/enet/: fsl_enet_mdio.h fsl_enet_mdio.c
    ../../../../../../components/phy/: fsl_mdio.h
  group phy
    ../../../../../../components/phy/device/phyksz8081/: fsl_phyksz8081.h fsl_phyksz8081.c
    ../../../../../../components/phy/device/phyrtl8211f/: fsl_phyrtl8211f.h fsl_phyrtl8211f.c
    ../../../../../../components/phy/: fsl_phy.h
  group drivers
    ../../../../../../devices/MIMXRT1166/drivers/: fsl_caam.c fsl_caam.h fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_clock.h fsl_clock.c fsl_dcdc.h fsl_dcdc.c fsl_gpio.h fsl_gpio.c fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_pmu.h fsl_pmu.c fsl_anatop_ai.h fsl_anatop_ai.c fsl_enet.h fsl_enet.c
    ../../../../../../devices/MIMXRT1166/drivers/cm7/: fsl_cache.c fsl_cache.h
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group device
    ../../../../../../devices/MIMXRT1166/: fsl_device_registers.h MIMXRT1166_cm7.h MIMXRT1166_cm7_features.h system_MIMXRT1166_cm7.c system_MIMXRT1166_cm7.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group startup
    ../../../../../../devices/MIMXRT1166/arm/: startup_MIMXRT1166_cm7.S
  group xip
    ../../../../xip/: evkmimxrt1160_flexspi_nor_config.c evkmimxrt1160_flexspi_nor_config.h
    ../../../../../../devices/MIMXRT1166/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
  group utilities
    ../../../../../../devices/MIMXRT1166/utilities/: fsl_assert.c
    ../../../../../../devices/MIMXRT1166/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1166/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group azure-rtos/netxduo/addons/auto_ip
    ../../../../../../rtos/azure-rtos/netxduo/addons/auto_ip/: nx_auto_ip.c nx_auto_ip.h
  group azure-rtos/netxduo/addons/cloud
    ../../../../../../rtos/azure-rtos/netxduo/addons/cloud/: nx_cloud.c nx_cloud.h
  group azure-rtos/netxduo/addons/dhcp
    ../../../../../../rtos/azure-rtos/netxduo/addons/dhcp/: nxd_dhcpv6_server.c nxd_dhcp_server.h nxd_dhcpv6_server.h nxd_dhcpv6_client.h nxd_dhcpv6_client.c nxd_dhcp_client.c nxd_dhcp_server.c nxd_dhcp_client.h
  group azure-rtos/netxduo/addons/dns
    ../../../../../../rtos/azure-rtos/netxduo/addons/dns/: nxd_dns.c nxd_dns.h
  group azure-rtos/netxduo/addons/ftp
    ../../../../../../rtos/azure-rtos/netxduo/addons/ftp/: nxd_ftp_client.h nxd_ftp_server.h nxd_ftp_client.c nxd_ftp_server.c
  group azure-rtos/netxduo/addons/http
    ../../../../../../rtos/azure-rtos/netxduo/addons/http/: nxd_http_client.c nxd_http_server.h nxd_http_client.h nxd_http_server.c
  group azure-rtos/netxduo/addons/mdns
    ../../../../../../rtos/azure-rtos/netxduo/addons/mdns/: nxd_mdns.h nxd_mdns.c
  group azure-rtos/netxduo/addons/mqtt
    ../../../../../../rtos/azure-rtos/netxduo/addons/mqtt/: nxd_mqtt_client.h nxd_mqtt_client.c
  group azure-rtos/netxduo/addons/nat
    ../../../../../../rtos/azure-rtos/netxduo/addons/nat/: nx_nat.h nx_nat.c
  group azure-rtos/netxduo/addons/pop3
    ../../../../../../rtos/azure-rtos/netxduo/addons/pop3/: nxd_pop3_client.h nxd_pop3_client.c
  group azure-rtos/netxduo/addons/ppp
    ../../../../../../rtos/azure-rtos/netxduo/addons/ppp/: nx_ppp.h nx_ppp.c
  group azure-rtos/netxduo/addons/pppoe
    ../../../../../../rtos/azure-rtos/netxduo/addons/pppoe/: nx_pppoe_server.c nx_pppoe_server.h nx_pppoe_client.c nx_pppoe_client.h
  group azure-rtos/netxduo/addons/smtp
    ../../../../../../rtos/azure-rtos/netxduo/addons/smtp/: nxd_smtp_client.c nxd_smtp_client.h
  group azure-rtos/netxduo/addons/snmp
    ../../../../../../rtos/azure-rtos/netxduo/addons/snmp/: nx_sha1.c nxd_snmp.h nx_des.h nx_sha1.h nx_des.c nxd_snmp.c
  group azure-rtos/netxduo/addons/sntp
    ../../../../../../rtos/azure-rtos/netxduo/addons/sntp/: nxd_sntp_client.h nxd_sntp_client.c
  group azure-rtos/netxduo/addons/telnet
    ../../../../../../rtos/azure-rtos/netxduo/addons/telnet/: nxd_telnet_server.c nxd_telnet_client.c nxd_telnet_server.h nxd_telnet_client.h
  group azure-rtos/netxduo/addons/tftp
    ../../../../../../rtos/azure-rtos/netxduo/addons/tftp/: nxd_tftp_client.c nxd_tftp_server.h nxd_tftp_server.c nxd_tftp_client.h
  group azure-rtos/netxduo/addons/web
    ../../../../../../rtos/azure-rtos/netxduo/addons/web/: nx_tcpserver.c nx_web_http_server.h nx_web_http_server.c nx_tcpserver.h nx_web_http_client.c nx_web_http_common.h nx_web_http_client.h
  group azure-rtos/netxduo/common/inc
    ../../../../../../rtos/azure-rtos/netxduo/common/inc/: nx_igmp.h nx_ipv4.h nx_packet.h nx_nd_cache.h nx_md5.h nx_icmpv6.h nx_icmp.h nx_user_sample.h nx_tcp.h nx_icmpv4.h nx_arp.h nx_ipv6.h nx_system.h nx_api.h nx_rarp.h nx_mld.h nx_ip.h nx_udp.h
  group azure-rtos/netxduo/crypto_libraries/inc
    ../../../../../../rtos/azure-rtos/netxduo/crypto_libraries/inc/: nx_crypto_sha1.h nx_crypto_hmac_md5.h nx_crypto_xcbc_mac.h nx_crypto_hmac.h nx_crypto_ccm.h nx_crypto_dh.h nx_crypto_tls_prf_1.h nx_crypto_const.h nx_crypto_cbc.h nx_crypto_ec.h nx_crypto_md5.h nx_crypto_tls_prf_sha384.h nx_crypto.h nx_crypto_sha5.h nx_crypto_rsa.h nx_crypto_ecdh.h nx_crypto_ecdsa.h nx_crypto_hmac_sha2.h nx_crypto_3des.h nx_crypto_null.h nx_crypto_drbg.h nx_crypto_phash.h nx_crypto_hmac_sha1.h nx_crypto_gcm.h nx_crypto_tls_prf_sha256.h nx_crypto_sha2.h nx_crypto_pkcs1_v1.5.h nx_crypto_tls_prf_sha512.h nx_crypto_huge_number.h nx_crypto_hmac_sha5.h nx_crypto_ecjpake.h nx_crypto_des.h nx_crypto_ctr.h nx_crypto_aes.h nx_crypto_method_self_test.h nx_crypto_hkdf.h
  group azure-rtos/netxduo/nx_secure/inc
    ../../../../../../rtos/azure-rtos/netxduo/nx_secure/inc/: nx_secure_tls_api.h nx_secure_dtls_api.h nx_secure_user_sample.h nx_secure_x509.h nx_secure_dtls.h nx_secure_crypto_table_self_test.h nx_secure_tls.h
  group azure-rtos/netxduo/nx_secure/ports
    ../../../../../../rtos/azure-rtos/netxduo/nx_secure/ports/: nx_secure_port.h
  group azure-rtos/netxduo/ports/cortex_m7/ac6/inc
    ../../../../../../rtos/azure-rtos/netxduo/ports/cortex_m7/ac6/inc/: nx_port.h
  group azure-rtos/filex/common/inc
    ../../../../../../rtos/azure-rtos/filex/common/inc/: fx_media.h fx_unicode.h fx_api.h fx_directory_exFAT.h fx_utility.h fx_file.h fx_system.h fx_directory.h fx_user_sample.h fx_fault_tolerant.h
  group azure-rtos/filex/ports/cortex_m7/ac6/inc
    ../../../../../../rtos/azure-rtos/filex/ports/cortex_m7/ac6/inc/: fx_port.h
  group azure-rtos/threadx/common/inc
    ../../../../../../rtos/azure-rtos/threadx/common/inc/: tx_byte_pool.h tx_event_flags.h tx_timer.h tx_queue.h tx_thread.h tx_mutex.h tx_trace.h tx_initialize.h tx_api.h tx_user_sample.h tx_block_pool.h tx_semaphore.h
  group azure-rtos/threadx/ports/cortex_m7/ac6/inc
    ../../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc/: tx_port.h
  group azure-rtos/threadx/ports/cortex_m7/ac6/src
    ../../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/src/: tx_thread_schedule.S tx_initialize_low_level.S tx_thread_stack_build.S tx_thread_system_return.S tx_timer_interrupt.S tx_thread_interrupt_control.S tx_thread_context_restore.S tx_thread_context_save.S
target pnp_temperature_controller flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1166DVM6A:cm7 NXP
  pack: NXP.MIMXRT1166_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: pnp_temperature_controller.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, __CLANG_ARM, CPU_MIMXRT1166DVM6A_cm7, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, ASC_SERIALIZER_USE_CUSTOM_ALLOCATOR, AZ_NO_PRECONDITION_CHECKING, CRYPTO_USE_DRIVER_CAAM, NX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE
  c misc: as above
  c include: as above
  asm define: as above
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1166xxxxx_cm7_flexspi_nor.scf
  link misc: ../../../../../../rtos/azure-rtos/binary/netxduo/cortex_m7/mdk/libnetxduo.lib ../../../../../../rtos/azure-rtos/binary/filex/cortex_m7/mdk/libfilex.lib ../../../../../../rtos/azure-rtos/binary/threadx/cortex_m7/mdk/libthreadx.lib --remove --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
target pnp_temperature_controller sdram_txt_release (ARM-ADS)
  device: MIMXRT1166DVM6A:cm7 NXP
  pack: NXP.MIMXRT1166_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: pnp_temperature_controller.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_SDRAM, DATA_SECTION_IS_CACHEABLE, NDEBUG, __CLANG_ARM, CPU_MIMXRT1166DVM6A_cm7, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, ASC_SERIALIZER_USE_CUSTOM_ALLOCATOR, AZ_NO_PRECONDITION_CHECKING, CRYPTO_USE_DRIVER_CAAM, NX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA, TX_ENABLE_FPU_SUPPORT
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1166xxxxx_cm7_sdram_txt.scf
  link misc: as above
target pnp_temperature_controller flexspi_nor_release (ARM-ADS)
  device: MIMXRT1166DVM6A:cm7 NXP
  pack: NXP.MIMXRT1166_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: pnp_temperature_controller.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, __CLANG_ARM, CPU_MIMXRT1166DVM6A_cm7, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, ASC_SERIALIZER_USE_CUSTOM_ALLOCATOR, AZ_NO_PRECONDITION_CHECKING, CRYPTO_USE_DRIVER_CAAM, NX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE
  c misc: as above
  c include: as above
  asm define: as above
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1166xxxxx_cm7_flexspi_nor.scf
  link misc: as above
