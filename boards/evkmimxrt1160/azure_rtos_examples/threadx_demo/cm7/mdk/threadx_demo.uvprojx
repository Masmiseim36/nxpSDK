# Keil uVision project threadx_demo.uvprojx, settings and files
target threadx_demo debug (ARM-ADS)
  device: MIMXRT1166DVM6A:cm7 NXP
  pack: NXP.MIMXRT1166_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: threadx_demo.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, __CLANG_ARM, CPU_MIMXRT1166DVM6A_cm7, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK, TX_INCLUDE_USER_DEFINE_FILE, FSL_RTOS_THREADX
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../components/lists;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../devices/MIMXRT1166/drivers;../../../../../../devices/MIMXRT1166;../../../../../../devices/MIMXRT1166/drivers/cm7;../../../../xip;../../../../../../devices/MIMXRT1166/xip;../../../../../../devices/MIMXRT1166/utilities;../../../../../../devices/MIMXRT1166/utilities/str;../../../../../../devices/MIMXRT1166/utilities/debug_console;../../../../../../rtos/azure-rtos/threadx/common/inc;../../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc;../../../../../../CMSIS/Core/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1166xxxxx_cm7_ram.scf
  link misc: ../../../../../../rtos/azure-rtos/binary/threadx/cortex_m7/mdk/libthreadx.lib --remove --entry=Reset_Handler --diag_suppress 6314
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group source
    ../: threadx_demo.c
  group azure-rtos/config
    ../: tx_user.h
  group doc
    ../: readme.md
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group drivers
    ../../../../../../devices/MIMXRT1166/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_dcdc.h fsl_dcdc.c fsl_gpio.h fsl_gpio.c fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_pmu.h fsl_pmu.c fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../devices/MIMXRT1166/drivers/cm7/: fsl_cache.c fsl_cache.h
  group device
    ../../../../../../devices/MIMXRT1166/: fsl_device_registers.h MIMXRT1166_cm7.h MIMXRT1166_cm7_features.h system_MIMXRT1166_cm7.c system_MIMXRT1166_cm7.h
  group startup
    ../../../../../../devices/MIMXRT1166/arm/: startup_MIMXRT1166_cm7.S
  group xip
    ../../../../xip/: evkmimxrt1160_flexspi_nor_config.c evkmimxrt1160_flexspi_nor_config.h
    ../../../../../../devices/MIMXRT1166/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
  group utilities
    ../../../../../../devices/MIMXRT1166/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../../devices/MIMXRT1166/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1166/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group azure-rtos/threadx/common/inc
    ../../../../../../rtos/azure-rtos/threadx/common/inc/: tx_api.h tx_block_pool.h tx_byte_pool.h tx_event_flags.h tx_initialize.h tx_mutex.h tx_queue.h tx_semaphore.h tx_thread.h tx_timer.h tx_trace.h tx_user_sample.h
  group azure-rtos/threadx/ports/common
    ../../../../../../rtos/azure-rtos/threadx/ports/common/: tx_initialize_low_level.c
  group azure-rtos/threadx/ports/cortex_m7/ac6/inc
    ../../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc/: tx_port.h
  group azure-rtos/threadx/ports/cortex_m7/ac6/src
    ../../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/src/: tx_thread_context_restore.S tx_thread_context_save.S tx_thread_interrupt_control.S tx_thread_interrupt_disable.S tx_thread_interrupt_restore.S tx_thread_schedule.S tx_thread_stack_build.S tx_thread_system_return.S tx_timer_interrupt.S
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
target threadx_demo flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1166DVM6A:cm7 NXP
  pack: NXP.MIMXRT1166_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: threadx_demo.out
  AfterMake: fromelf.exe --output "$Lthreadx_demo.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, __CLANG_ARM, CPU_MIMXRT1166DVM6A_cm7, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK, TX_INCLUDE_USER_DEFINE_FILE, FSL_RTOS_THREADX
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1166xxxxx_cm7_flexspi_nor.scf
  link misc: ../../../../../../rtos/azure-rtos/binary/threadx/cortex_m7/mdk/libthreadx.lib --remove --legacyalign --entry=Reset_Handler --diag_suppress 6314 --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
target threadx_demo release (ARM-ADS)
  device: MIMXRT1166DVM6A:cm7 NXP
  pack: NXP.MIMXRT1166_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: threadx_demo.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, __CLANG_ARM, CPU_MIMXRT1166DVM6A_cm7, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK, TX_INCLUDE_USER_DEFINE_FILE, FSL_RTOS_THREADX
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1166xxxxx_cm7_ram.scf
  link misc: as above
target threadx_demo flexspi_nor_release (ARM-ADS)
  device: MIMXRT1166DVM6A:cm7 NXP
  pack: NXP.MIMXRT1166_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: threadx_demo.out
  AfterMake: fromelf.exe --output "$Lthreadx_demo.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, __CLANG_ARM, CPU_MIMXRT1166DVM6A_cm7, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK, TX_INCLUDE_USER_DEFINE_FILE, FSL_RTOS_THREADX
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1166xxxxx_cm7_flexspi_nor.scf
  link misc: as above
