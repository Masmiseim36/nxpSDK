# IAR project power_mode_switch_bm_dcdc_core0.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1166xxx6_M7 NXP MIMXRT1166xxx6_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1166DVM6A_cm7; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../../devices/MIMXRT1166/drivers; ../../../../../../../devices/MIMXRT1166; ../../../../../../../devices/MIMXRT1166/utilities/str; ../../../../../../../devices/MIMXRT1166/utilities/debug_console; ../../../../../../../components/uart; ../../../../../../../components/serial_manager; ../../../../../../../components/lists; ../../../../../../../devices/MIMXRT1166/utilities; ../../../../../../../devices/MIMXRT1166/xip; ../../../../../xip; ../../../../../../../devices/MIMXRT1166/drivers/cm7; ../../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: power_mode_switch_bm_dcdc_core0.out
  ILINK.IlinkKeepSymbols: _power_mode_switch_bm_core1_image
  ILINK.IlinkIcfFile: MIMXRT1166xxxxx_cm7_ram.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CORE1_IMAGE_COPY_TO_RAM; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1166DVM6A_cm7; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1166xxxxx_cm7_flexspi_nor.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1166DVM6A_cm7; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: app.srec
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CORE1_IMAGE_COPY_TO_RAM; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1166DVM6A_cm7; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: app.srec
  ILINK.IlinkIcfFile: MIMXRT1166xxxxx_cm7_flexspi_nor.icf
  group source
    ../: power_mode_switch_core0.c lpm.c lpm.h chip_init_def.h setpoint_table_def.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.md
  group evkmimxrt1160
    ../: evkmimxrt1160_connect_cm4_cm7side.jlinkscript
  group drivers
    ../../../../../../../devices/MIMXRT1166/drivers/: fsl_gpio.h fsl_gpio.c fsl_dcdc.h fsl_dcdc.c fsl_mu.h fsl_mu.c fsl_gpc.h fsl_gpc.c fsl_pgmc.h fsl_pgmc.c fsl_soc_src.h fsl_soc_src.c fsl_pmu.h fsl_pmu.c fsl_ssarc.h fsl_ssarc.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../../devices/MIMXRT1166/drivers/cm7/: fsl_cache.c fsl_cache.h
  group device
    ../../../../../../../devices/MIMXRT1166/: fsl_device_registers.h MIMXRT1166_cm7.h MIMXRT1166_cm7_features.h system_MIMXRT1166_cm7.c system_MIMXRT1166_cm7.h
  group utilities
    ../../../../../../../devices/MIMXRT1166/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MIMXRT1166/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/MIMXRT1166/utilities/: fsl_assert.c fsl_assert.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../../devices/MIMXRT1166/iar/: startup_MIMXRT1166_cm7.s
  group xip
    ../../../../../../../devices/MIMXRT1166/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../../xip/: evkmimxrt1160_flexspi_nor_config.c evkmimxrt1160_flexspi_nor_config.h
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
