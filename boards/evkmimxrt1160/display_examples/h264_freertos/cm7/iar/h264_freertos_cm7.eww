<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>h264_freertos_cm7</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
      <member>
        <project>h264_freertos_cm7</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_debug</name>
      <member>
        <project>h264_freertos_cm7</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_release</name>
      <member>
        <project>h264_freertos_cm7</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/h264_freertos_cm7.ewp</path>
  </project>
</workspace>
