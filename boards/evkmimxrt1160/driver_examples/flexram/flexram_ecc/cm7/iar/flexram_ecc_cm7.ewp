# IAR project flexram_ecc_cm7.ewp, settings and files
configuration flexspi_nor_sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1166xxx6_M7 NXP MIMXRT1166xxx6_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1166DVM6A_cm7; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../../devices/MIMXRT1166/utilities/debug_console_lite; ../../../../../../../devices/MIMXRT1166/drivers; ../../../../../../../devices/MIMXRT1166; ../../../../../../../CMSIS/Include; ../../../../../../../components/uart; ../../../../../../../components/lists; ../../../../../../../devices/MIMXRT1166/xip; ../../../../../xip; ../../../../../../../devices/MIMXRT1166/drivers/cm7
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: flexram_ecc_cm7.out
  ILINK.IlinkIcfFile: MIMXRT1166xxxxx_cm7_flexspi_nor_sdram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration sdram_txt_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_SDRAM; DEBUG; CPU_MIMXRT1166DVM6A_cm7; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1
  ILINK.IlinkIcfFile: evkmimxrt1160_flexram_ram_allocate.icf
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1166DVM6A_cm7; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration sdram_txt_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_SDRAM; NDEBUG; CPU_MIMXRT1166DVM6A_cm7; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: evkmimxrt1160_flexram_ram_allocate.icf
  group source
    ../: flexram_ecc.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../../../devices/MIMXRT1166/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../../devices/MIMXRT1166/drivers/: fsl_flexram.c fsl_flexram.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../../devices/MIMXRT1166/drivers/cm7/: fsl_cache.c fsl_cache.h
  group device
    ../../../../../../../devices/MIMXRT1166/: fsl_device_registers.h MIMXRT1166_cm7.h MIMXRT1166_cm7_features.h system_MIMXRT1166_cm7.c system_MIMXRT1166_cm7.h
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../../devices/MIMXRT1166/iar/: startup_MIMXRT1166_cm7.s
  group xip
    ../../../../../../../devices/MIMXRT1166/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../../xip/: evkmimxrt1160_flexspi_nor_config.c evkmimxrt1160_flexspi_nor_config.h
