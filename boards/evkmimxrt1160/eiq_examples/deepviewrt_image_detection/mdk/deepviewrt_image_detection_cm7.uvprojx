# Keil uVision project deepviewrt_image_detection_cm7.uvprojx, settings and files
target deepviewrt_image_detection_cm7 flexspi_nor_sdram_debug (ARM-ADS)
  device: MIMXRT1166DVM6A:cm7 NXP
  pack: NXP.MIMXRT1166_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: deepviewrt_image_detection_cm7.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=0, XIP_BOOT_HEADER_XMCD_ENABLE=1, USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, DEBUG, CPU_MIMXRT1166DVM6A_cm7, _POSIX_C_SOURCE=200809L, ARM_MATH_CM7, __FPU_PRESENT=1, PRINTF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SDK_I2C_BASED_COMPONENT_USED=1, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, MCUXPRESSO_SDK, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../source;..;../../../../../middleware/eiq/deepviewrt/include;../../../../../components/lists;../../../../../components/uart;../../../../../components/serial_manager;../../../../../devices/MIMXRT1166/drivers;../../../../../devices/MIMXRT1166;../../../../../devices/MIMXRT1166/xip;../../../xip;../../../../../devices/MIMXRT1166/utilities;../../../../../devices/MIMXRT1166/utilities/str;../../../../../devices/MIMXRT1166/utilities/debug_console;../../../xmcd;../../../../../CMSIS/Core/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../source
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1166xxxxx_cm7_flexspi_nor_sdram.scf
  link misc: ../../../../../middleware/eiq/deepviewrt/lib/deepview-rt-mdk.lib --remove --predefine="-D__stack_size__=0x10000" --predefine="-D__heap_size__=0x1000000" --diag-warning=6242 --entry=Reset_Handler --diag_suppress 6314 --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-DXIP_BOOT_HEADER_DCD_ENABLE=0" --predefine="-DXIP_BOOT_HEADER_XMCD_ENABLE=1"
  group source
    ../: main.c model.S
  group source/data
    ../source/data/: horse.jpg
  group source/models
    ../source/models/: mobilenet_ssd_v1_1.00_trimmed_quant_anchors.rtm mobilenet_ssd_v2_lite_quant_anchors.rtm
  group board
    ../: pin_mux.h pin_mux.c cr_section_macros.h board_init.h board_init.c dcd.c dcd.h board.h board.c clock_config.h clock_config.c
    ./: retarget.c
    ../../../xmcd/: xmcd.c xmcd.h
  group eiq/deepviewrt/include
    ../../../../../middleware/eiq/deepviewrt/include/: deepview_ops.h deepview_rpc.h deepview_rt.h mathrt.h stb_image.h stb_image_resize.h stb_image_write.h
  group eiq/deepviewrt
    ../../../../../middleware/eiq/deepviewrt/: readme.txt
  group eiq/deepviewrt/lib
    ../../../../../middleware/eiq/deepviewrt/lib/: LICENSE.txt
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group drivers
    ../../../../../devices/MIMXRT1166/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_dcdc.h fsl_dcdc.c fsl_pmu.h fsl_pmu.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_gpio.h fsl_gpio.c fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_anatop_ai.h fsl_anatop_ai.c
  group device
    ../../../../../devices/MIMXRT1166/: fsl_device_registers.h MIMXRT1166_cm7.h MIMXRT1166_cm7_features.h system_MIMXRT1166_cm7.c system_MIMXRT1166_cm7.h
  group startup
    ../../../../../devices/MIMXRT1166/arm/: startup_MIMXRT1166_cm7.S
  group xip
    ../../../../../devices/MIMXRT1166/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1160_flexspi_nor_config.c evkmimxrt1160_flexspi_nor_config.h
  group utilities
    ../../../../../devices/MIMXRT1166/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../devices/MIMXRT1166/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1166/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
  group doc
    ../: readme.md
target deepviewrt_image_detection_cm7 flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1166DVM6A:cm7 NXP
  pack: NXP.MIMXRT1166_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: deepviewrt_image_detection_cm7.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=0, XIP_BOOT_HEADER_XMCD_ENABLE=1, USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, CPU_MIMXRT1166DVM6A_cm7, _POSIX_C_SOURCE=200809L, ARM_MATH_CM7, __FPU_PRESENT=1, PRINTF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SDK_I2C_BASED_COMPONENT_USED=1, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, MCUXPRESSO_SDK, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../source
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1166xxxxx_cm7_flexspi_nor_sdram.scf
  link misc: as above
