# IAR project erpc_two_way_rpc_rpmsg_rtos_cm7.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1166xxx6_M7 NXP MIMXRT1166xxx6_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CORE1_IMAGE_COPY_TO_RAM; CPU_MIMXRT1166DVM6A_cm7; __USE_SHMEM; MULTICORE_APP=1; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.CCIncludePath2: ..; ../../../erpc_common; ../../../erpc_common/erpc_two_way_rpc/service; ../..; ../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imxrt1160; ../../../../../../middleware/multicore/rpmsg_lite/lib/include; ../../../../../../middleware/multicore/rpmsg_lite/lib/include/environment/freertos; ../../../../../../devices/MIMXRT1166/drivers; ../../../../../../middleware/multicore/erpc/erpc_c/infra; ../../../../../../middleware/multicore/erpc/erpc_c/setup; ../../../../../../middleware/multicore/erpc/erpc_c/port; ../../../../../../middleware/multicore/erpc/erpc_c/transports; ../../../../../../middleware/multicore/mcmgr/src; ../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F; ../../../../../../devices/MIMXRT1166; ../../../../../../devices/MIMXRT1166/utilities/str; ../../../../../../devices/MIMXRT1166/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1166/xip; ../../../../xip; ../../../../../../devices/MIMXRT1166/drivers/cm7; ../../../../../../CMSIS/Core/Include; ../../../../../../middleware/multicore/erpc/erpc_c
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: erpc_two_way_rpc_rpmsg_rtos_cm7.out
  ILINK.IlinkKeepSymbols: _erpc_two_way_rpc_rpmsg_rtos_cm4_image
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __use_shmem__=1
  ILINK.IlinkIcfFile: MIMXRT1166xxxxx_cm7_flexspi_nor.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CORE1_IMAGE_COPY_TO_RAM; CPU_MIMXRT1166DVM6A_cm7; __USE_SHMEM; MULTICORE_APP=1; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: app.srec
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h dcd.c dcd.h
  group source
    ../../../erpc_common/: erpc_error_handler.h erpc_error_handler.cpp
    ../: main_core0.c FreeRTOSConfig.h
    ../../: rpmsg_config.h erpc_config.h
  group erpc/service
    ../../../erpc_common/erpc_two_way_rpc/service/: erpc_two_way_rpc.erpc erpc_two_way_rpc_Core0Interface.h erpc_two_way_rpc_Core0Interface_client.cpp erpc_two_way_rpc_Core1Interface.h erpc_two_way_rpc_Core1Interface_server.h erpc_two_way_rpc_Core1Interface_server.cpp
  group erpc/infra
    ../../../../../../middleware/multicore/erpc/erpc_c/infra/: erpc_arbitrated_client_manager.hpp erpc_arbitrated_client_manager.cpp erpc_client_manager.h erpc_client_manager.cpp erpc_simple_server.hpp erpc_simple_server.cpp erpc_server.hpp erpc_server.cpp erpc_transport_arbitrator.hpp erpc_transport_arbitrator.cpp erpc_version.h erpc_codec.hpp erpc_basic_codec.hpp erpc_transport.hpp erpc_message_buffer.hpp erpc_message_loggers.hpp erpc_common.h erpc_manually_constructed.hpp erpc_crc16.hpp erpc_basic_codec.cpp erpc_message_buffer.cpp erpc_message_loggers.cpp erpc_crc16.cpp erpc_client_server_common.hpp erpc_pre_post_action.h erpc_pre_post_action.cpp
  group erpc/setup
    ../../../../../../middleware/multicore/erpc/erpc_c/setup/: erpc_arbitrated_client_setup.h erpc_arbitrated_client_setup.cpp erpc_server_setup.h erpc_server_setup.cpp erpc_setup_rpmsg_lite_rtos_master.cpp erpc_setup_mbf_rpmsg.cpp erpc_transport_setup.h erpc_mbf_setup.h
  group erpc/port
    ../../../../../../middleware/multicore/erpc/erpc_c/port/: erpc_threading.h erpc_threading_freertos.cpp erpc_port.h erpc_port_freertos.cpp erpc_config_internal.h erpc_threading.h erpc_threading_freertos.cpp erpc_setup_extensions.h erpc_setup_extensions_freertos.cpp erpc_setup_extensions.h erpc_endianness_agnostic_example.h erpc_endianness_undefined.h
  group erpc/transports
    ../../../../../../middleware/multicore/erpc/erpc_c/transports/: erpc_rpmsg_lite_base_transport.hpp erpc_rpmsg_lite_rtos_transport.hpp erpc_rpmsg_lite_rtos_transport.cpp
  group doc
    ../: readme.txt
  group evkmimxrt1160
    ../: evkmimxrt1160_connect_cm4_cm7side.jlinkscript
  group mcmgr
    ../../../../../../middleware/multicore/mcmgr/src/: mcmgr_internal_core_api_imxrt1160.c mcmgr_mu_internal.c mcmgr.h mcmgr_internal_core_api.h mcmgr.c
  group rpmsg_lite/include
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_lite.h rpmsg_ns.h llist.h rpmsg_default_config.h virtio_ring.h virtqueue.h rpmsg_compiler.h rpmsg_env.h rpmsg_queue.h
  group rpmsg_lite/include/platform/imxrt1160
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imxrt1160/: rpmsg_platform.h
  group rpmsg_lite/include/environment/freertos
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/environment/freertos/: rpmsg_env_specific.h
  group rpmsg_lite/rpmsg_lite
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c rpmsg_queue.c
  group rpmsg_lite/rpmsg_lite/porting/platform/imxrt1160
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/platform/imxrt1160/: rpmsg_platform.c
  group rpmsg_lite/rpmsg_lite/porting/environment
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_freertos.c
  group rpmsg_lite/common
    ../../../../../../middleware/multicore/rpmsg_lite/lib/common/: llist.c
  group rpmsg_lite/virtio
    ../../../../../../middleware/multicore/rpmsg_lite/lib/virtio/: virtqueue.c
  group drivers
    ../../../../../../devices/MIMXRT1166/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_mu.h fsl_mu.c fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../devices/MIMXRT1166/drivers/cm7/: fsl_cache.c fsl_cache.h
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/IAR/ARM_CM4F
    ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group device
    ../../../../../../devices/MIMXRT1166/: fsl_device_registers.h MIMXRT1166_cm7.h MIMXRT1166_cm7_features.h system_MIMXRT1166_cm7.c system_MIMXRT1166_cm7.h
  group utilities
    ../../../../../../devices/MIMXRT1166/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1166/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1166/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMXRT1166/iar/: startup_MIMXRT1166_cm7.s
  group xip
    ../../../../../../devices/MIMXRT1166/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1160_flexspi_nor_config.c evkmimxrt1160_flexspi_nor_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
