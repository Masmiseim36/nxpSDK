# Keil uVision project erpc_two_way_rpc_rpmsg_rtos_cm7.uvprojx, settings and files
target erpc_two_way_rpc_rpmsg_rtos_cm7 flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1166DVM6A:cm7 NXP
  pack: NXP.MIMXRT1166_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: erpc_two_way_rpc_rpmsg_rtos_cm7.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CORE1_IMAGE_COPY_TO_RAM, CPU_MIMXRT1166DVM6A_cm7, __USE_SHMEM, MULTICORE_APP=1, SDK_OS_FREE_RTOS, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../erpc_common;../../../erpc_common/erpc_two_way_rpc/service;../..;../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imxrt1160;../../../../../../middleware/multicore/rpmsg_lite/lib/include;../../../../../../middleware/multicore/rpmsg_lite/lib/include/environment/freertos;../../../../../../devices/MIMXRT1166/drivers;../../../../../../middleware/multicore/erpc/erpc_c/infra;../../../../../../middleware/multicore/erpc/erpc_c/setup;../../../../../../middleware/multicore/erpc/erpc_c/port;../../../../../../middleware/multicore/erpc/erpc_c/transports;../../../../../../middleware/multicore/mcmgr/src;../../../../../../rtos/freertos/freertos_kernel/include;../../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM4F;../../../../../../devices/MIMXRT1166;../../../../../../devices/MIMXRT1166/utilities/str;../../../../../../devices/MIMXRT1166/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../devices/MIMXRT1166/xip;../../../../xip;../../../../../../devices/MIMXRT1166/drivers/cm7;../../../../../../CMSIS/Core/Include;../../../../../../middleware/multicore/erpc/erpc_c
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../../cm4/mdk/debug;..
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1166xxxxx_cm7_flexspi_nor.scf
  link misc: --remove --keep=*(*core1_code) --muldefweak --entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-D__stack_size__=0x400" --predefine="-D__use_shmem__=1"
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h dcd.c dcd.h
  group source
    ../../../erpc_common/: erpc_error_handler.h erpc_error_handler.cpp
    ../: main_core0.c FreeRTOSConfig.h
    ../../: rpmsg_config.h erpc_config.h
  group erpc/service
    ../../../erpc_common/erpc_two_way_rpc/service/: erpc_two_way_rpc.erpc erpc_two_way_rpc_Core0Interface.h erpc_two_way_rpc_Core0Interface_client.cpp erpc_two_way_rpc_Core1Interface.h erpc_two_way_rpc_Core1Interface_server.h erpc_two_way_rpc_Core1Interface_server.cpp
  group doc
    ../: readme.txt
  group evkmimxrt1160
    ../: evkmimxrt1160_connect_cm4_cm7side.jlinkscript
  group mcmgr
    ../../../../../../middleware/multicore/mcmgr/src/: mcmgr_internal_core_api_imxrt1160.c mcmgr_mu_internal.c mcmgr.h mcmgr_internal_core_api.h mcmgr.c
  group rpmsg_lite/include/platform/imxrt1160
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imxrt1160/: rpmsg_platform.h
  group rpmsg_lite/rpmsg_lite/porting/platform/imxrt1160
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/platform/imxrt1160/: rpmsg_platform.c
  group rpmsg_lite/include
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_lite.h rpmsg_ns.h llist.h rpmsg_default_config.h virtio_ring.h virtqueue.h rpmsg_compiler.h rpmsg_env.h rpmsg_queue.h
  group rpmsg_lite/common
    ../../../../../../middleware/multicore/rpmsg_lite/lib/common/: llist.c
  group rpmsg_lite/rpmsg_lite
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c rpmsg_queue.c
  group rpmsg_lite/virtio
    ../../../../../../middleware/multicore/rpmsg_lite/lib/virtio/: virtqueue.c
  group rpmsg_lite/rpmsg_lite/porting/environment
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_freertos.c
  group rpmsg_lite/include/environment/freertos
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/environment/freertos/: rpmsg_env_specific.h
  group drivers
    ../../../../../../devices/MIMXRT1166/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_mu.h fsl_mu.c fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../devices/MIMXRT1166/drivers/cm7/: fsl_cache.c fsl_cache.h
  group erpc/infra
    ../../../../../../middleware/multicore/erpc/erpc_c/infra/: erpc_arbitrated_client_manager.h erpc_arbitrated_client_manager.cpp erpc_client_manager.h erpc_client_manager.cpp erpc_simple_server.h erpc_simple_server.cpp erpc_server.h erpc_server.cpp erpc_transport_arbitrator.h erpc_transport_arbitrator.cpp erpc_version.h erpc_codec.h erpc_basic_codec.h erpc_transport.h erpc_message_buffer.h erpc_message_loggers.h erpc_common.h erpc_manually_constructed.h erpc_crc16.h erpc_basic_codec.cpp erpc_message_buffer.cpp erpc_message_loggers.cpp erpc_crc16.cpp erpc_client_server_common.h erpc_pre_post_action.h erpc_pre_post_action.cpp
  group erpc/setup
    ../../../../../../middleware/multicore/erpc/erpc_c/setup/: erpc_arbitrated_client_setup.h erpc_arbitrated_client_setup.cpp erpc_server_setup.h erpc_server_setup.cpp erpc_setup_rpmsg_lite_rtos_master.cpp erpc_setup_mbf_rpmsg.cpp erpc_transport_setup.h erpc_mbf_setup.h
  group erpc/port
    ../../../../../../middleware/multicore/erpc/erpc_c/port/: erpc_threading.h erpc_threading_freertos.cpp erpc_port.h erpc_port_freertos.cpp erpc_config_internal.h erpc_threading.h erpc_threading_freertos.cpp erpc_setup_extensions.h erpc_setup_extensions_freertos.cpp erpc_setup_extensions.h
  group erpc/transports
    ../../../../../../middleware/multicore/erpc/erpc_c/transports/: erpc_rpmsg_lite_base_transport.h erpc_rpmsg_lite_rtos_transport.h erpc_rpmsg_lite_rtos_transport.cpp
  group freertos/freertos_kernel
    ../../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    ../../../../../../rtos/freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos_kernel/portable/GCC/ARM_CM4F
    ../../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos_kernel/portable
    ../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group utilities
    ../../../../../../devices/MIMXRT1166/utilities/incbin/: fsl_incbin.S
    ../../../../../../devices/MIMXRT1166/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1166/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1166/utilities/: fsl_assert.c
  group device
    ../../../../../../devices/MIMXRT1166/: fsl_device_registers.h MIMXRT1166_cm7.h MIMXRT1166_cm7_features.h system_MIMXRT1166_cm7.c system_MIMXRT1166_cm7.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMXRT1166/arm/: startup_MIMXRT1166_cm7.S
  group xip
    ../../../../../../devices/MIMXRT1166/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1160_flexspi_nor_config.c evkmimxrt1160_flexspi_nor_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
target erpc_two_way_rpc_rpmsg_rtos_cm7 flexspi_nor_release (ARM-ADS)
  device: MIMXRT1166DVM6A:cm7 NXP
  pack: NXP.MIMXRT1166_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: erpc_two_way_rpc_rpmsg_rtos_cm7.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CORE1_IMAGE_COPY_TO_RAM, CPU_MIMXRT1166DVM6A_cm7, __USE_SHMEM, MULTICORE_APP=1, SDK_OS_FREE_RTOS, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../../cm4/mdk/release;..
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1166xxxxx_cm7_flexspi_nor.scf
  link misc: as above
