# IAR project ota_mcuboot_basic_cm7.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1166xxx6_M7 NXP MIMXRT1166xxx6_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SHELL_PRINT_COPYRIGHT=0; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; DATA_SECTION_IS_CACHEABLE=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1166DVM6A_cm7; MIMXRT1166_cm7_SERIES; SERIAL_PORT_TYPE_UART=1; MFLASH_FILE_BASEADDR=14221312
  ICCARM.IExtraOptions: --diag_suppress=Pe257  --diag_suppress=Pa082,Pa050 --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../xip; ../../../../../../devices/MIMXRT1166/xip; ../../../../../../devices/MIMXRT1166/drivers; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT1166; ../../../../../../devices/MIMXRT1166/periph; ../../../../../../devices/MIMXRT1166/drivers/cm7; ../../../../../../devices/MIMXRT1166/utilities/debug_console; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1166/utilities/str; ../../../../../../devices/MIMXRT1166/utilities/shell; ../../../../../../components/serial_manager; ../../../../../../components/uart; ../../../../../../components/flash/mflash; ../../../../../../components/flash/mflash/mimxrt1160; ../../../../../../middleware/mcuboot_opensource/ext/tinycrypt/lib/include; ../../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/app_support; ../../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/include; ../../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/include/mcuboot_config; ../../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT1166DVM6A_cm7; MIMXRT1166_cm7_SERIES
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ota_mcuboot_basic.bin
  ILINK.IlinkOutputFile: ota_mcuboot_basic_cm7.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x400
  ILINK.IlinkIcfFile: MIMXRT1166xxxxx_cm7_flexspi_nor_mcuboot.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SHELL_PRINT_COPYRIGHT=0; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; DATA_SECTION_IS_CACHEABLE=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1166DVM6A_cm7; MIMXRT1166_cm7_SERIES; SERIAL_PORT_TYPE_UART=1; MFLASH_FILE_BASEADDR=14221312
  ICCARM.CCOptLevel: 3
  group source
    ../: ota_mcuboot_basic.c xmodem.c xmodem.h platform_bindings.c platform_bindings.h flash_partitioning.h flash_partitioning.c sblconfig.h fsl_debug_console_conf.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group xip
    ../../../../xip/: evkmimxrt1160_flexspi_nor_config.c evkmimxrt1160_flexspi_nor_config.h
    ../../../../: dcd.c dcd.h xmcd.c xmcd.h
    ../../../../../../devices/MIMXRT1166/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group drivers
    ../../../../../../devices/MIMXRT1166/drivers/: fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_anatop_ai.c fsl_anatop_ai.h fsl_memory.h fsl_dcdc.c fsl_dcdc.h fsl_gpc.c fsl_gpc.h fsl_pgmc.h fsl_pgmc.c fsl_pmu.h fsl_pmu.c fsl_soc_src.c fsl_soc_src.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_flexspi.c fsl_flexspi.h fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_mu.h fsl_mu.c
    ../../../../../../devices/MIMXRT1166/drivers/cm7/: fsl_cache.c fsl_cache.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv7m_cachel1.h armv7m_mpu.h
  group device
    ../../../../../../devices/MIMXRT1166/: fsl_device_registers.h MIMXRT1166_cm7.h MIMXRT1166_cm7_COMMON.h MIMXRT1166_cm7_features.h system_MIMXRT1166_cm7.c system_MIMXRT1166_cm7.h
  group device/periph
    ../../../../../../devices/MIMXRT1166/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_ANADIG_LDO_SNVS.h PERI_ANADIG_LDO_SNVS_DIG.h PERI_ANADIG_MISC.h PERI_ANADIG_OSC.h PERI_ANADIG_PLL.h PERI_ANADIG_PMU.h PERI_ANADIG_TEMPSENSOR.h PERI_AOI.h PERI_ASRC.h PERI_AUDIO_PLL.h PERI_CAAM.h PERI_CAN.h PERI_CAN_WRAPPER.h PERI_CCM.h PERI_CCM_OBS.h PERI_CDOG.h PERI_CMP.h PERI_CSI.h PERI_DAC.h PERI_DCDC.h PERI_DCIC.h PERI_DMA.h PERI_DMAMUX.h PERI_DSI_HOST.h PERI_DSI_HOST_APB_PKT_IF.h PERI_DSI_HOST_DPI_INTFC.h PERI_DSI_HOST_NXP_FDSOI28_DPHY_INTFC.h PERI_EMVSIM.h PERI_ENC.h PERI_ENET.h PERI_ETHERNET_PLL.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC_CPU_MODE_CTRL.h PERI_GPC_SET_POINT_CTRL.h PERI_GPC_STBY_CTRL.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IEE.h PERI_IEE_APC.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_LPSR.h PERI_IOMUXC_LPSR_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_IPS_DOMAIN.h PERI_KEY_MANAGER.h PERI_KPP.h PERI_LCDIF.h PERI_LCDIFV2.h PERI_LMEM.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_MCM.h PERI_MECC.h PERI_MIPI_CSI2RX.h PERI_MMCAU.h PERI_MU.h PERI_OCOTP.h PERI_OSC_RC_400M.h PERI_OTFAD.h PERI_PDM.h PERI_PGMC_BPC.h PERI_PGMC_CPC.h PERI_PGMC_MIF.h PERI_PGMC_PPC.h PERI_PHY_LDO.h PERI_PIT.h PERI_PUF.h PERI_PWM.h PERI_PXP.h PERI_RDC.h PERI_RDC_SEMAPHORE.h PERI_RTWDOG.h PERI_SEMA4.h PERI_SEMC.h PERI_SNVS.h PERI_SPDIF.h PERI_SRAM.h PERI_SRC.h PERI_SSARC_HP.h PERI_SSARC_LP.h PERI_TMPSNS.h PERI_TMR.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_VIDEO_MUX.h PERI_VIDEO_PLL.h PERI_VMBANDGAP.h PERI_WDOG.h PERI_XBARA.h PERI_XBARB.h PERI_XECC.h PERI_XRDC2.h
  group startup/iar
    ../../../../../../devices/MIMXRT1166/iar/: startup_MIMXRT1166_cm7.s
  group utilities
    ../../../../../../devices/MIMXRT1166/utilities/debug_console/: fsl_assert.h fsl_assert.c
    ../../../../../../devices/MIMXRT1166/utilities/shell/: fsl_shell.h fsl_shell.c
  group utilities/str
    ../../../../../../devices/MIMXRT1166/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console
    ../../../../../../devices/MIMXRT1166/utilities/debug_console/: fsl_debug_console.h fsl_debug_console.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group flash/mflash
    ../../../../../../components/flash/mflash/: mflash_common.h mflash_file.c mflash_file.h
  group flash/mflash/mimxrt1160
    ../../../../../../components/flash/mflash/mimxrt1160/: mflash_drv.c mflash_drv.h
  group tinycrypt/include/tinycrypt
    ../../../../../../middleware/mcuboot_opensource/ext/tinycrypt/lib/include/tinycrypt/: aes.h cbc_mode.h ccm_mode.h cmac_mode.h constants.h ctr_mode.h ctr_prng.h ecc.h ecc_dsa.h hmac.h hmac_prng.h sha256.h utils.h ecc_platform_specific.h
  group tinycrypt/source
    ../../../../../../middleware/mcuboot_opensource/ext/tinycrypt/lib/source/: aes_decrypt.c aes_encrypt.c cbc_mode.c ccm_mode.c cmac_mode.c ctr_mode.c ctr_prng.c ecc.c ecc_dsa.c hmac.c hmac_prng.c sha256.c utils.c
  group bootutil/app_support/app_support
    ../../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/app_support/: mcuboot_app_support.c mcuboot_app_support.h
  group bootutil/app_support/include
    ../../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/include/: flash_map.h
  group bootutil/app_support/include/mcuboot_config
    ../../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/include/mcuboot_config/: mcuboot_config.h
  group bootutil/app_support/include/sysflash
    ../../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/include/sysflash/: sysflash.h
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
