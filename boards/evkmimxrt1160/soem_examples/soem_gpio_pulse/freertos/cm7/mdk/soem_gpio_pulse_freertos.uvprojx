# Keil uVision project soem_gpio_pulse_freertos.uvprojx, settings and files
target soem_gpio_pulse_freertos debug (ARM-ADS)
  device: MIMXRT1166DVM6A:cm7 NXP
  pack: NXP.MIMXRT1166_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: soem_gpio_pulse_freertos.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT1166DVM6A_cm7, SDK_DEBUGCONSOLE_UART, SERIAL_PORT_TYPE_UART=1, PRINTF_ADVANCED_ENABLE=1, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, BOARD_NETWORK_USE_100M_ENET_PORT=1, MCUXPRESSO_SDK, SDK_OS_FREE_RTOS
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ../../../../../../../middleware/soem/osal/freertos;..;../../../../../../../devices/MIMXRT1166/drivers;../../../../../../../components/phy/device/phyksz8081;../../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F;../../../../../../../middleware/soem/oshw/mcux-sdk;../../../../../../../middleware/soem/oshw/mcux-sdk/enet;../../../../../../../middleware/soem/soem;../../../../../../../middleware/soem/osal;../../../../../../../devices/MIMXRT1166;../../../../../../../devices/MIMXRT1166/utilities/debug_console;../../../../../../../components/uart;../../../../../../../components/serial_manager;../../../../../../../components/lists;../../../../../../../devices/MIMXRT1166/utilities;../../../../../../../devices/MIMXRT1166/xip;../../../../../xip;../../../../../../../devices/MIMXRT1166/drivers/cm7;../../../../../../../components/phy;../../../../../../../CMSIS/Core/Include;../../../../../../../devices/MIMXRT1166/utilities/str
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../../../../../../rtos/freertos/freertos-kernel/include
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1166xxxxx_cm7_ram.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314 --predefine="-D__stack_size__=0x1000" --predefine="-D__heap_size__=0x1000"
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group source
    ../: soem_gpio_pulse.c FreeRTOSConfig.h
  group doc
    ../: readme.md
  group evkmimxrt1160
    ../: evkmimxrt1160_connect_cm4_cm7side.jlinkscript
  group drivers
    ../../../../../../../devices/MIMXRT1166/drivers/: fsl_enet.h fsl_enet.c fsl_gpt.c fsl_gpt.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_memory.h fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../../devices/MIMXRT1166/drivers/cm7/: fsl_cache.c fsl_cache.h
  group component/phy
    ../../../../../../../components/phy/device/phyksz8081/: fsl_phyksz8081.h fsl_phyksz8081.c
    ../../../../../../../components/phy/: fsl_phy.h
  group freertos/freertos-kernel
    ../../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable/GCC/ARM_CM4F
    ../../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url
  group freertos/freertos-kernel/portable
    ../../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group soem/oshw/mcux-sdk
    ../../../../../../../middleware/soem/oshw/mcux-sdk/: nicdrv.c nicdrv.h oshw.c oshw.h soem_port.c soem_port.h
  group soem/oshw/mcux-sdk/enet
    ../../../../../../../middleware/soem/oshw/mcux-sdk/enet/: soem_enet.h enet.c enet.h
  group soem/soem
    ../../../../../../../middleware/soem/soem/: ethercat.h ethercatbase.c ethercatbase.h ethercatcoe.c ethercatcoe.h ethercatconfig.c ethercatconfig.h ethercatconfiglist.h ethercatdc.c ethercatdc.h ethercateoe.c ethercateoe.h ethercatfoe.c ethercatfoe.h ethercatmain.c ethercatmain.h ethercatprint.c ethercatprint.h ethercatsoe.c ethercatsoe.h ethercattype.h
  group soem/osal
    ../../../../../../../middleware/soem/osal/: osal.h
  group soem/osal/freertos
    ../../../../../../../middleware/soem/osal/freertos/: osal.c osal_defs.h
  group device
    ../../../../../../../devices/MIMXRT1166/: fsl_device_registers.h MIMXRT1166_cm7.h MIMXRT1166_cm7_features.h system_MIMXRT1166_cm7.c system_MIMXRT1166_cm7.h
  group utilities
    ../../../../../../../devices/MIMXRT1166/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/MIMXRT1166/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../../../devices/MIMXRT1166/utilities/str/: fsl_str.c fsl_str.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../../devices/MIMXRT1166/arm/: startup_MIMXRT1166_cm7.S
  group xip
    ../../../../../../../devices/MIMXRT1166/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../../xip/: evkmimxrt1160_flexspi_nor_config.c evkmimxrt1160_flexspi_nor_config.h
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
target soem_gpio_pulse_freertos flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1166DVM6A:cm7 NXP
  pack: NXP.MIMXRT1166_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: soem_gpio_pulse_freertos.out
  AfterMake: fromelf.exe --output "$Lsoem_gpio_pulse_bm.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1166DVM6A_cm7, SDK_DEBUGCONSOLE_UART, SERIAL_PORT_TYPE_UART=1, PRINTF_ADVANCED_ENABLE=1, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, BOARD_NETWORK_USE_100M_ENET_PORT=1, MCUXPRESSO_SDK, SDK_OS_FREE_RTOS
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1166xxxxx_cm7_flexspi_nor.scf
  link misc: as above
target soem_gpio_pulse_freertos release (ARM-ADS)
  device: MIMXRT1166DVM6A:cm7 NXP
  pack: NXP.MIMXRT1166_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: soem_gpio_pulse_freertos.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1166DVM6A_cm7, SDK_DEBUGCONSOLE_UART, SERIAL_PORT_TYPE_UART=1, PRINTF_ADVANCED_ENABLE=1, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, BOARD_NETWORK_USE_100M_ENET_PORT=1, MCUXPRESSO_SDK, SDK_OS_FREE_RTOS
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1166xxxxx_cm7_ram.scf
  link misc: as above
target soem_gpio_pulse_freertos flexspi_nor_release (ARM-ADS)
  device: MIMXRT1166DVM6A:cm7 NXP
  pack: NXP.MIMXRT1166_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: soem_gpio_pulse_freertos.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1166DVM6A_cm7, SDK_DEBUGCONSOLE_UART, SERIAL_PORT_TYPE_UART=1, PRINTF_ADVANCED_ENABLE=1, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, BOARD_NETWORK_USE_100M_ENET_PORT=1, MCUXPRESSO_SDK, SDK_OS_FREE_RTOS
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1166xxxxx_cm7_flexspi_nor.scf
  link misc: as above
