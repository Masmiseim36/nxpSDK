# Keil uVision project tensorflow_lite_adt_cm7.uvprojx, settings and files
target tensorflow_lite_adt_cm7 flexspi_nor_sdram_debug (ARM-ADS)
  device: MIMXRT1166DVM6A:cm7 NXP
  pack: NXP.MIMXRT1166_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: tensorflow_lite_adt_cm7.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, DEBUG, __CLK_TCK=1000000, CPU_MIMXRT1166DVM6A_cm7, SDK_DEBUGCONSOLE_UART, FLATBUFFERS_LITTLEENDIAN, GEMMLOWP_MCU, TFLITE_MCU, ARM_MATH_CM7, __FPU_PRESENT=1, SDK_I2C_BASED_COMPONENT_USED=1, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1
  c misc: -Wno-missing-field-initializers  -Wno-self-assign  -Wno-unreachable-code  -fno-exceptions  -Wno-armcc-pragma-import  -Wno-bad-function-cast  -Wno-c++98-compat-pedantic  -Wno-c11-extensions  -Wno-c99-extensions  -Wno-cast-qual  -Wno-conversion  -Wno-covered-switch-default  -Wno-dollar-in-identifier-extension  -Wno-double-promotion  -Wno-exit-time-destructors  -Wno-extern-c-compat  -Wno-extra-semi-stmt  -Wno-float-equal  -Wno-gnu-folding-constant  -Wno-inconsistent-missing-destructor-override  -Wno-missing-noreturn  -Wno-missing-prototypes  -Wno-missing-variable-declarations  -Wno-nested-anon-types  -Wno-old-style-cast  -Wno-padded  -Wno-shadow-uncaptured-local  -Wno-shadow  -Wno-sign-compare  -Wno-sign-conversion  -Wno-switch-enum  -Wno-undef  -Wno-unknown-warning-option  -Wno-unreachable-code-break  -Wno-unreachable-code-return  -Wno-unused-parameter  -Wno-unused-variable  -Wno-weak-vtables  -Wno-zero-as-null-pointer-constant  -Wno-typedef-redefinition  -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../../middleware/eiq/tensorflow-lite/examples/adt;../../../../../middleware/issdk/drivers/systick;../../../../../middleware/issdk/drivers/gpio/i.mx;../../../../../middleware/issdk/drivers/gpio;../../../../../middleware/issdk/sensors;../../../../../devices/MIMXRT1166/drivers;../../../../../devices/MIMXRT1166/cmsis_drivers;../../../../../CMSIS/Include;../../../../../CMSIS/Driver/Include;../../../../../devices/MIMXRT1166/utilities/debug_console_lite;../../../../../middleware/eiq/tensorflow-lite;../../../../../middleware/eiq/tensorflow-lite/third_party;../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include;../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp;../../../../../components/lists;../../../../../components/uart;../../../../../devices/MIMXRT1166;../../../../../devices/MIMXRT1166/xip;../../../../evkmimxrt1160/xip
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: ../../../../../devices/MIMXRT1166/arm/MIMXRT1166xxxxx_cm7_flexspi_nor_sdram.scf
  link misc: ../../../../../middleware/eiq/tensorflow-lite/lib/cm7/mdk/tensorflow-lite.lib --remove --predefine="-D__stack_size__=0x10000" --predefine="-D__heap_size__=0x800000" --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group board
    ../: frdm_stbc_agm01_shield.h issdk_hal.h RTE_Device.h evkmimxrt1160.c evkmimxrt1160.h pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
    ./: retarget.c
  group source
    ../../../../../middleware/eiq/tensorflow-lite/examples/adt/: adt.cpp adt_model.h parameters.h get_sensor_data.c get_sensor_data.h
  group doc
    ../../../../../middleware/eiq/tensorflow-lite/examples/adt/adt_train/: adt_model.tflite adt_train.py input_data.txt keras_model.h5 requirements.txt validation_data.txt
    ../: readme.txt
  group utilities
    ../../../../../middleware/issdk/drivers/systick/: systick_utils.c systick_utils.h systick_utils.c systick_utils.h
    ../../../../../devices/MIMXRT1166/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group gpio_driver
    ../../../../../middleware/issdk/drivers/gpio/i.mx/: gpio_driver.c gpio_driver.h
    ../../../../../middleware/issdk/drivers/gpio/: Driver_GPIO.h
  group interfaces
    ../../../../../middleware/issdk/sensors/: register_io_i2c.c register_io_spi.c sensor_io_spi.c sensor_io_i2c.c register_io_i2c.h register_io_spi.h sensor_io_spi.h sensor_io_i2c.h sensor_drv.h
  group sensors
    ../../../../../middleware/issdk/sensors/: fxas21002.h fxas21002_drv.h fxas21002_drv.c fxos8700.h fxos8700_drv.h fxos8700_drv.c
  group drivers
    ../../../../../devices/MIMXRT1166/drivers/: fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.h fsl_lpspi_edma.c fsl_lpuart.h fsl_lpuart.c fsl_lpuart_edma.h fsl_lpuart_edma.c fsl_gpc.h fsl_gpc.c fsl_common.h fsl_common.c fsl_dcdc.h fsl_dcdc.c fsl_pmu.h fsl_pmu.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../devices/MIMXRT1166/cmsis_drivers/: fsl_lpi2c_cmsis.h fsl_lpi2c_cmsis.c fsl_lpspi_cmsis.h fsl_lpspi_cmsis.c fsl_lpuart_cmsis.h fsl_lpuart_cmsis.c
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group CMSIS_driver
    ../../../../../CMSIS/Driver/Include/: Driver_Common.h Driver_SPI.h Driver_USART.h Driver_I2C.h
  group eiq/tensorflow-lite/tensorflow/core/public
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/core/public/: version.h session.h
  group eiq/tensorflow-lite/tensorflow/core/util
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/core/util/: stat_summarizer_options.h stats_calculator.h
  group eiq/tensorflow-lite/tensorflow/lite
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/: graph_info.h configuration.h stderr_reporter.h op_resolver.h interpreter.h simple_memory_arena.h allocation.h context.h string_type.h mutable_op_resolver.h string_util.h interpreter_builder.h builtin_op_data.h minimal_logging.h memory_planner.h arena_planner.h tflite_with_xnnpack_optional.h model.h optional_debug_tools.h version.h builtin_ops.h type_to_tflitetype.h error_reporter.h external_cpu_backend_context.h model_builder.h util.h context_util.h
  group eiq/tensorflow-lite/tensorflow/lite/c
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/c/: common.h c_api_internal.h c_api.h builtin_op_data.h
  group eiq/tensorflow-lite/tensorflow/lite/core
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/: subgraph.h macros.h
  group eiq/tensorflow-lite/tensorflow/lite/core/api
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/api/: op_resolver.h tensor_utils.h profiler.h flatbuffer_conversions.h error_reporter.h
  group eiq/tensorflow-lite/tensorflow/lite/experimental/resource
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/experimental/resource/: resource_variable.h resource_base.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/: fully_connected.h lstm_shared.h custom_ops_register.h op_macros.h cpu_backend_gemm_eigen.h kernel_util.h eigen_support.h dequantize.h cpu_backend_threadpool.h register.h cpu_backend_context.h register_ref.h cpu_backend_gemm_gemmlowp.h cpu_backend_gemm_params.h cpu_backend_gemm.h padding.h cpu_backend_gemm_ruy.h builtin_op_kernels.h cpu_backend_gemm_custom_gemv.h lstm_eval.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops/: fully_connected.h pooling.h depthwise_conv.h dequantize.h l2normalization.h add.h tanh.h log_softmax.h conv.h mul.h mean.h transpose_conv.h logistic.h
  group eiq/tensorflow-lite/tensorflow/lite/profiling
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/profiling/: buffered_profiler.h time.h profile_summarizer.h platform_profiler.h memory_info.h profiler.h profile_buffer.h noop_profiler.h profile_summary_formatter.h
  group eiq/tensorflow-lite/tensorflow/lite/schema
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/schema/: schema_generated.h
  group eiq/tensorflow-lite/tensorflow/lite/tools
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/tools/: logging.h command_line_flags.h tool_params.h
  group eiq/tensorflow-lite/tensorflow/lite/tools/benchmark
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/tools/benchmark/: benchmark_params.h benchmark_tflite_model.h benchmark_model.h benchmark_utils.h profiling_listener.h
  group eiq/tensorflow-lite/tensorflow/lite/tools/delegates
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/tools/delegates/: delegate_provider.h
  group eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/: reflection.h registry.h reflection_generated.h idl.h code_generators.h stl_emulation.h base.h flexbuffers.h util.h minireflect.h hash.h flatbuffers.h
  group eiq/tensorflow-lite/third_party/absl/base
    ../../../../../middleware/eiq/tensorflow-lite/third_party/absl/base/: attributes.h
  group eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint/: fixedpoint_sse.h fixedpoint_msa.h fixedpoint_neon.h fixedpoint.h
  group eiq/tensorflow-lite/third_party/gemmlowp/internal
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/internal/: pack_sse.h dispatch_gemm_shape.h pack_msa.h simd_wrappers.h common.h kernel_msa.h pack_neon.h platform.h block_params.h single_thread_gemm.h simd_wrappers_msa.h allocator.h unpack.h output_sse.h kernel_default.h simd_wrappers_common_neon_sse.h kernel_dsp.h output_msa.h kernel.h simd_wrappers_sse.h pack.h output.h compute.h simd_wrappers_neon.h kernel_sse.h multi_thread_gemm.h kernel_reference.h detect_platform.h output_neon.h kernel_neon.h
  group eiq/tensorflow-lite/third_party/gemmlowp/meta
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/meta/: quantized_mul_kernels_arm_32.h streams.h legacy_multi_thread_gemm.h legacy_multi_thread_common.h legacy_multi_thread_gemv.h transform_kernels_arm_32.h streams_arm_32.h single_thread_transform.h multi_thread_common.h streams_arm_64.h transform_kernels.h multi_thread_transform.h single_thread_gemm.h legacy_single_thread_gemm.h transform_kernels_arm_64.h base.h legacy_operations_common.h quantized_mul_kernels.h multi_thread_gemm.h quantized_mul_kernels_arm_64.h
  group eiq/tensorflow-lite/third_party/gemmlowp/profiling
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/profiling/: pthread_everywhere.h profiler.h instrumentation.h
  group eiq/tensorflow-lite/third_party/gemmlowp/public
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/public/: bit_depth.h gemmlowp.h config.h map.h output_stages.h
  group eiq/tensorflow-lite/third_party/ruy
    ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/: cpu_cache_params.h tune.h ruy.h dispatch.h mul_params.h time.h common.h size_util.h context.h trmul.h platform.h ctx.h pack_x86.h path.h prepacked_cache.h side_pair.h kernel_x86.h system_aligned_alloc.h allocator.h have_built_path_for.h mat.h ctx_impl.h blocking_counter.h pack_common.h kernel.h pack.h apply_multiplier.h opt_set.h thread_pool.h cpuinfo.h kernel_arm.h trmul_params.h matrix.h block_map.h pack_arm.h check_macros.h kernel_common.h context_get_ctx.h
  group eiq/tensorflow-lite/third_party/ruy/profiler
    ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/profiler/: profiler.h instrumentation.h treeview.h
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group device
    ../../../../../devices/MIMXRT1166/: fsl_device_registers.h MIMXRT1166_cm7.h MIMXRT1166_cm7_features.h system_MIMXRT1166_cm7.c system_MIMXRT1166_cm7.h
  group startup
    ../../../../../devices/MIMXRT1166/arm/: startup_MIMXRT1166_cm7.S
  group xip
    ../../../../../devices/MIMXRT1166/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../evkmimxrt1160/xip/: evkmimxrt1160_flexspi_nor_config.c evkmimxrt1160_flexspi_nor_config.h
target tensorflow_lite_adt_cm7 flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1166DVM6A:cm7 NXP
  pack: NXP.MIMXRT1166_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: tensorflow_lite_adt_cm7.out
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, __CLK_TCK=1000000, CPU_MIMXRT1166DVM6A_cm7, SDK_DEBUGCONSOLE_UART, FLATBUFFERS_LITTLEENDIAN, GEMMLOWP_MCU, TFLITE_MCU, ARM_MATH_CM7, __FPU_PRESENT=1, SDK_I2C_BASED_COMPONENT_USED=1, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: as above
  link misc: as above
