# IAR project maestro_usb_mic.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1176DVMAA_cm7; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; SD_ENABLED; DISABLEFLOAT16; DEBUG_CONSOLE_RX_ENABLE=0; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; CASCFG_PLATFORM_FREERTOS; FSL_OS_SELECTED=SDK_OS_FREERTOS; FSL_OSA_TASK_ENABLE=1; STREAMER_ENABLE_FILESRC; STREAMER_ENABLE_FILE_SINK; STREAMER_ENABLE_MEM_SRC; STREAMER_ENABLE_MEM_SINK; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa050,Pa082,Pe186,Pe815
  ICCARM.IExtraOptions: --align_sp_on_irq  --macro_positions_in_diagnostics  --header_context  --no_unaligned_access
  ICCARM.CCIncludePath2: ..; ../..; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../components/codec/wm8960; ../../../../../../components/codec; ../../../../../../components/codec/port/wm8960; ../../../../../../components/codec/port; ../../../../../../components/codec/i2c; ../../../../../../components/i2c; ../../../../../../middleware/sdmmc/sd; ../../../../../../middleware/sdmmc/common; ../../../../../../middleware/sdmmc/host/usdhc; ../../../../../../devices/MIMXRT1176/drivers/cm7; ../../../../../../CMSIS/DSP/Include; ../../../../../../CMSIS/DSP/PrivateInclude; ../../../../../../CMSIS/DSP/Source/DistanceFunctions; ../../../../../../middleware/usb/device; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/phy; ../../../../../../components/osa; ../../../../../../middleware/maestro/config; ../../../../../../middleware/maestro/inc; ../../../../../../devices/MIMXRT1176/utilities; ../../../../../../middleware/fatfs/source; ../../../../../../middleware/fatfs/source/fsl_sd_disk; ../../../../../../devices/MIMXRT1176; ../../../../../../devices/MIMXRT1176/utilities/str; ../../../../../../devices/MIMXRT1176/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1176/xip; ../../../../xip; ../../../../../../components/silicon_id; ../../../../../../CMSIS/Core/Include; ../../../../../../middleware/sdmmc/osa; ../../../../../../rtos/freertos/freertos_kernel/include; ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F; ../../../../../../middleware/maestro/streamer/cci/include; ../../../../../../middleware/maestro/streamer/core; ../../../../../../middleware/maestro/streamer/decoders/cci_dec; ../../../../../../middleware/maestro/streamer/devices; ../../../../../../middleware/maestro/streamer/elements; ../../../../../../middleware/maestro/streamer/encoders/opus; ../../../../../../middleware/maestro/streamer/encoders/cei; ../../../../../../middleware/maestro/streamer/pipelines
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: maestro_usb_mic.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x2500
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../middleware/maestro/libs/cm7f/iar/release/libmp3.a; ../../../../../../middleware/maestro/libs/cm7f/iar/release/libwav.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; SD_ENABLED; DISABLEFLOAT16; DEBUG_CONSOLE_RX_ENABLE=0; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; CASCFG_PLATFORM_FREERTOS; FSL_OS_SELECTED=SDK_OS_FREERTOS; FSL_OSA_TASK_ENABLE=1; STREAMER_ENABLE_FILESRC; STREAMER_ENABLE_FILE_SINK; STREAMER_ENABLE_MEM_SRC; STREAMER_ENABLE_MEM_SINK; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: streamer_pcm.c streamer_pcm_app.h usb_device_config.h app_streamer.c app_streamer.h cmd.c cmd.h main.c main.h usb_device_descriptor.h usb_device_descriptor.c audio_microphone.h audio_microphone.c ffconf.h FreeRTOSConfig.h app_definitions.h
  group board
    ../../: pin_mux.c pin_mux.h
    ../: board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.txt
  group evkmimxrt1170
    ../: evkmimxrt1170_connect_cm4_cm7side.jlinkscript
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_lpi2c.c fsl_lpi2c.h fsl_sai.h fsl_sai.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_sai_edma.h fsl_sai_edma.c fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_anatop_ai.h fsl_anatop_ai.c fsl_memory.h fsl_usdhc.c fsl_usdhc.h
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group codec
    ../../../../../../components/codec/wm8960/: fsl_wm8960.h fsl_wm8960.c
    ../../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
  group codec/port
    ../../../../../../components/codec/port/: fsl_codec_adapter.h
  group codec/port/wm8960
    ../../../../../../components/codec/port/wm8960/: fsl_codec_wm8960_adapter.c fsl_codec_wm8960_adapter.h
  group component/i2c
    ../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/silicon_id
    ../../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group sdmmc/src
    ../../../../../../middleware/sdmmc/sd/: fsl_sd.c
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../../middleware/sdmmc/sd/: fsl_sd.h
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sd
    ../../../../../../middleware/sdmmc/sd/: ChangeLogKSDK.txt
  group sdmmc/host
    ../../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt
    ../../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group sdmmc/osa
    ../../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
  group CMSIS/DSP/Include
    ../../../../../../CMSIS/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h arm_common_tables_f16.h arm_const_structs_f16.h arm_helium_utils.h arm_math_f16.h arm_math_memory.h arm_math_types.h arm_math_types_f16.h arm_mve_tables.h arm_mve_tables_f16.h arm_vec_math.h arm_vec_math_f16.h
  group CMSIS/DSP/Include/dsp
    ../../../../../../CMSIS/DSP/Include/dsp/: basic_math_functions.h basic_math_functions_f16.h bayes_functions.h bayes_functions_f16.h complex_math_functions.h complex_math_functions_f16.h controller_functions.h controller_functions_f16.h distance_functions.h distance_functions_f16.h fast_math_functions.h fast_math_functions_f16.h filtering_functions.h filtering_functions_f16.h interpolation_functions.h interpolation_functions_f16.h matrix_functions.h matrix_functions_f16.h none.h quaternion_math_functions.h statistics_functions.h statistics_functions_f16.h support_functions.h support_functions_f16.h svm_defines.h svm_functions.h svm_functions_f16.h transform_functions.h transform_functions_f16.h utils.h
  group CMSIS/DSP/PrivateInclude
    ../../../../../../CMSIS/DSP/PrivateInclude/: arm_sorting.h arm_vec_fft.h arm_vec_filtering.h
  group CMSIS/DSP/Source/BasicMathFunctions
    ../../../../../../CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
  group CMSIS/DSP/Source/BayesFunctions
    ../../../../../../CMSIS/DSP/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
  group CMSIS/DSP/Source/CommonTables
    ../../../../../../CMSIS/DSP/Source/CommonTables/: CommonTables.c CommonTablesF16.c
  group CMSIS/DSP/Source/ComplexMathFunctions
    ../../../../../../CMSIS/DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
  group CMSIS/DSP/Source/ControllerFunctions
    ../../../../../../CMSIS/DSP/Source/ControllerFunctions/: ControllerFunctions.c
  group CMSIS/DSP/Source/DistanceFunctions
    ../../../../../../CMSIS/DSP/Source/DistanceFunctions/: DistanceFunctions.c arm_boolean_distance_template.h DistanceFunctionsF16.c
  group CMSIS/DSP/Source/FastMathFunctions
    ../../../../../../CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
  group CMSIS/DSP/Source/FilteringFunctions
    ../../../../../../CMSIS/DSP/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
  group CMSIS/DSP/Source/InterpolationFunctions
    ../../../../../../CMSIS/DSP/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
  group CMSIS/DSP/Source/MatrixFunctions
    ../../../../../../CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
  group CMSIS/DSP/Source/QuaternionMathFunctions
    ../../../../../../CMSIS/DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
  group CMSIS/DSP/Source/SVMFunctions
    ../../../../../../CMSIS/DSP/Source/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
  group CMSIS/DSP/Source/StatisticsFunctions
    ../../../../../../CMSIS/DSP/Source/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
  group CMSIS/DSP/Source/SupportFunctions
    ../../../../../../CMSIS/DSP/Source/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
  group CMSIS/DSP/Source/TransformFunctions
    ../../../../../../CMSIS/DSP/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
  group usb/device/source
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h usb_device_dci.h
    ../: usb_device_ch9.c usb_device_ch9.h
  group usb/device/source/ehci
    ../../../../../../middleware/usb/device/: usb_device_ehci.c usb_device_ehci.h
  group usb/device/include
    ../../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/audio
    ../: usb_device_audio.c usb_device_audio.h
  group usb/phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group freertos/freertos_kernel
    ../../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/include
    ../../../../../../rtos/freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group maestro/inc
    ../../../../../../middleware/maestro/inc/: error.h file_utils.h general_utils.h logging.h ringbuffer.h streamer_api.h streamer_element_properties.h streamer_message.h streamer_pcm.h
  group maestro/config
    ../../../../../../middleware/maestro/config/: audio_cfg.h
  group maestro/streamer/cci/include
    ../../../../../../middleware/maestro/streamer/cci/include/: cci_metadata.h codec_interface.h codec_interface_public_api.h errordefs.h
  group maestro/streamer/cci/metadata/src/mp3
    ../../../../../../middleware/maestro/streamer/cci/metadata/src/mp3/: mp3_extractmetadata.c mp3_id3v2.c mp3_vbr.c mp3_id3v2.h mp3_id3v2_internal.h mp3_metadata.h
  group maestro/streamer/cci/metadata/src/adpcm
    ../../../../../../middleware/maestro/streamer/cci/metadata/src/adpcm/: adpcm_extractmetadata.c
  group maestro/streamer/cci/metadata/src/opus
    ../../../../../../middleware/maestro/streamer/cci/metadata/src/opus/: opus_extractmetadata.c
  group maestro/streamer/core
    ../../../../../../middleware/maestro/streamer/core/: pad.h pipeline.h streamer.h streamer_element.h pad.c pipeline.c streamer.c streamer_element.c streamer_msg.c
  group maestro/streamer/decoders/cci_dec
    ../../../../../../middleware/maestro/streamer/decoders/cci_dec/: ccidec.h ccidec.c codec_interface.c codecextractmetadata.c
  group maestro/streamer/devices
    ../../../../../../middleware/maestro/streamer/devices/: audio_sink_pcmrtos.h audio_src_pcmrtos.h freertos_pcm.h audio_sink_pcmrtos.c audio_src_pcmrtos.c
  group maestro/streamer/elements
    ../../../../../../middleware/maestro/streamer/elements/: audio_sink.h audio_src.h decoder.h decoder_pads.h eap.h encoder.h file_sink.h file_src_freertos.h mem_sink.h mem_src.h netbuf_src.h vit_sink.h audio_sink.c audio_src.c decoder.c decoder_pads.c eap.c file_sink.c file_src_freertos.c mem_sink.c vit_sink.c mem_src.c netbuf_src.c encoder.c
  group maestro/streamer/pipelines
    ../../../../../../middleware/maestro/streamer/pipelines/: streamer_audiosrc.h streamer_fs.h streamer_mic2file.h streamer_opusmem2mem.h streamer_pcm_eap_speaker.h streamer_testeapfile2file.h streamer_vit.h streamer_audiosrc.c streamer_fs.c streamer_mic2file.c streamer_opusmem2mem.c streamer_pcm_eap_speaker.c streamer_testeapfile2file.c streamer_vit.c
  group maestro/streamer/encoders/cei
    ../../../../../../middleware/maestro/streamer/encoders/cei/: cei.h cei_enctypes.h cei_table.h
  group maestro/streamer/encoders/opus
    ../../../../../../middleware/maestro/streamer/encoders/opus/: opusenc_cei.h opusenc_cei.c
  group maestro/streamer/parsers/cci
    ../../../../../../middleware/maestro/streamer/parsers/cci/: cci_codec_type_conversion.c
  group maestro/streamer/utils
    ../../../../../../middleware/maestro/streamer/utils/: file_utils.c general_utils.c logging.c ringbuffer.c
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/: fsl_shell.c fsl_shell.h fsl_assert.c
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1176/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group fatfs/source
    ../../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_sd_disk
    ../../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group startup
    ../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group xip
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
