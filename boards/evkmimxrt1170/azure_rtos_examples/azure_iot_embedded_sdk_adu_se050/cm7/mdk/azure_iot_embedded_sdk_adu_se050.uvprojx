# Keil uVision project azure_iot_embedded_sdk_adu_se050.uvprojx, settings and files
target azure_iot_embedded_sdk_adu_se050 flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: azure_iot_embedded_sdk_adu_se050.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, __CLANG_ARM, CPU_MIMXRT1176DVMAA_cm7, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, USE_THREADX_RTOS, DEBUG_CONSOLE_ENABLE_ECHO=1, DEBUG_CONSOLE_SCANF_MAX_LOG_LEN=120, SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC, IMX_RT, NXD_MQTT_OVER_WEBSOCKET, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK, AZ_NO_PRECONDITION_CHECKING, CRYPTO_USE_DRIVER_CAAM, CACHE_MODE_WRITE_THROUGH=1, MFLASH_FILE_BASEADDR=14221312, T1oI2C, T1oI2C_UM11225, SSS_USE_FTR_FILE, NO_SECURE_CHANNEL_SUPPORT, NX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE, FSL_RTOS_THREADX
  c misc: -Wno-tautological-pointer-compare  -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../se050;../mcuboot;../azure_iot/azure-sdk-for-c/sdk/inc;../azure_iot;../azure_iot/azure_iot_security_module;../azure_iot/azure_iot_security_module/inc;../azure_iot/azure_iot_security_module/inc/configs/RTOS_BASE;../azure_iot/azure_iot_security_module/iot-security-module-core/inc;../azure_iot/azure_iot_security_module/iot-security-module-core/deps/flatcc/src/runtime;../azure_iot/azure_iot_security_module/iot-security-module-core/deps/flatcc/include;../../../../../../devices/MIMXRT1176/drivers;../../../../../../components/phy/device/phyksz8081;../../../../../../components/phy/device/phyrtl8211f;../../../../../../devices/MIMXRT1176/drivers/cm7;../../../../../../components/flash/mflash/mimxrt1170;../../../../../../middleware/se_hostlib/sss/port/ksdk;../../../../../../middleware/se_hostlib/hostlib/hostLib/inc;../../../../../../middleware/se_hostlib/hostlib/hostLib/se05x/src;../../../../../../middleware/se_hostlib/sss/inc;../../../../../../middleware/se_hostlib;../../../../../../middleware/se_hostlib/platform;../../../../../../components/lists;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../devices/MIMXRT1176;../../../../../../devices/MIMXRT1176/utilities/str;../../../../../../devices/MIMXRT1176/utilities/debug_console;../../../../../../rtos/azure-rtos/netxduo/addons/auto_ip;../../../../../../rtos/azure-rtos/netxduo/addons/cloud;../../../../../../rtos/azure-rtos/netxduo/addons/BSD;../../../../../../rtos/azure-rtos/netxduo/addons/dhcp;../../../../../../rtos/azure-rtos/netxduo/addons/dns;../../../../../../rtos/azure-rtos/netxduo/addons/ftp;../../../../../../rtos/azure-rtos/netxduo/addons/http;../../../../../../rtos/azure-rtos/netxduo/addons/lwm2m;../../../../../../rtos/azure-rtos/netxduo/addons/mdns;../../../../../../rtos/azure-rtos/netxduo/addons/mqtt;../../../../../../rtos/azure-rtos/netxduo/addons/nat;../../../../../../rtos/azure-rtos/netxduo/addons/pop3;../../../../../../rtos/azure-rtos/netxduo/addons/ppp;../../../../../../rtos/azure-rtos/netxduo/addons/pppoe;../../../../../../rtos/azure-rtos/netxduo/addons/ptp;../../../../../../rtos/azure-rtos/netxduo/addons/smtp;../../../../../../rtos/azure-rtos/netxduo/addons/snmp;../../../../../../rtos/azure-rtos/netxduo/addons/sntp;../../../../../../rtos/azure-rtos/netxduo/addons/telnet;../../../../../../rtos/azure-rtos/netxduo/addons/tftp;../../../../../../rtos/azure-rtos/netxduo/addons/web;../../../../../../rtos/azure-rtos/netxduo/addons/websocket;../../../../../../rtos/azure-rtos/netxduo/common/inc;../../../../../../rtos/azure-rtos/netxduo/crypto_libraries/inc;../../../../../../rtos/azure-rtos/netxduo/nx_secure/inc;../../../../../../rtos/azure-rtos/netxduo/nx_secure/ports;../../../../../../rtos/azure-rtos/netxduo/ports/cortex_m7/ac6/inc;../../../../../../rtos/azure-rtos/filex/common/inc;../../../../../../rtos/azure-rtos/filex/ports/generic/inc;../../../../../../rtos/azure-rtos/threadx/common/inc;../../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc;../../../../../../components/phy;../../../../../../components/flash/mflash;../../../../../../middleware/se_hostlib/hostlib/hostLib/platform/inc;../../../../../../middleware/se_hostlib/hostlib/hostLib/platform/ksdk;../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom;../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/T1oI2C;../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/infra;../../../../../../middleware/se_hostlib/sss/ex/inc;../../../../../../middleware/se_hostlib/sss/ex/src;../../../../../../middleware/se_hostlib/hostlib/hostLib/se05x_03_xx_xx;../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/log;../../../../../../CMSIS/Core/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor.scf
  link misc: ../../../../../../rtos/azure-rtos/binary/netxduo/cortex_m7/mdk/libnetxduo.lib ../../../../../../rtos/azure-rtos/binary/filex/cortex_m7/mdk/libfilex.lib ../../../../../../rtos/azure-rtos/binary/threadx/cortex_m7/mdk/libthreadx.lib --remove --legacyalign --entry=Reset_Handler --diag_suppress 6314 --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group board
    ../: pin_mux.c pin_mux.h se_board_config.h se_board_config.c board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group source
    ../: main.c azure_iot_embedded_sdk_pnp.c azure_iot_embedded_sdk_adu_se050.c sample_azure_iot_embedded_sdk_connect.c sample_config.h get_seed.c nx_azure_iot_cert.c nx_azure_iot_cert.h nx_azure_iot_ciphersuites.c nx_azure_iot_ciphersuites.h
  group azure-rtos/config
    ../: tx_user.h nx_user.h fx_user.h
  group ports
    ../: nx_azure_iot_adu_agent_mflash_driver.c
  group source/se050
    ../se050/: se_api.c se_api.h fsl_sss_ftr.h nx_crypto_ecdsa_se.c nx_crypto_ecdsa_se.h se05x_get_certificate.c se05x_ecdsa_sign.c se05x_ecdsa_verify.c se_memory_pool_threadx.c
  group scripts
    ../scripts/: sign_image.py gen_manifest.py
  group keys
    ../keys/: sign-rsa2048-pub.pem sign-rsa2048-priv.pem
  group mcuboot
    ../mcuboot/: mcuboot_app_support.c mcuboot_app_support.h flash_map.h sbldef.h mcuboot_config.h sblconfig.h flash_partitioning.c flash_partitioning.h
  group mcuboot/sysflash
    ../mcuboot/sysflash/: sysflash.h
  group azure_iot/azure-sdk-for-c/sdk/inc/azure
    ../azure_iot/azure-sdk-for-c/sdk/inc/azure/: az_core.h az_iot.h
  group azure_iot/azure-sdk-for-c/sdk/inc/azure/core
    ../azure_iot/azure-sdk-for-c/sdk/inc/azure/core/: _az_cfg.h _az_cfg_prefix.h _az_cfg_suffix.h az_base64.h az_config.h az_context.h az_credentials.h az_http.h az_http_transport.h az_json.h az_log.h az_platform.h az_precondition.h az_result.h az_span.h az_version.h
  group azure_iot/azure-sdk-for-c/sdk/inc/azure/core/internal
    ../azure_iot/azure-sdk-for-c/sdk/inc/azure/core/internal/: az_config_internal.h az_credentials_internal.h az_http_internal.h az_log_internal.h az_precondition_internal.h az_result_internal.h az_retry_internal.h az_span_internal.h
  group azure_iot/azure-sdk-for-c/sdk/inc/azure/iot
    ../azure_iot/azure-sdk-for-c/sdk/inc/azure/iot/: az_iot_common.h az_iot_hub_client.h az_iot_hub_client_properties.h az_iot_provisioning_client.h
  group azure_iot/azure-sdk-for-c/sdk/inc/azure/iot/internal
    ../azure_iot/azure-sdk-for-c/sdk/inc/azure/iot/internal/: az_iot_common_internal.h
  group azure_iot/azure-sdk-for-c/sdk/src/azure/core
    ../azure_iot/azure-sdk-for-c/sdk/src/azure/core/: az_base64.c az_context.c az_hex_private.h az_http_header_validation_private.h az_http_pipeline.c az_http_policy.c az_http_policy_logging.c az_http_policy_logging_private.h az_http_policy_retry.c az_http_private.h az_http_request.c az_http_response.c az_json_private.h az_json_reader.c az_json_token.c az_json_writer.c az_log.c az_precondition.c az_span.c az_span_private.h
  group azure_iot/azure-sdk-for-c/sdk/src/azure/iot
    ../azure_iot/azure-sdk-for-c/sdk/src/azure/iot/: az_iot_common.c az_iot_hub_client.c az_iot_hub_client_c2d.c az_iot_hub_client_commands.c az_iot_hub_client_methods.c az_iot_hub_client_properties.c az_iot_hub_client_sas.c az_iot_hub_client_telemetry.c az_iot_hub_client_twin.c az_iot_provisioning_client.c az_iot_provisioning_client_sas.c
  group azure_iot/azure-sdk-for-c/sdk/src/azure/platform
    ../azure_iot/azure-sdk-for-c/sdk/src/azure/platform/: az_nohttp.c az_noplatform.c
  group azure_iot/azure_iot_security_module/inc/configs/RTOS_BASE
    ../azure_iot/azure_iot_security_module/inc/configs/RTOS_BASE/: asc_config.h
  group azure_iot/azure_iot_security_module/inc/iot_security_module/model/objects
    ../azure_iot/azure_iot_security_module/inc/iot_security_module/model/objects/: object_network_activity_ext.h
  group azure_iot/azure_iot_security_module/inc/iot_security_module
    ../azure_iot/azure_iot_security_module/inc/iot_security_module/: mti.h
  group azure_iot/azure_iot_security_module/iot-security-module-core/deps/flatcc/include/flatcc
    ../azure_iot/azure_iot_security_module/iot-security-module-core/deps/flatcc/include/flatcc/: flatcc_accessors.h flatcc_alloc.h flatcc_assert.h flatcc_builder.h flatcc_emitter.h flatcc_endian.h flatcc_epilogue.h flatcc_flatbuffers.h flatcc_identifier.h flatcc_iov.h flatcc_prologue.h flatcc_refmap.h flatcc_rtconfig.h flatcc_types.h
  group azure_iot/azure_iot_security_module/iot-security-module-core/deps/flatcc/include/flatcc/portable
    ../azure_iot/azure_iot_security_module/iot-security-module-core/deps/flatcc/include/flatcc/portable/: paligned_alloc.h pdiagnostic.h pdiagnostic_pop.h pdiagnostic_push.h pendian.h pendian_detect.h pstatic_assert.h pstdalign.h pstdint.h pwarnings.h
  group azure_iot/azure_iot_security_module/iot-security-module-core/deps/flatcc/src/runtime
    ../azure_iot/azure_iot_security_module/iot-security-module-core/deps/flatcc/src/runtime/: builder.c emitter.c refmap.c
  group azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core
    ../azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/: asc_result.h collector.h collector_collection.h collectors_info.h component_id.h component_info.h components_factory.h components_factory_declarations.h components_factory_enum.h components_factory_type.h components_manager.h core.h logger.h object_pool.h object_pool_def.h object_pool_dynamic.h object_pool_static.h serializer.h version.h
  group azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/model
    ../azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/model/: mti.h security_message.h
  group azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/model/objects
    ../azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/model/objects/: network_activity.h objects.h system_information.h transport_protocol.h
  group azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/model/schema
    ../azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/model/schema/: baseline_builder.h baseline_json_parser.h baseline_json_printer.h baseline_reader.h event_builder.h event_json_parser.h event_json_printer.h event_reader.h flatbuffers_common_builder.h flatbuffers_common_reader.h heartbeat_builder.h heartbeat_json_parser.h heartbeat_json_printer.h heartbeat_reader.h listening_ports_builder.h listening_ports_json_parser.h listening_ports_json_printer.h listening_ports_reader.h log_builder.h log_json_parser.h log_json_printer.h log_reader.h message_builder.h message_json_parser.h message_json_printer.h message_reader.h network_activity_builder.h network_activity_json_parser.h network_activity_json_printer.h network_activity_reader.h payload_builder.h payload_json_parser.h payload_json_printer.h payload_reader.h process_builder.h process_event_builder.h process_event_json_parser.h process_event_json_printer.h process_event_reader.h process_event_type_builder.h process_event_type_json_parser.h process_event_type_json_printer.h process_event_type_reader.h process_json_parser.h process_json_printer.h process_reader.h protocol_builder.h protocol_json_parser.h protocol_json_printer.h protocol_reader.h system_information_builder.h system_information_json_parser.h system_information_json_printer.h system_information_reader.h uuid_builder.h uuid_json_parser.h uuid_json_printer.h uuid_reader.h
  group azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/serializer
    ../azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/serializer/: custom_builder_allocator.h page_allocator.h
  group azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/utils/collection
    ../azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/utils/collection/: bit_vector.h collection.h hashset.h hashtable.h linked_list.h list.h stack.h
  group azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/utils
    ../azure_iot/azure_iot_security_module/iot-security-module-core/inc/asc_security_core/utils/: containerof.h event_loop_be.h iconv.h ievent_loop.h ifile.h irand.h istream.h itime.h macros.h notifier.h notifier_topics.h num2str.h os_utils.h string_utils.h uuid.h
  group azure_iot/azure_iot_security_module/iot-security-module-core/src
    ../azure_iot/azure_iot_security_module/iot-security-module-core/src/: collector_collection.c collectors_info.c components_factory.c components_manager.c core.c logger.c object_pool_static.c
  group azure_iot/azure_iot_security_module/iot-security-module-core/src/collectors
    ../azure_iot/azure_iot_security_module/iot-security-module-core/src/collectors/: collector_heartbeat.c
  group azure_iot/azure_iot_security_module/iot-security-module-core/src/model
    ../azure_iot/azure_iot_security_module/iot-security-module-core/src/model/: collector.c security_message.c
  group azure_iot/azure_iot_security_module/iot-security-module-core/src/serializer/extensions
    ../azure_iot/azure_iot_security_module/iot-security-module-core/src/serializer/extensions/: custom_builder_allocator.c page_allocator.c
  group azure_iot/azure_iot_security_module/iot-security-module-core/src/serializer
    ../azure_iot/azure_iot_security_module/iot-security-module-core/src/serializer/: heartbeat.c network_activity.c protocol_serialize_enum.h serializer.c serializer_private.c serializer_private.h system_information.c
  group azure_iot/azure_iot_security_module/iot-security-module-core/src/utils/collection
    ../azure_iot/azure_iot_security_module/iot-security-module-core/src/utils/collection/: bit_vector.c hashtable.c list.c stack.c
  group azure_iot/azure_iot_security_module/iot-security-module-core/src/utils
    ../azure_iot/azure_iot_security_module/iot-security-module-core/src/utils/: event_loop_be.c iconv.c notifier.c string_utils.c uuid.c
  group azure_iot/azure_iot_security_module
    ../azure_iot/azure_iot_security_module/: nx_azure_iot_security_module.c nx_azure_iot_security_module.h
  group azure_iot/azure_iot_security_module/src/collectors
    ../azure_iot/azure_iot_security_module/src/collectors/: collector_network_activity.c collector_system_information.c
  group azure_iot/azure_iot_security_module/src/model/objects
    ../azure_iot/azure_iot_security_module/src/model/objects/: object_network_activity_ext.c
  group azure_iot/azure_iot_security_module/src/utils
    ../azure_iot/azure_iot_security_module/src/utils/: ievent_loop.c irand.c itime.c os_utils.c
  group azure_iot
    ../azure_iot/: nx_azure_iot.c nx_azure_iot.h nx_azure_iot_adu_agent.c nx_azure_iot_adu_agent.h nx_azure_iot_adu_root_key.c nx_azure_iot_hub_client.c nx_azure_iot_hub_client.h nx_azure_iot_hub_client_properties.c nx_azure_iot_hub_client_properties.h nx_azure_iot_json_reader.c nx_azure_iot_json_reader.h nx_azure_iot_json_writer.c nx_azure_iot_json_writer.h nx_azure_iot_provisioning_client.c nx_azure_iot_provisioning_client.h
  group doc
    ../: readme.txt
  group azure-rtos/ports
    ../../../../../../rtos/azure-rtos/ports/netxduo/: nx_driver_imxrt_irq.c nx_driver_imxrt.c nx_driver_imxrt.h
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_enet.h fsl_enet.c fsl_flexspi.c fsl_flexspi.h fsl_lpi2c.c fsl_lpi2c.h fsl_caam.c fsl_caam.h fsl_pit.c fsl_pit.h fsl_lpuart.h fsl_lpuart.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_dcdc.h fsl_dcdc.c fsl_gpio.h fsl_gpio.c fsl_iomuxc.h fsl_pmu.h fsl_pmu.c fsl_memory.h fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group component/phy
    ../../../../../../components/phy/device/phyksz8081/: fsl_phyksz8081.h fsl_phyksz8081.c
    ../../../../../../components/phy/device/phyrtl8211f/: fsl_phyrtl8211f.h fsl_phyrtl8211f.c
    ../../../../../../components/phy/: fsl_phy.h
  group flash/mflash/mimxrt1170
    ../../../../../../components/flash/mflash/mimxrt1170/: mflash_drv.h mflash_drv.c
  group se_hostlib/sss/port/ksdk
    ../../../../../../middleware/se_hostlib/sss/port/ksdk/: fsl_sss_types.h
  group se_hostlib/hostlib/hostLib/inc
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/inc/: Applet_SE050_Ver.h HLSEAPI.h HLSEComm.h HLSECrypto.h HLSEMisc.h HLSEObjects.h HLSETypes.h PlugAndTrust_HostLib_Ver.h PlugAndTrust_Pkg_Ver.h SE_HAL_Lib.h a71ch_api.h a71ch_util.h a71cl_api.h a71cl_util.h ax_api.h ax_common.h ax_common_a71ch.h ax_common_a71cl.h ax_common_private.h ax_scp.h ax_scp_private.h ax_sss_scp.h ax_util.h ledHandler.h modules.h nxEnsure.h nxScp03_Apis.h nxScp03_Const.h nxScp03_Types.h scp.h se05x_const.h se05x_ecc_curves.h se05x_ecc_curves_inc.h se05x_ecc_curves_values.h se05x_enums.h se05x_ftr.h se05x_tlv.h sm_const.h
  group se_hostlib/hostlib/hostLib/se05x/src
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/se05x/src/: se05x_ECC_curves.c se05x_mw.c se05x_tlv.c
  group se_hostlib/sss/inc
    ../../../../../../middleware/se_hostlib/sss/inc/: fsl_sscp.h fsl_sscp_a71ch.h fsl_sscp_a71cl.h fsl_sscp_commands.h fsl_sscp_mu.h fsl_sss_api.h fsl_sss_api_ver.h fsl_sss_config.h fsl_sss_ftr_default.h fsl_sss_keyid_map.h fsl_sss_lpc55s_apis.h fsl_sss_lpc55s_types.h fsl_sss_mbedtls_apis.h fsl_sss_mbedtls_types.h fsl_sss_openssl_apis.h fsl_sss_openssl_types.h fsl_sss_policy.h fsl_sss_se05x_apis.h fsl_sss_se05x_policy.h fsl_sss_se05x_scp03.h fsl_sss_se05x_types.h fsl_sss_sscp.h fsl_sss_sscp_config.h fsl_sss_user_apis.h fsl_sss_user_types.h fsl_sss_util_asn1_der.h fsl_sss_util_rsa_sign_utils.h
  group se_hostlib/sss/src
    ../../../../../../middleware/se_hostlib/sss/src/: fsl_sss_apis.c fsl_sss_util_asn1_der.c fsl_sss_util_rsa_sign_utils.c
  group se_hostlib/sss/src/se05x
    ../../../../../../middleware/se_hostlib/sss/src/se05x/: fsl_sss_se05x_apis.c fsl_sss_se05x_eckey.c fsl_sss_se05x_mw.c fsl_sss_se05x_policy.c fsl_sss_se05x_scp03.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group startup
    ../../../../../../devices/MIMXRT1176/arm/: startup_MIMXRT1176_cm7.S
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/: fsl_assert.c
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1176/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group azure-rtos/netxduo/addons/auto_ip
    ../../../../../../rtos/azure-rtos/netxduo/addons/auto_ip/: nx_auto_ip.c nx_auto_ip.h
  group azure-rtos/netxduo/addons/cloud
    ../../../../../../rtos/azure-rtos/netxduo/addons/cloud/: nx_cloud.c nx_cloud.h
  group azure-rtos/netxduo/addons/dhcp
    ../../../../../../rtos/azure-rtos/netxduo/addons/dhcp/: nxd_dhcp_client.c nxd_dhcp_client.h nxd_dhcp_server.c nxd_dhcp_server.h nxd_dhcpv6_client.c nxd_dhcpv6_client.h nxd_dhcpv6_server.c nxd_dhcpv6_server.h
  group azure-rtos/netxduo/addons/dns
    ../../../../../../rtos/azure-rtos/netxduo/addons/dns/: nxd_dns.c nxd_dns.h
  group azure-rtos/netxduo/addons/ftp
    ../../../../../../rtos/azure-rtos/netxduo/addons/ftp/: nxd_ftp_client.c nxd_ftp_client.h nxd_ftp_server.c nxd_ftp_server.h
  group azure-rtos/netxduo/addons/http
    ../../../../../../rtos/azure-rtos/netxduo/addons/http/: nxd_http_client.c nxd_http_client.h nxd_http_server.c nxd_http_server.h
  group azure-rtos/netxduo/addons/lwm2m
    ../../../../../../rtos/azure-rtos/netxduo/addons/lwm2m/: nx_lwm2m_client.c nx_lwm2m_client.h
  group azure-rtos/netxduo/addons/mdns
    ../../../../../../rtos/azure-rtos/netxduo/addons/mdns/: nxd_mdns.c nxd_mdns.h
  group azure-rtos/netxduo/addons/mqtt
    ../../../../../../rtos/azure-rtos/netxduo/addons/mqtt/: nxd_mqtt_client.c nxd_mqtt_client.h
  group azure-rtos/netxduo/addons/nat
    ../../../../../../rtos/azure-rtos/netxduo/addons/nat/: nx_nat.c nx_nat.h
  group azure-rtos/netxduo/addons/pop3
    ../../../../../../rtos/azure-rtos/netxduo/addons/pop3/: nxd_pop3_client.c nxd_pop3_client.h
  group azure-rtos/netxduo/addons/ppp
    ../../../../../../rtos/azure-rtos/netxduo/addons/ppp/: nx_ppp.c nx_ppp.h
  group azure-rtos/netxduo/addons/pppoe
    ../../../../../../rtos/azure-rtos/netxduo/addons/pppoe/: nx_pppoe_client.c nx_pppoe_client.h nx_pppoe_server.c nx_pppoe_server.h
  group azure-rtos/netxduo/addons/ptp
    ../../../../../../rtos/azure-rtos/netxduo/addons/ptp/: nxd_ptp_client.c nxd_ptp_client.h
  group azure-rtos/netxduo/addons/smtp
    ../../../../../../rtos/azure-rtos/netxduo/addons/smtp/: nxd_smtp_client.c nxd_smtp_client.h
  group azure-rtos/netxduo/addons/snmp
    ../../../../../../rtos/azure-rtos/netxduo/addons/snmp/: nx_des.c nx_des.h nx_sha1.c nx_sha1.h nxd_snmp.c nxd_snmp.h
  group azure-rtos/netxduo/addons/sntp
    ../../../../../../rtos/azure-rtos/netxduo/addons/sntp/: nxd_sntp_client.c nxd_sntp_client.h
  group azure-rtos/netxduo/addons/telnet
    ../../../../../../rtos/azure-rtos/netxduo/addons/telnet/: nxd_telnet_client.c nxd_telnet_client.h nxd_telnet_server.c nxd_telnet_server.h
  group azure-rtos/netxduo/addons/tftp
    ../../../../../../rtos/azure-rtos/netxduo/addons/tftp/: nxd_tftp_client.c nxd_tftp_client.h nxd_tftp_server.c nxd_tftp_server.h
  group azure-rtos/netxduo/addons/web
    ../../../../../../rtos/azure-rtos/netxduo/addons/web/: nx_tcpserver.c nx_tcpserver.h nx_web_http_client.c nx_web_http_client.h nx_web_http_common.h nx_web_http_server.c nx_web_http_server.h
  group azure-rtos/netxduo/addons/websocket
    ../../../../../../rtos/azure-rtos/netxduo/addons/websocket/: nx_websocket_client.c nx_websocket_client.h
  group azure-rtos/netxduo/common/inc
    ../../../../../../rtos/azure-rtos/netxduo/common/inc/: nx_api.h nx_arp.h nx_http_proxy_client.h nx_icmp.h nx_icmpv4.h nx_icmpv6.h nx_igmp.h nx_ip.h nx_ipv4.h nx_ipv6.h nx_md5.h nx_mld.h nx_nd_cache.h nx_packet.h nx_rarp.h nx_system.h nx_tcp.h nx_udp.h nx_user_sample.h
  group azure-rtos/netxduo/crypto_libraries/inc
    ../../../../../../rtos/azure-rtos/netxduo/crypto_libraries/inc/: nx_crypto.h nx_crypto_3des.h nx_crypto_aes.h nx_crypto_cbc.h nx_crypto_ccm.h nx_crypto_const.h nx_crypto_ctr.h nx_crypto_des.h nx_crypto_dh.h nx_crypto_drbg.h nx_crypto_ec.h nx_crypto_ecdh.h nx_crypto_ecdsa.h nx_crypto_ecjpake.h nx_crypto_gcm.h nx_crypto_hkdf.h nx_crypto_hmac.h nx_crypto_hmac_md5.h nx_crypto_hmac_sha1.h nx_crypto_hmac_sha2.h nx_crypto_hmac_sha5.h nx_crypto_huge_number.h nx_crypto_md5.h nx_crypto_method_self_test.h nx_crypto_null.h nx_crypto_phash.h nx_crypto_pkcs1_v1.5.h nx_crypto_rsa.h nx_crypto_sha1.h nx_crypto_sha2.h nx_crypto_sha5.h nx_crypto_tls_prf_1.h nx_crypto_tls_prf_sha256.h nx_crypto_tls_prf_sha384.h nx_crypto_tls_prf_sha512.h nx_crypto_xcbc_mac.h
  group azure-rtos/netxduo/nx_secure/inc
    ../../../../../../rtos/azure-rtos/netxduo/nx_secure/inc/: nx_secure_crypto_table_self_test.h nx_secure_dtls.h nx_secure_dtls_api.h nx_secure_tls.h nx_secure_tls_api.h nx_secure_user_sample.h nx_secure_x509.h
  group azure-rtos/netxduo/nx_secure/ports
    ../../../../../../rtos/azure-rtos/netxduo/nx_secure/ports/: nx_secure_port.h
  group azure-rtos/netxduo/ports/cortex_m7/ac6/inc
    ../../../../../../rtos/azure-rtos/netxduo/ports/cortex_m7/ac6/inc/: nx_port.h
  group azure-rtos/filex/common/inc
    ../../../../../../rtos/azure-rtos/filex/common/inc/: fx_api.h fx_directory.h fx_directory_exFAT.h fx_fault_tolerant.h fx_file.h fx_media.h fx_system.h fx_unicode.h fx_user_sample.h fx_utility.h
  group azure-rtos/filex/ports/generic/inc
    ../../../../../../rtos/azure-rtos/filex/ports/generic/inc/: fx_port.h
  group azure-rtos/threadx/common/inc
    ../../../../../../rtos/azure-rtos/threadx/common/inc/: tx_api.h tx_block_pool.h tx_byte_pool.h tx_event_flags.h tx_initialize.h tx_mutex.h tx_queue.h tx_semaphore.h tx_thread.h tx_timer.h tx_trace.h tx_user_sample.h
  group azure-rtos/threadx/ports/common
    ../../../../../../rtos/azure-rtos/threadx/ports/common/: tx_initialize_low_level.c
  group azure-rtos/threadx/ports/cortex_m7/ac6/inc
    ../../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc/: tx_port.h
  group azure-rtos/threadx/ports/cortex_m7/ac6/src
    ../../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/src/: tx_thread_context_restore.S tx_thread_context_save.S tx_thread_interrupt_control.S tx_thread_interrupt_disable.S tx_thread_interrupt_restore.S tx_thread_schedule.S tx_thread_stack_build.S tx_thread_system_return.S tx_timer_interrupt.S
  group flash/mflash
    ../../../../../../components/flash/mflash/: mflash_common.h
  group se_hostlib/hostlib/hostLib/platform/inc
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/platform/inc/: ax_reset.h i2c_a7.h se05x_apis.h se_pit_config.h se_reset_config.h sm_printf.h sm_timer.h
  group se_hostlib/hostlib/hostLib/platform/ksdk
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/platform/ksdk/: ax_reset.c i2c_frdm.c i2c_imxrt.c i2c_lpc54xxx.c i2c_lpc55sxx.c se05x_reset.c timer_kinetis.c timer_kinetis_bm.c timer_kinetis_freertos.c timer_kinetis_threadx.c
  group se_hostlib/hostlib/hostLib/libCommon/smCom
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/: apduComm.h sci2c_cfg.h smCom.c smCom.h smComT1oI2C.c smComT1oI2C.h
  group se_hostlib/hostlib/hostLib/libCommon/smCom/T1oI2C
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/T1oI2C/: phEseStatus.h phEseTypes.h phNxpEsePal_i2c.h phNxpEseProto7816_3.h phNxpEse_Api.h phNxpEse_Internal.h phNxpEsePal_i2c.c phNxpEseProto7816_3.c phNxpEse_Api.c
  group se_hostlib/hostlib/hostLib/libCommon/infra
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/infra/: global_platf.c sm_connect.c a71_debug.h app_boot.h app_boot_nfc.h cm_commands.h global_platf.h sm_apdu.h sm_api.h sm_demo_utils.h sm_errors.h sm_types.h sm_apdu.c sm_errors.c sm_printf.c
  group se_hostlib/sss/ex/inc
    ../../../../../../middleware/se_hostlib/sss/ex/inc/: ex_a71ch_scp03.h ex_scp03_puf.h ex_sss.h ex_sss_auth.h ex_sss_boot.h ex_sss_main_cc_inc.h ex_sss_main_freeRTOS_inc.h ex_sss_main_inc.h ex_sss_main_inc_frdmk64f.h ex_sss_main_inc_imx_rt.h ex_sss_main_inc_ksdk.h ex_sss_main_inc_linux.h ex_sss_main_inc_lpcxpresso55s.h ex_sss_main_inc_nrf.h ex_sss_main_inc_qn9090.h ex_sss_objid.h ex_sss_ports.h ex_sss_scp03_keys.h ex_sss_tp_scp03_keys.h
  group se_hostlib/sss/ex/src
    ../../../../../../middleware/se_hostlib/sss/ex/src/: ex_sss_boot.c ex_sss_boot_connectstring.c ex_sss_boot_int.h ex_sss_se05x.c ex_sss_se05x_auth.c
  group se_hostlib/hostlib/hostLib/se05x_03_xx_xx
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/se05x_03_xx_xx/: se05x_APDU.c se05x_APDU.h se05x_APDU_apis.h se05x_APDU_impl.h se05x_04_xx_APDU_apis.h se05x_04_xx_APDU_impl.h
  group se_hostlib/hostlib/hostLib/libCommon/nxScp
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/nxScp/: nxScp03_Com.c
  group se_hostlib/hostlib/hostLib/libCommon/scp
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/scp/: scp.c
  group se_hostlib/hostlib/hostLib/libCommon/log
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/log/: nxLog.c nxLog.h nxLog_App.h nxLog_DefaultConfig.h nxLog_UseCases.h nxLog_VCOM.h nxLog_hostLib.h nxLog_mbedtls.h nxLog_scp.h nxLog_smCom.h nxLog_sscp.h nxLog_sss.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
target azure_iot_embedded_sdk_adu_se050 flexspi_nor_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: azure_iot_embedded_sdk_adu_se050.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, __CLANG_ARM, CPU_MIMXRT1176DVMAA_cm7, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, USE_THREADX_RTOS, DEBUG_CONSOLE_ENABLE_ECHO=1, DEBUG_CONSOLE_SCANF_MAX_LOG_LEN=120, SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC, IMX_RT, NXD_MQTT_OVER_WEBSOCKET, SDK_DEBUGCONSOLE_UART, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK, AZ_NO_PRECONDITION_CHECKING, CRYPTO_USE_DRIVER_CAAM, CACHE_MODE_WRITE_THROUGH=1, MFLASH_FILE_BASEADDR=14221312, T1oI2C, T1oI2C_UM11225, SSS_USE_FTR_FILE, NO_SECURE_CHANNEL_SUPPORT, NX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE, FSL_RTOS_THREADX
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor.scf
  link misc: as above
