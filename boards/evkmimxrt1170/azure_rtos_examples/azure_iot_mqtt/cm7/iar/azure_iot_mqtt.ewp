# IAR project azure_iot_mqtt.ewp, settings and files
configuration sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; DEBUG; CPU_MIMXRT1176DVMAA_cm7; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; CRYPTO_USE_DRIVER_CAAM; NX_INCLUDE_USER_DEFINE_FILE; FX_INCLUDE_USER_DEFINE_FILE; TX_INCLUDE_USER_DEFINE_FILE
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../components/phy/mdio/enet; ../../../../../../components/phy/device/phyksz8081; ../../../../../../components/phy/device/phyrtl8211f; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../components/lists; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../devices/MIMXRT1176; ../../../../../../CMSIS/Include; ../../../../../../devices/MIMXRT1176/drivers/cm7; ../../../../xip; ../../../../../../devices/MIMXRT1176/xip; ../../../../../../devices/MIMXRT1176/utilities/str; ../../../../../../devices/MIMXRT1176/utilities/debug_console; ../../../../../../rtos/azure-rtos/netxduo/addons/auto_ip; ../../../../../../rtos/azure-rtos/netxduo/addons/cloud; ../../../../../../rtos/azure-rtos/netxduo/addons/BSD; ../../../../../../rtos/azure-rtos/netxduo/addons/dhcp; ../../../../../../rtos/azure-rtos/netxduo/addons/dns; ../../../../../../rtos/azure-rtos/netxduo/addons/ftp; ../../../../../../rtos/azure-rtos/netxduo/addons/http; ../../../../../../rtos/azure-rtos/netxduo/addons/mdns; ../../../../../../rtos/azure-rtos/netxduo/addons/mqtt; ../../../../../../rtos/azure-rtos/netxduo/addons/nat; ../../../../../../rtos/azure-rtos/netxduo/addons/pop3; ../../../../../../rtos/azure-rtos/netxduo/addons/ppp; ../../../../../../rtos/azure-rtos/netxduo/addons/pppoe; ../../../../../../rtos/azure-rtos/netxduo/addons/smtp; ../../../../../../rtos/azure-rtos/netxduo/addons/snmp; ../../../../../../rtos/azure-rtos/netxduo/addons/sntp; ../../../../../../rtos/azure-rtos/netxduo/addons/telnet; ../../../../../../rtos/azure-rtos/netxduo/addons/tftp; ../../../../../../rtos/azure-rtos/netxduo/addons/web; ../../../../../../rtos/azure-rtos/netxduo/common/inc; ../../../../../../rtos/azure-rtos/netxduo/crypto_libraries/inc; ../../../../../../rtos/azure-rtos/netxduo/nx_secure/inc; ../../../../../../rtos/azure-rtos/netxduo/nx_secure/ports; ../../../../../../rtos/azure-rtos/netxduo/ports/cortex_m7/iar/inc; ../../../../../../rtos/azure-rtos/filex/common/inc; ../../../../../../rtos/azure-rtos/filex/ports/cortex_m7/iar/inc; ../../../../../../rtos/azure-rtos/threadx/common/inc; ../../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/iar/inc; ../../../../../../components/phy
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA; TX_ENABLE_FPU_SUPPORT
  ILINK.IlinkOutputFile: azure_iot_mqtt.out
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../rtos/azure-rtos/binary/netxduo/cortex_m7/iar/libnetxduo.a; ../../../../../../rtos/azure-rtos/binary/filex/cortex_m7/iar/libfilex.a; ../../../../../../rtos/azure-rtos/binary/threadx/cortex_m7/iar/libthreadx.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1176DVMAA_cm7; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; CRYPTO_USE_DRIVER_CAAM; NX_INCLUDE_USER_DEFINE_FILE; FX_INCLUDE_USER_DEFINE_FILE; TX_INCLUDE_USER_DEFINE_FILE
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; CRYPTO_USE_DRIVER_CAAM; NX_INCLUDE_USER_DEFINE_FILE; FX_INCLUDE_USER_DEFINE_FILE; TX_INCLUDE_USER_DEFINE_FILE
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA; TX_ENABLE_FPU_SUPPORT
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; CRYPTO_USE_DRIVER_CAAM; NX_INCLUDE_USER_DEFINE_FILE; FX_INCLUDE_USER_DEFINE_FILE; TX_INCLUDE_USER_DEFINE_FILE
  AARM.ADefines: as above
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group source
    ../: main.c sample_azure_iot.c get_seed.c
  group azure-rtos/config
    ../: tx_user.h nx_user.h fx_user.h
  group azure-rtos/netxduo/addons/auto_ip
    ../../../../../../rtos/azure-rtos/netxduo/addons/auto_ip/: nx_auto_ip.c nx_auto_ip.h
  group azure-rtos/netxduo/addons/cloud
    ../../../../../../rtos/azure-rtos/netxduo/addons/cloud/: nx_cloud.c nx_cloud.h
  group azure-rtos/netxduo/addons/dhcp
    ../../../../../../rtos/azure-rtos/netxduo/addons/dhcp/: nxd_dhcpv6_server.c nxd_dhcp_server.h nxd_dhcpv6_server.h nxd_dhcpv6_client.h nxd_dhcpv6_client.c nxd_dhcp_client.c nxd_dhcp_server.c nxd_dhcp_client.h
  group azure-rtos/netxduo/addons/dns
    ../../../../../../rtos/azure-rtos/netxduo/addons/dns/: nxd_dns.c nxd_dns.h
  group azure-rtos/netxduo/addons/ftp
    ../../../../../../rtos/azure-rtos/netxduo/addons/ftp/: nxd_ftp_client.h nxd_ftp_server.h nxd_ftp_client.c nxd_ftp_server.c
  group azure-rtos/netxduo/addons/http
    ../../../../../../rtos/azure-rtos/netxduo/addons/http/: nxd_http_client.c nxd_http_server.h nxd_http_client.h nxd_http_server.c
  group azure-rtos/netxduo/addons/mdns
    ../../../../../../rtos/azure-rtos/netxduo/addons/mdns/: nxd_mdns.h nxd_mdns.c
  group azure-rtos/netxduo/addons/mqtt
    ../../../../../../rtos/azure-rtos/netxduo/addons/mqtt/: nxd_mqtt_client.h nxd_mqtt_client.c
  group azure-rtos/netxduo/addons/nat
    ../../../../../../rtos/azure-rtos/netxduo/addons/nat/: nx_nat.h nx_nat.c
  group azure-rtos/netxduo/addons/pop3
    ../../../../../../rtos/azure-rtos/netxduo/addons/pop3/: nxd_pop3_client.h nxd_pop3_client.c
  group azure-rtos/netxduo/addons/ppp
    ../../../../../../rtos/azure-rtos/netxduo/addons/ppp/: nx_ppp.h nx_ppp.c
  group azure-rtos/netxduo/addons/pppoe
    ../../../../../../rtos/azure-rtos/netxduo/addons/pppoe/: nx_pppoe_server.c nx_pppoe_server.h nx_pppoe_client.c nx_pppoe_client.h
  group azure-rtos/netxduo/addons/smtp
    ../../../../../../rtos/azure-rtos/netxduo/addons/smtp/: nxd_smtp_client.c nxd_smtp_client.h
  group azure-rtos/netxduo/addons/snmp
    ../../../../../../rtos/azure-rtos/netxduo/addons/snmp/: nx_sha1.c nxd_snmp.h nx_des.h nx_sha1.h nx_des.c nxd_snmp.c
  group azure-rtos/netxduo/addons/sntp
    ../../../../../../rtos/azure-rtos/netxduo/addons/sntp/: nxd_sntp_client.h nxd_sntp_client.c
  group azure-rtos/netxduo/addons/telnet
    ../../../../../../rtos/azure-rtos/netxduo/addons/telnet/: nxd_telnet_server.c nxd_telnet_client.c nxd_telnet_server.h nxd_telnet_client.h
  group azure-rtos/netxduo/addons/tftp
    ../../../../../../rtos/azure-rtos/netxduo/addons/tftp/: nxd_tftp_client.c nxd_tftp_server.h nxd_tftp_server.c nxd_tftp_client.h
  group azure-rtos/netxduo/addons/web
    ../../../../../../rtos/azure-rtos/netxduo/addons/web/: nx_tcpserver.c nx_web_http_server.h nx_web_http_server.c nx_tcpserver.h nx_web_http_client.c nx_web_http_common.h nx_web_http_client.h
  group azure-rtos/netxduo/common/inc
    ../../../../../../rtos/azure-rtos/netxduo/common/inc/: nx_igmp.h nx_ipv4.h nx_packet.h nx_nd_cache.h nx_md5.h nx_icmpv6.h nx_icmp.h nx_user_sample.h nx_tcp.h nx_icmpv4.h nx_arp.h nx_ipv6.h nx_system.h nx_api.h nx_rarp.h nx_mld.h nx_ip.h nx_udp.h
  group azure-rtos/netxduo/crypto_libraries/inc
    ../../../../../../rtos/azure-rtos/netxduo/crypto_libraries/inc/: nx_crypto_sha1.h nx_crypto_hmac_md5.h nx_crypto_xcbc_mac.h nx_crypto_hmac.h nx_crypto_ccm.h nx_crypto_dh.h nx_crypto_tls_prf_1.h nx_crypto_const.h nx_crypto_cbc.h nx_crypto_ec.h nx_crypto_md5.h nx_crypto_tls_prf_sha384.h nx_crypto.h nx_crypto_sha5.h nx_crypto_rsa.h nx_crypto_ecdh.h nx_crypto_ecdsa.h nx_crypto_hmac_sha2.h nx_crypto_3des.h nx_crypto_null.h nx_crypto_drbg.h nx_crypto_phash.h nx_crypto_hmac_sha1.h nx_crypto_gcm.h nx_crypto_tls_prf_sha256.h nx_crypto_sha2.h nx_crypto_pkcs1_v1.5.h nx_crypto_tls_prf_sha512.h nx_crypto_huge_number.h nx_crypto_hmac_sha5.h nx_crypto_ecjpake.h nx_crypto_des.h nx_crypto_ctr.h nx_crypto_aes.h nx_crypto_method_self_test.h nx_crypto_hkdf.h
  group azure-rtos/netxduo/nx_secure/inc
    ../../../../../../rtos/azure-rtos/netxduo/nx_secure/inc/: nx_secure_tls_api.h nx_secure_dtls_api.h nx_secure_user_sample.h nx_secure_x509.h nx_secure_dtls.h nx_secure_crypto_table_self_test.h nx_secure_tls.h
  group azure-rtos/netxduo/nx_secure/ports
    ../../../../../../rtos/azure-rtos/netxduo/nx_secure/ports/: nx_secure_port.h
  group azure-rtos/netxduo/ports/cortex_m7/iar/inc
    ../../../../../../rtos/azure-rtos/netxduo/ports/cortex_m7/iar/inc/: nx_port.h
  group azure-rtos/filex/common/inc
    ../../../../../../rtos/azure-rtos/filex/common/inc/: fx_media.h fx_unicode.h fx_api.h fx_directory_exFAT.h fx_utility.h fx_file.h fx_system.h fx_directory.h fx_user_sample.h fx_fault_tolerant.h
  group azure-rtos/filex/ports/cortex_m7/iar/inc
    ../../../../../../rtos/azure-rtos/filex/ports/cortex_m7/iar/inc/: fx_port.h
  group azure-rtos/threadx/common/inc
    ../../../../../../rtos/azure-rtos/threadx/common/inc/: tx_byte_pool.h tx_event_flags.h tx_timer.h tx_queue.h tx_thread.h tx_mutex.h tx_trace.h tx_initialize.h tx_api.h tx_user_sample.h tx_block_pool.h tx_semaphore.h
  group azure-rtos/threadx/ports/cortex_m7/iar/inc
    ../../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/iar/inc/: tx_port.h
  group azure-rtos/threadx/ports/cortex_m7/iar/src
    ../../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/iar/src/: tx_thread_interrupt_control.s tx_timer_interrupt.s tx_thread_interrupt_restore.s tx_iar.c tx_thread_schedule.s tx_initialize_low_level.s tx_thread_stack_build.s tx_thread_system_return.s tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_disable.s
  group ports
    ../: nx_driver_imxrt_irq.c nx_driver_imxrt.c nx_driver_imxrt.h
  group doc
    ../: readme.txt
  group mdio
    ../../../../../../components/phy/mdio/enet/: fsl_enet_mdio.h fsl_enet_mdio.c
    ../../../../../../components/phy/: fsl_mdio.h
  group phy
    ../../../../../../components/phy/device/phyksz8081/: fsl_phyksz8081.h fsl_phyksz8081.c
    ../../../../../../components/phy/device/phyrtl8211f/: fsl_phyrtl8211f.h fsl_phyrtl8211f.c
    ../../../../../../components/phy/: fsl_phy.h
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_caam.c fsl_caam.h fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_clock.h fsl_clock.c fsl_dcdc.h fsl_dcdc.c fsl_gpio.h fsl_gpio.c fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_pmu.h fsl_pmu.c fsl_anatop_ai.h fsl_anatop_ai.c fsl_enet.h fsl_enet.c
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group startup
    ../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group xip
    ../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/: fsl_assert.c
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1176/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
