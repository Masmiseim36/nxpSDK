<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>pnp_temperature_controller</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
      <member>
        <project>pnp_temperature_controller</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
      <member>
        <project>pnp_temperature_controller</project>
        <configuration>sdram_txt_debug</configuration>
      </member>
      <member>
        <project>pnp_temperature_controller</project>
        <configuration>sdram_txt_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_debug</name>
      <member>
        <project>pnp_temperature_controller</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_release</name>
      <member>
        <project>pnp_temperature_controller</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdram_txt_debug</name>
      <member>
        <project>pnp_temperature_controller</project>
        <configuration>sdram_txt_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdram_txt_release</name>
      <member>
        <project>pnp_temperature_controller</project>
        <configuration>sdram_txt_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/pnp_temperature_controller.ewp</path>
  </project>
</workspace>
