# Keil uVision project usbx_lib.uvprojx, settings and files
target usbx_lib Debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: libusbx.lib (library)
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: DEBUG, CPU_MIMXRT1176DVMAA_cm7, MIMXRT, UX_OTG_SUPPORT, TX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, NX_INCLUDE_USER_DEFINE_FILE, UX_INCLUDE_USER_DEFINE_FILE, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../rtos/azure-rtos/threadx/common/inc;../../../../../rtos/azure-rtos/filex/common/inc;../../../../../rtos/azure-rtos/netxduo/common/inc;../../../../../rtos/azure-rtos/netxduo/crypto_libraries/inc;../../../../../rtos/azure-rtos/netxduo/nx_secure/inc;../../../../../rtos/azure-rtos/netxduo/nx_secure/ports;../../../../../rtos/azure-rtos/usbx/common/core/inc;../../../../../rtos/azure-rtos/usbx/common/usbx_device_classes/inc;../../../../../rtos/azure-rtos/usbx/common/usbx_host_classes/inc;../../../../../rtos/azure-rtos/usbx/common/usbx_host_controllers/inc;../../../../../rtos/azure-rtos/usbx/common/usbx_network/inc;../../../../../rtos/azure-rtos/usbx/common/usbx_pictbridge/inc;../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc;../../../../../rtos/azure-rtos/filex/ports/cortex_m7/ac6/inc;../../../../../rtos/azure-rtos/netxduo/ports/cortex_m7/ac6/inc;../../../../../rtos/azure-rtos/usbx/ports/cortex_m7/ac6/inc
  asm define: DEBUG, DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group doc
    ../: readme.txt
  group azure-rtos/config
    ../: tx_user.h fx_user.h nx_user.h ux_user.h
  group azure-rtos/threadx/common/inc
    ../../../../../rtos/azure-rtos/threadx/common/inc/: tx_api.h tx_block_pool.h tx_byte_pool.h tx_event_flags.h tx_initialize.h tx_mutex.h tx_queue.h tx_semaphore.h tx_thread.h tx_timer.h tx_trace.h tx_user_sample.h
  group azure-rtos/filex/common/inc
    ../../../../../rtos/azure-rtos/filex/common/inc/: fx_api.h fx_directory.h fx_directory_exFAT.h fx_fault_tolerant.h fx_file.h fx_media.h fx_system.h fx_unicode.h fx_user_sample.h fx_utility.h
  group azure-rtos/netxduo/common/inc
    ../../../../../rtos/azure-rtos/netxduo/common/inc/: nx_api.h nx_arp.h nx_icmp.h nx_icmpv4.h nx_icmpv6.h nx_igmp.h nx_ip.h nx_ipv4.h nx_ipv6.h nx_md5.h nx_mld.h nx_nd_cache.h nx_packet.h nx_rarp.h nx_system.h nx_tcp.h nx_udp.h nx_user_sample.h
  group azure-rtos/netxduo/crypto_libraries/inc
    ../../../../../rtos/azure-rtos/netxduo/crypto_libraries/inc/: nx_crypto.h nx_crypto_3des.h nx_crypto_aes.h nx_crypto_cbc.h nx_crypto_ccm.h nx_crypto_const.h nx_crypto_ctr.h nx_crypto_des.h nx_crypto_dh.h nx_crypto_drbg.h nx_crypto_ec.h nx_crypto_ecdh.h nx_crypto_ecdsa.h nx_crypto_ecjpake.h nx_crypto_gcm.h nx_crypto_hkdf.h nx_crypto_hmac.h nx_crypto_hmac_md5.h nx_crypto_hmac_sha1.h nx_crypto_hmac_sha2.h nx_crypto_hmac_sha5.h nx_crypto_huge_number.h nx_crypto_md5.h nx_crypto_method_self_test.h nx_crypto_null.h nx_crypto_phash.h nx_crypto_pkcs1_v1.5.h nx_crypto_rsa.h nx_crypto_sha1.h nx_crypto_sha2.h nx_crypto_sha5.h nx_crypto_tls_prf_1.h nx_crypto_tls_prf_sha256.h nx_crypto_tls_prf_sha384.h nx_crypto_tls_prf_sha512.h nx_crypto_xcbc_mac.h
  group azure-rtos/netxduo/nx_secure/inc
    ../../../../../rtos/azure-rtos/netxduo/nx_secure/inc/: nx_secure_crypto_table_self_test.h nx_secure_dtls.h nx_secure_dtls_api.h nx_secure_tls.h nx_secure_tls_api.h nx_secure_user_sample.h nx_secure_x509.h
  group azure-rtos/netxduo/nx_secure/ports
    ../../../../../rtos/azure-rtos/netxduo/nx_secure/ports/: nx_secure_port.h
  group azure-rtos/usbx/common/core/inc
    ../../../../../rtos/azure-rtos/usbx/common/core/inc/: ux_api.h ux_dcd_sim_slave.h ux_device_class_dpump.h ux_device_stack.h ux_hcd_sim_host.h ux_host_class_dpump.h ux_host_stack.h ux_system.h ux_user_sample.h ux_utility.h
  group azure-rtos/usbx/common/usbx_device_classes/inc
    ../../../../../rtos/azure-rtos/usbx/common/usbx_device_classes/inc/: ux_device_class_audio.h ux_device_class_audio10.h ux_device_class_audio20.h ux_device_class_cdc_acm.h ux_device_class_cdc_ecm.h ux_device_class_dfu.h ux_device_class_hid.h ux_device_class_pima.h ux_device_class_rndis.h ux_device_class_storage.h
  group azure-rtos/usbx/common/usbx_host_classes/inc
    ../../../../../rtos/azure-rtos/usbx/common/usbx_host_classes/inc/: ux_host_class_asix.h ux_host_class_audio.h ux_host_class_cdc_acm.h ux_host_class_cdc_ecm.h ux_host_class_gser.h ux_host_class_hid.h ux_host_class_hid_keyboard.h ux_host_class_hid_mouse.h ux_host_class_hid_remote_control.h ux_host_class_hub.h ux_host_class_pima.h ux_host_class_printer.h ux_host_class_prolific.h ux_host_class_storage.h ux_host_class_swar.h ux_host_class_video.h
  group azure-rtos/usbx/common/usbx_host_controllers/inc
    ../../../../../rtos/azure-rtos/usbx/common/usbx_host_controllers/inc/: ux_hcd_ehci.h ux_hcd_ohci.h
  group azure-rtos/usbx/common/usbx_network/inc
    ../../../../../rtos/azure-rtos/usbx/common/usbx_network/inc/: ux_network_driver.h
  group azure-rtos/usbx/common/usbx_pictbridge/inc
    ../../../../../rtos/azure-rtos/usbx/common/usbx_pictbridge/inc/: ux_pictbridge.h
  group azure-rtos/usbx/common/core/src
    ../../../../../rtos/azure-rtos/usbx/common/core/src/: ux_system_initialize.c
  group azure-rtos/usbx/common/core
    ../../../../../rtos/azure-rtos/usbx/common/core/: usbx_core_source.c
  group azure-rtos/usbx/common/usbx_device_classes
    ../../../../../rtos/azure-rtos/usbx/common/usbx_device_classes/: usbx_device_classes_source.c
  group azure-rtos/usbx/common/usbx_host_classes
    ../../../../../rtos/azure-rtos/usbx/common/usbx_host_classes/: usbx_host_classes_source.c
  group azure-rtos/usbx/common/usbx_host_controllers/src
    ../../../../../rtos/azure-rtos/usbx/common/usbx_host_controllers/src/: ux_hcd_ehci_asynch_td_process.c ux_hcd_ehci_asynchronous_endpoint_create.c ux_hcd_ehci_asynchronous_endpoint_destroy.c ux_hcd_ehci_controller_disable.c ux_hcd_ehci_done_queue_process.c ux_hcd_ehci_door_bell_wait.c ux_hcd_ehci_ed_clean.c ux_hcd_ehci_ed_obtain.c ux_hcd_ehci_endpoint_reset.c ux_hcd_ehci_entry.c ux_hcd_ehci_frame_number_get.c ux_hcd_ehci_frame_number_set.c ux_hcd_ehci_fsisochronous_td_obtain.c ux_hcd_ehci_fsisochronous_tds_process.c ux_hcd_ehci_hsisochronous_td_obtain.c ux_hcd_ehci_hsisochronous_tds_process.c ux_hcd_ehci_initialize.c ux_hcd_ehci_interrupt_endpoint_create.c ux_hcd_ehci_interrupt_endpoint_destroy.c ux_hcd_ehci_interrupt_handler.c ux_hcd_ehci_isochronous_endpoint_create.c ux_hcd_ehci_isochronous_endpoint_destroy.c ux_hcd_ehci_least_traffic_list_get.c ux_hcd_ehci_next_td_clean.c ux_hcd_ehci_periodic_descriptor_link.c ux_hcd_ehci_periodic_tree_create.c ux_hcd_ehci_poll_rate_entry_get.c ux_hcd_ehci_port_disable.c ux_hcd_ehci_port_reset.c ux_hcd_ehci_port_resume.c ux_hcd_ehci_port_status_get.c ux_hcd_ehci_port_suspend.c ux_hcd_ehci_power_down_port.c ux_hcd_ehci_power_on_port.c ux_hcd_ehci_power_root_hubs.c ux_hcd_ehci_register_read.c ux_hcd_ehci_register_write.c ux_hcd_ehci_regular_td_obtain.c ux_hcd_ehci_request_bulk_transfer.c ux_hcd_ehci_request_control_transfer.c ux_hcd_ehci_request_interrupt_transfer.c ux_hcd_ehci_request_isochronous_transfer.c ux_hcd_ehci_request_transfer.c ux_hcd_ehci_request_transfer_add.c ux_hcd_ehci_transfer_abort.c ux_hcd_ehci_transfer_request_process.c ux_hcd_ohci_asynchronous_endpoint_create.c ux_hcd_ohci_asynchronous_endpoint_destroy.c ux_hcd_ohci_controller_disable.c ux_hcd_ohci_done_queue_process.c ux_hcd_ohci_ed_obtain.c ux_hcd_ohci_endpoint_error_clear.c ux_hcd_ohci_endpoint_reset.c ux_hcd_ohci_entry.c ux_hcd_ohci_frame_number_get.c ux_hcd_ohci_frame_number_set.c ux_hcd_ohci_initialize.c ux_hcd_ohci_interrupt_endpoint_create.c ux_hcd_ohci_interrupt_handler.c ux_hcd_ohci_isochronous_endpoint_create.c ux_hcd_ohci_isochronous_td_obtain.c ux_hcd_ohci_least_traffic_list_get.c ux_hcd_ohci_next_td_clean.c ux_hcd_ohci_periodic_endpoint_destroy.c ux_hcd_ohci_periodic_tree_create.c ux_hcd_ohci_port_disable.c ux_hcd_ohci_port_enable.c ux_hcd_ohci_port_reset.c ux_hcd_ohci_port_resume.c ux_hcd_ohci_port_status_get.c ux_hcd_ohci_port_suspend.c ux_hcd_ohci_power_down_port.c ux_hcd_ohci_power_on_port.c ux_hcd_ohci_power_root_hubs.c ux_hcd_ohci_register_read.c ux_hcd_ohci_register_write.c ux_hcd_ohci_regular_td_obtain.c ux_hcd_ohci_request_bulk_transfer.c ux_hcd_ohci_request_control_transfer.c ux_hcd_ohci_request_interupt_transfer.c ux_hcd_ohci_request_isochronous_transfer.c ux_hcd_ohci_request_transfer.c ux_hcd_ohci_transfer_abort.c ux_hcd_ohci_transfer_request_process.c
  group azure-rtos/usbx/common/usbx_pictbridge
    ../../../../../rtos/azure-rtos/usbx/common/usbx_pictbridge/: usbx_pictbridge_source.c
  group azure-rtos/usbx/common/usbx_network/src
    ../../../../../rtos/azure-rtos/usbx/common/usbx_network/src/: ux_network_driver.c
  group azure-rtos/threadx/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/threadx/ports/cortex_m7/ac6/inc/: tx_port.h
  group azure-rtos/filex/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/filex/ports/cortex_m7/ac6/inc/: fx_port.h
  group azure-rtos/netxduo/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/netxduo/ports/cortex_m7/ac6/inc/: nx_port.h
  group azure-rtos/usbx/ports/cortex_m7/ac6/inc
    ../../../../../rtos/azure-rtos/usbx/ports/cortex_m7/ac6/inc/: ux_port.h
target usbx_lib Release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: libusbx.lib (library)
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1176DVMAA_cm7, MIMXRT, UX_OTG_SUPPORT, TX_INCLUDE_USER_DEFINE_FILE, FX_INCLUDE_USER_DEFINE_FILE, NX_INCLUDE_USER_DEFINE_FILE, UX_INCLUDE_USER_DEFINE_FILE, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
