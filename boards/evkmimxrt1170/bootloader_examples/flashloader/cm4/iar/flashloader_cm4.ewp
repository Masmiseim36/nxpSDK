# IAR project flashloader_cm4.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M4 NXP MIMXRT1176xxxA_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1176DVMAA_cm4; CPU_IS_ARM_CORTEX_M4=1; BL_TARGET_RAM; MIMXRT1176; USB_STACK_BM
  ICCARM.CCDiagSuppress: Pa082,Pe177,Pe186,Ms014,Pa182
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MIMXRT1176; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../devices/MIMXRT1052; ../../../../../../middleware/mcu-boot/src/bm_usb; ../../../../../../middleware/mcu-boot/src/autobaud; ../../../../../../middleware/mcu-boot/src/bootloader; ../../../../../../middleware/mcu-boot/src/crc; ../../../../../../middleware/mcu-boot/src/include; ../../../../../../middleware/mcu-boot/src/memory; ../../../../../../middleware/mcu-boot/src/memory/src; ../../../../../../middleware/mcu-boot/src/startup; ../../../../../../middleware/mcu-boot/src/packet; ../../../../../../middleware/mcu-boot/src/property; ../../../../../../middleware/mcu-boot/src/sbloader; ../../../../../../middleware/mcu-boot/src/utilities; ../../../../../../middleware/mcu-boot/targets/MIMXRT1176/src; ../../../../../../middleware/mcu-boot/src; ../../../../../../middleware/mcu-boot/src/authentication; ../../../../../../middleware/mcu-boot/src/security/keyblob; ../../../../../../middleware/mcu-boot/src/drivers; ../../../../../../middleware/mcu-boot/src/drivers/flexspi_nor; ../../../../../../middleware/mcu-boot/src/drivers/flexspi; ../../../../../../middleware/mcu-boot/src/drivers/serial_nor_eeprom; ../../../../../../middleware/mcu-boot/src/drivers/sdmmc/inc; ../../../../../../platform/drivers/puf; ../../../../../../middleware/mcu-boot/src/drivers/semc; ../../../../../../middleware/mcu-boot/src/drivers/nand_ecc; ../../../../../../middleware/usb/device; ../../../../../../components/osa; ../../../../../../middleware/usb/include; ../../../../../../middleware/mcu-boot/src/drivers/semc_nand; ../../../../../../middleware/mcu-boot/src/drivers/microseconds; ../../../../../../middleware/mcu-boot/src/drivers/flexspi_nand; ../../../../../../middleware/mcu-boot/src/drivers/ocotp; ../../../../../../CMSIS/Core/Include; ../../../../../../middleware/mcu-boot/src/drivers/usdhc; ../../../../../../components/lists; ../../../../../../middleware/usb/phy
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG
  AARM.AUserIncludes: ../../../../../../middleware/mcu-boot/src/startup
  ILINK.IlinkOutputFile: flashloader_cm4.out
  ILINK.IlinkIcfFile: MIMXRT1176_ram_flashloader.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group board
    ../: pin_mux.c pin_mux.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm4.h MIMXRT1176_cm4_features.h system_MIMXRT1176_cm4.h
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_clock.h fsl_clock.c fsl_pmu.h fsl_pmu.c fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_anatop_ai.h fsl_anatop_ai.c fsl_lpspi.c fsl_lpspi.h
  group mcu-boot/device
    ../../../../../../middleware/mcu-boot/targets/MIMXRT1176/src/startup/: system_MIMXRT1176_cm4.c
  group startup
    ../../../../../../middleware/mcu-boot/targets/MIMXRT1176/src/startup/iar/: startup_MIMXRT1176_cm4.s
    ../../../../../../middleware/mcu-boot/src/startup/: ar_asm_macros.h startup.c
  group source/usb/bm_composite
    ../../../../../../middleware/mcu-boot/src/bm_usb/: bootloader_hid_report_ids.h fat_directory_entry.h composite.h composite.c hid_bootloader.h hid_bootloader.c usb_descriptor.h usb_descriptor.c
    ../../../../../../middleware/mcu-boot/targets/MIMXRT1176/src/: usb_device_config.h
  group source/autobaud
    ../../../../../../middleware/mcu-boot/src/autobaud/: autobaud.h
    ../../../../../../middleware/mcu-boot/src/autobaud/src/: autobaud_irq.c
  group source/bootloader
    ../../../../../../middleware/mcu-boot/src/bootloader/: bl_peripheral_interface.h bl_user_entry.h bl_version.h bootloader.h bl_command.h bl_context.h bl_peripheral.h bl_shutdown_cleanup.h bl_irq_common.h bl_app_crc_check.h bl_keyblob.h
  group source/bootloader/src
    ../../../../../../middleware/mcu-boot/src/bootloader/src/: bl_user_entry.c bl_main.c bl_context.c bl_exception_handler.c bl_tree_root.c bl_command.c bl_shutdown_cleanup.c bl_app_crc_check.c bl_misc.c lpuart_peripheral_interface.c usb_hid_msc_peripheral_interface.c
  group source/crc
    ../../../../../../middleware/mcu-boot/src/crc/: crc16.h crc32.h
    ../../../../../../middleware/mcu-boot/src/crc/src/: crc16.c crc32.c
  group source/include
    ../../../../../../middleware/mcu-boot/src/include/: bootloader_common.h bootloader_core.h
  group source/memory
    ../../../../../../middleware/mcu-boot/src/memory/: memory.h
  group source/memory/src
    ../../../../../../middleware/mcu-boot/src/memory/src/: sram_init.h memory.c normal_memory.h normal_memory.c pattern_fill.s pattern_fill.h sd_memory.c sd_memory.h mmc_memory.c mmc_memory.h semc_nand_memory.c semc_nand_memory.h flexspi_nor_memory.c flexspi_nor_memory.h spinand_memory.c spinand_memory.h spi_nor_eeprom_memory.c spi_nor_eeprom_memory.h
  group source/packet
    ../../../../../../middleware/mcu-boot/src/packet/: command_packet.h serial_packet.h
  group source/packet/src
    ../../../../../../middleware/mcu-boot/src/packet/src/: serial_packet.c
  group source/property
    ../../../../../../middleware/mcu-boot/src/property/: property.h
  group source/property/src
    ../../../../../../middleware/mcu-boot/src/property/src/: property_imx.c
  group source/sbloader
    ../../../../../../middleware/mcu-boot/src/sbloader/: sbloader.h sb_file_format.h
  group source/sbloader/src
    ../../../../../../middleware/mcu-boot/src/sbloader/src/: sbloader.c
  group source/utilities
    ../../../../../../middleware/mcu-boot/src/utilities/: fsl_rtos_abstraction.h fsl_assert.h vector_table_info.h
  group source/utilities/src
    ../../../../../../middleware/mcu-boot/src/utilities/src/: fsl_assert.c fsl_rtos_abstraction.c debug_util.c
  group source/drivers/puf
    ../../../../../../platform/drivers/puf/: fsl_puf.c fsl_puf.h
  group source/drivers/nand_ecc
    ../../../../../../middleware/mcu-boot/src/drivers/nand_ecc/: nand_ecc.c nand_ecc.h nand_ecc.c nand_ecc.h
  group source/drivers/semc
    ../../../../../../middleware/mcu-boot/src/drivers/semc/: bl_semc.c bl_semc.h bl_semc.c bl_semc.h
  group source/drivers/semc_nand
    ../../../../../../middleware/mcu-boot/src/drivers/semc_nand/: semc_nand_flash.c semc_nand_flash.h
  group source/drivers/microseconds
    ../../../../../../middleware/mcu-boot/src/drivers/microseconds/: microseconds.h
    ../../../../../../middleware/mcu-boot/src/drivers/microseconds/src/: microseconds_pit.c
  group source/drivers/flexspi
    ../../../../../../middleware/mcu-boot/src/drivers/flexspi/: bl_flexspi.c bl_flexspi.h bl_flexspi.c bl_flexspi.h
  group source/drivers/flexspi_nand
    ../../../../../../middleware/mcu-boot/src/drivers/flexspi_nand/: flexspi_nand_flash.c flexspi_nand_flash.h
  group source/drivers/ocotp
    ../../../../../../middleware/mcu-boot/src/drivers/ocotp/: bl_ocotp.c bl_ocotp.h
  group source/drivers/usdhc
    ../../../../../../middleware/mcu-boot/src/drivers/usdhc/: bl_usdhc.c bl_usdhc.h
  group source/drivers/sdmmc
    ../../../../../../middleware/mcu-boot/src/drivers/sdmmc/src/: fsl_mmc.c fsl_sd.c fsl_sdmmc_common.c
    ../../../../../../middleware/mcu-boot/src/drivers/sdmmc/inc/: fsl_mmc.h fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
    ../../../../../../middleware/mcu-boot/src/drivers/sdmmc/port/usdhc/polling/: fsl_sdmmc_host.c
  group source/drivers/flexspi_nor
    ../../../../../../middleware/mcu-boot/src/drivers/flexspi_nor/: flexspi_nor_flash.c flexspi_nor_flash.h
  group source/drivers/serial_nor_eeprom
    ../../../../../../middleware/mcu-boot/src/drivers/serial_nor_eeprom/: serial_nor_eeprom.c serial_nor_eeprom.h
  group source/security/keyblob
    ../../../../../../middleware/mcu-boot/src/security/keyblob/: keyblob.h
  group source/security/keyblob/src
    ../../../../../../middleware/mcu-boot/src/security/keyblob/src/: keyblob_caam.c keyblob.c
  group source/authentication
    ../../../../../../middleware/mcu-boot/src/authentication/: key_store_puf.c key_store_puf.h
  group MIMXRT1176
    ../../../../../../middleware/mcu-boot/targets/MIMXRT1176/src/: bl_lpuart_irq_config_MIMXRT1176.c bl_mpu.h bootloader_config.h clock_cfg_MIMXRT1176.c external_memory_property_map_MIMXRT1176.c flexspi_config_MIMXRT1176.c flexspi_nand_config_MIMXRT1176.c fusemap.h hardware_init_MIMXRT1176.c memory_config.h memory_map_MIMXRT1176.c periph_MIMXRT1176.c peripherals_pinmux.h sdmmc_config_MIMXRT1176.c sdmmc_convert_MIMXRT1176.c sdmmc_init.h security_config_MIMXRT1176.c semc_nand_config_MIMXRT1176.c target_config.h sram_init_MIMXRT1176.c
    ../../../../../../middleware/mcu-boot/targets/common/src/: pinmux_utility_imxrt_series.c
  group usb/device/include
    ../../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group usb/device/source
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h usb_device_dci.h
    ../: usb_device_ch9.c usb_device_ch9.h
  group usb/device/source/ehci
    ../../../../../../middleware/usb/device/: usb_device_ehci.c usb_device_ehci.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/hid
    ../: usb_device_hid.c usb_device_hid.h
  group usb/phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
