# Keil uVision project flashloader_cm4.uvprojx, settings and files
target flashloader_cm4 release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm4 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M4")
  output: flashloader_cm4.out
  AfterMake: fromelf.exe --output "$L$[project_name].srec" --m32combined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1176DVMAA_cm4, CPU_IS_ARM_CORTEX_M4=1, BL_TARGET_RAM, MIMXRT1176, USB_STACK_BM, SDK_OS_BAREMETAL
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -Wno-null-dereference  -Wno-unknown-attributes  -Wno-expansion-to-defined  -Wno-invalid-noreturn
  c include: ..;../../../../../../devices/MIMXRT1176;../../../../../../devices/MIMXRT1176/drivers;../../../../../../devices/MIMXRT1052;../../../../../../middleware/mcu_bootloader/src/bm_usb;../../../../../../middleware/mcu_bootloader/src/autobaud;../../../../../../middleware/mcu_bootloader/src/bootloader;../../../../../../middleware/mcu_bootloader/src/crc;../../../../../../middleware/mcu_bootloader/src/include;../../../../../../middleware/mcu_bootloader/src/memory;../../../../../../middleware/mcu_bootloader/src/memory/src;../../../../../../middleware/mcu_bootloader/src/startup;../../../../../../middleware/mcu_bootloader/src/packet;../../../../../../middleware/mcu_bootloader/src/property;../../../../../../middleware/mcu_bootloader/src/sbloader;../../../../../../middleware/mcu_bootloader/src/utilities;../../../../../../middleware/mcu_bootloader/targets/MIMXRT1176/src;../../../../../../middleware/mcu_bootloader/src;../../../../../../middleware/mcu_bootloader/src/authentication;../../../../../../middleware/mcu_bootloader/src/security/keyblob;../../../../../../middleware/mcu_bootloader/src/drivers;../../../../../../middleware/mcu_bootloader/src/drivers/flexspi_nor;../../../../../../middleware/mcu_bootloader/src/drivers/flexspi;../../../../../../middleware/mcu_bootloader/src/drivers/serial_nor_eeprom;../../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/inc;../../../../../../middleware/mcu_bootloader/src/drivers/semc;../../../../../../middleware/mcu_bootloader/src/drivers/nand_ecc;../../../../../../middleware/usb/device;../../../../../../middleware/usb/phy;../../../../../../components/lists;../../../../../../middleware/mcu_bootloader/src/drivers/semc_nand;../../../../../../middleware/mcu_bootloader/src/drivers/microseconds;../../../../../../middleware/mcu_bootloader/src/drivers/flexspi_nand;../../../../../../middleware/mcu_bootloader/src/drivers/ocotp;../../../../../../CMSIS/Core/Include;../../../../../../middleware/mcu_bootloader/src/drivers/usdhc;../../../../../../components/osa;../../../../../../middleware/usb/include
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=0
  asm include: ../../../../../../middleware/mcu_bootloader/src/startup
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176_ram_flashloader.scf
  link misc: --remove --datacompressor off --entry=Reset_Handler
  group board
    ../: pin_mux.c pin_mux.h
  group usb/device/class/hid
    ../: usb_device_hid.c usb_device_hid.h
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb/device/: usb_device_dci.h usb_device_ehci.c usb_device_ehci.h usb_device_dci.c usb_device_dci.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm4.h MIMXRT1176_cm4_features.h system_MIMXRT1176_cm4.h
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_clock.h fsl_clock.c fsl_pmu.h fsl_pmu.c fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_puf.h fsl_puf.c fsl_memory.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_anatop_ai.h fsl_anatop_ai.c fsl_lpspi.c fsl_lpspi.h
  group mcu_bootloader/device
    ../../../../../../middleware/mcu_bootloader/targets/MIMXRT1176/src/startup/: system_MIMXRT1176_cm4.c
  group startup
    ../../../../../../middleware/mcu_bootloader/targets/MIMXRT1176/src/startup/arm/: startup_MIMXRT1176_cm4.S
    ../../../../../../middleware/mcu_bootloader/src/startup/: ar_asm_macros.h startup.c
  group source/usb/bm_composite
    ../../../../../../middleware/mcu_bootloader/src/bm_usb/: bootloader_hid_report_ids.h fat_directory_entry.h composite.h composite.c hid_bootloader.h hid_bootloader.c usb_descriptor.h usb_descriptor.c
    ../../../../../../middleware/mcu_bootloader/targets/MIMXRT1176/src/: usb_device_config.h
  group source/autobaud
    ../../../../../../middleware/mcu_bootloader/src/autobaud/: autobaud.h
    ../../../../../../middleware/mcu_bootloader/src/autobaud/src/: autobaud_irq.c
  group source/bootloader
    ../../../../../../middleware/mcu_bootloader/src/bootloader/: bl_peripheral_interface.h bl_user_entry.h bl_version.h bootloader.h bl_command.h bl_context.h bl_peripheral.h bl_shutdown_cleanup.h bl_irq_common.h bl_app_crc_check.h bl_keyblob.h
  group source/bootloader/src
    ../../../../../../middleware/mcu_bootloader/src/bootloader/src/: bl_user_entry.c bl_main.c bl_context.c bl_exception_handler.c bl_tree_root.c bl_command.c bl_shutdown_cleanup.c bl_app_crc_check.c bl_misc.c lpuart_peripheral_interface.c usb_hid_msc_peripheral_interface.c
  group source/crc
    ../../../../../../middleware/mcu_bootloader/src/crc/: crc16.h crc32.h
    ../../../../../../middleware/mcu_bootloader/src/crc/src/: crc16.c crc32.c
  group source/include
    ../../../../../../middleware/mcu_bootloader/src/include/: bootloader_common.h bootloader_core.h
  group source/memory
    ../../../../../../middleware/mcu_bootloader/src/memory/: memory.h
  group source/memory/src
    ../../../../../../middleware/mcu_bootloader/src/memory/src/: sram_init.h memory.c normal_memory.h normal_memory.c pattern_fill_mdk.s pattern_fill.h sd_memory.c sd_memory.h mmc_memory.c mmc_memory.h semc_nand_memory.c semc_nand_memory.h flexspi_nor_memory.c flexspi_nor_memory.h spinand_memory.c spinand_memory.h spi_nor_eeprom_memory.c spi_nor_eeprom_memory.h
  group source/packet
    ../../../../../../middleware/mcu_bootloader/src/packet/: command_packet.h serial_packet.h
  group source/packet/src
    ../../../../../../middleware/mcu_bootloader/src/packet/src/: serial_packet.c
  group source/property
    ../../../../../../middleware/mcu_bootloader/src/property/: property.h
  group source/sbloader
    ../../../../../../middleware/mcu_bootloader/src/sbloader/: sbloader.h sb_file_format.h
  group source/sbloader/src
    ../../../../../../middleware/mcu_bootloader/src/sbloader/src/: sbloader.c
  group source/utilities
    ../../../../../../middleware/mcu_bootloader/src/utilities/: fsl_rtos_abstraction.h fsl_assert.h vector_table_info.h
  group source/utilities/src
    ../../../../../../middleware/mcu_bootloader/src/utilities/src/: fsl_assert.c fsl_rtos_abstraction.c debug_util.c
  group MIMXRT1176
    ../../../../../../middleware/mcu_bootloader/targets/MIMXRT1176/src/: bl_lpuart_irq_config_MIMXRT1176.c bl_mpu.h bootloader_config.h clock_cfg_MIMXRT1176.c external_memory_property_map_MIMXRT1176.c flexspi_config_MIMXRT1176.c flexspi_nand_config_MIMXRT1176.c flexspi_nor_config_MIMXRT1176.c fusemap.h hardware_init_MIMXRT1176.c memory_config.h memory_map_MIMXRT1176.c ocotp_MIMXRT1176.c periph_MIMXRT1176.c peripherals_pinmux.h sdmmc_config_MIMXRT1176.c sdmmc_convert_MIMXRT1176.c sdmmc_init.h security_config_MIMXRT1176.c semc_nand_config_MIMXRT1176.c target_config.h sram_init_MIMXRT1176.c
    ../../../../../../middleware/mcu_bootloader/targets/common/src/: pinmux_utility_imxrt_series.c
  group source/property/src
    ../../../../../../middleware/mcu_bootloader/src/property/src/: property_imx.c
  group source/security/keyblob/src
    ../../../../../../middleware/mcu_bootloader/src/security/keyblob/src/: keyblob_caam.c keyblob.c
  group source/security/keyblob
    ../../../../../../middleware/mcu_bootloader/src/security/keyblob/: keyblob.h
  group source/authentication
    ../../../../../../middleware/mcu_bootloader/src/authentication/: key_store_puf.c key_store_puf.h
  group source/drivers/nand_ecc
    ../../../../../../middleware/mcu_bootloader/src/drivers/nand_ecc/: nand_ecc.c nand_ecc.h nand_ecc.c nand_ecc.h
  group source/drivers/semc
    ../../../../../../middleware/mcu_bootloader/src/drivers/semc/: bl_semc.c bl_semc.h bl_semc.c bl_semc.h
  group usb/device/include
    ../../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group usb/phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group source/drivers/semc_nand
    ../../../../../../middleware/mcu_bootloader/src/drivers/semc_nand/: semc_nand_flash.c semc_nand_flash.h
  group source/drivers/microseconds
    ../../../../../../middleware/mcu_bootloader/src/drivers/microseconds/: microseconds.h
    ../../../../../../middleware/mcu_bootloader/src/drivers/microseconds/src/: microseconds_pit.c
  group source/drivers/flexspi
    ../../../../../../middleware/mcu_bootloader/src/drivers/flexspi/: bl_flexspi.c bl_flexspi.h bl_flexspi.c bl_flexspi.h
  group source/drivers/flexspi_nand
    ../../../../../../middleware/mcu_bootloader/src/drivers/flexspi_nand/: flexspi_nand_flash.c flexspi_nand_flash.h
  group source/drivers/ocotp
    ../../../../../../middleware/mcu_bootloader/src/drivers/ocotp/: bl_ocotp.c bl_ocotp.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm4.h mpu_armv7.h
  group source/drivers/usdhc
    ../../../../../../middleware/mcu_bootloader/src/drivers/usdhc/: bl_usdhc.c bl_usdhc.h
  group source/drivers/sdmmc
    ../../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/src/: fsl_mmc.c fsl_sd.c fsl_sdmmc_common.c
    ../../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/inc/: fsl_mmc.h fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
    ../../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/port/usdhc/polling/: fsl_sdmmc_host.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group source/drivers/flexspi_nor
    ../../../../../../middleware/mcu_bootloader/src/drivers/flexspi_nor/: flexspi_nor_flash.c flexspi_nor_flash.h
  group source/drivers/serial_nor_eeprom
    ../../../../../../middleware/mcu_bootloader/src/drivers/serial_nor_eeprom/: serial_nor_eeprom.c serial_nor_eeprom.h
