# IAR project cmsis_enet_txrx_transfer_cm7.ewp, settings and files
configuration sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; DEBUG; CPU_MIMXRT1176DVMAA_cm7; PHY_STABILITY_DELAY_US=500000U; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../../components/phy/device/phyrtl8211f; ../../../../../../../devices/MIMXRT1176/utilities/str; ../../../../../../../devices/MIMXRT1176/utilities/debug_console_lite; ../../../../../../../components/silicon_id/socs; ../../../../../../../components/silicon_id; ../../../../../../../devices/MIMXRT1176/drivers; ../../../../../../../devices/MIMXRT1176/cmsis_drivers; ../../../../../../../devices/MIMXRT1176; ../../../../../../../components/uart; ../../../../../../../components/lists; ../../../../../../../devices/MIMXRT1176/xip; ../../../../../xip; ../../../../../../../devices/MIMXRT1176/drivers/cm7; ../../../../../xmcd; ../../../../../../../components/phy; ../../../../../../../CMSIS/Driver/Include; ../../../../../../../devices/MIMXRT1176/template; ../../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: cmsis_enet_txrx_transfer_cm7.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x1000
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=0; XIP_BOOT_HEADER_XMCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; PHY_STABILITY_DELAY_US=500000U; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; PHY_STABILITY_DELAY_US=500000U; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=0; XIP_BOOT_HEADER_XMCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; PHY_STABILITY_DELAY_US=500000U; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
  group source
    ../: cmsis_enet_txrx_transfer.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
    ../../../../../xmcd/: xmcd.c xmcd.h
  group doc
    ../: readme.txt
  group evkmimxrt1170
    ../: evkmimxrt1170_connect_cm4_cm7side.jlinkscript
  group component/phy
    ../../../../../../../components/phy/device/phyrtl8211f/: fsl_phyrtl8211f.h fsl_phyrtl8211f.c
    ../../../../../../../components/phy/: fsl_phy.h
  group component/silicon_id
    ../../../../../../../components/silicon_id/socs/imxrt1170/: fsl_silicon_id_soc.c
    ../../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
    ../../../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group utilities
    ../../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../../devices/MIMXRT1176/drivers/: fsl_clock.h fsl_clock.c fsl_enet.h fsl_enet.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_anatop_ai.h fsl_anatop_ai.c fsl_memory.h fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c
    ../../../../../../../devices/MIMXRT1176/cmsis_drivers/: fsl_enet_cmsis.h fsl_enet_cmsis.c fsl_enet_phy_cmsis.c fsl_enet_phy_cmsis.h
    ../../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group device
    ../../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group startup
    ../../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group xip
    ../../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
  group CMSIS_driver/Include
    ../../../../../../../CMSIS/Driver/Include/: Driver_ETH.h Driver_Common.h Driver_ETH_MAC.h Driver_ETH.h Driver_ETH_PHY.h Driver_Common.h Driver_Common.h Driver_ETH.h Driver_ETH_MAC.h Driver_ETH_PHY.h
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
