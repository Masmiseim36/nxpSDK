# Keil uVision project mc_pmsm.uvprojx, settings and files
target mc_pmsm debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: mc_pmsm.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT1176DVMAA_cm7, USB_STACK_BM, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../../devices/MIMXRT1176/drivers;../../../../../../../middleware/rtcesl/CM7F_RTCESL_4.7_KEIL/AMCLIB/Include;../../../../../../../middleware/rtcesl/CM7F_RTCESL_4.7_KEIL/GDFLIB/Include;../../../../../../../middleware/rtcesl/CM7F_RTCESL_4.7_KEIL/GFLIB/Include;../../../../../../../middleware/rtcesl/CM7F_RTCESL_4.7_KEIL/GMCLIB/Include;../../../../../../../middleware/rtcesl/CM7F_RTCESL_4.7_KEIL/MLIB/Include;../../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_drivers;../../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_algorithms/mcaa_lib/cm7f_mdk/Include;../../../../../../../middleware/motor_control/freemaster/pmsm_float/mcat;../../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_identification;../../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_algorithms;../../../../../../../middleware/motor_control/pmsm/pmsm_float/state_machine;../../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_state_machine;../../../../../../../middleware/motor_control/pmsm/pmsm_float;../../../../../../../devices/MIMXRT1176;../../../../../../../components/uart;../../../../../../../components/lists;../../../../../../../devices/MIMXRT1176/xip;../../../../../xip;../../../../../../../middleware/freemaster/src/common;../../../../../../../middleware/freemaster/src/platforms/gen32le;../../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can;../../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial;../../../../../../../devices/MIMXRT1176/utilities/debug_console_lite;../../../../../../../CMSIS/Core/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_ram.scf
  link misc: ../../../../../../../middleware/rtcesl/CM7F_RTCESL_4.7_KEIL/AMCLIB/AMCLIB.lib ../../../../../../../middleware/rtcesl/CM7F_RTCESL_4.7_KEIL/GFLIB/GFLIB.lib ../../../../../../../middleware/rtcesl/CM7F_RTCESL_4.7_KEIL/GDFLIB/GDFLIB.lib ../../../../../../../middleware/rtcesl/CM7F_RTCESL_4.7_KEIL/GMCLIB/GMCLIB.lib ../../../../../../../middleware/rtcesl/CM7F_RTCESL_4.7_KEIL/MLIB/MLIB.lib ../../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_algorithms/mcaa_lib/cm7f_mdk/mcaa_lib.lib --remove --entry=Reset_Handler
  group motor_control/freemaster
    ../../../../../../../middleware/motor_control/freemaster/: pmsm_float_enc.pmp
  group source
    ../: main.c m1_pmsm_appconfig.h mc_periph_init.c char_pwrstg.h freemaster_cfg.h mc_periph_init.h
  group board
    ../: pin_mux.c pin_mux.h clock_config.h clock_config.c peripherals.h peripherals.c board.c board.h dcd.c dcd.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MIMXRT1176/drivers/: fsl_dmamux.h fsl_dmamux.c fsl_xbara.h fsl_xbara.c fsl_clock.h fsl_clock.c fsl_adc_etc.c fsl_adc_etc.h fsl_lpadc.c fsl_lpadc.h fsl_acmp.c fsl_acmp.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_anatop_ai.h fsl_anatop_ai.c
  group rtcesl/CM7F_RTCESL_4.7_KEIL/AMCLIB/Include
    ../../../../../../../middleware/rtcesl/CM7F_RTCESL_4.7_KEIL/AMCLIB/Include/: amclib.h AMCLIB_ACIMCtrlMTPA_FLT.h AMCLIB_ACIMRotFluxObsrv_FLT.h AMCLIB_ACIMSpeedMRAS_FLT.h AMCLIB_AngleTrackObsrv_F32.h AMCLIB_AngleTrackObsrv_FLT.h AMCLIB_CtrlFluxWkng_A32.h AMCLIB_CtrlFluxWkng_FLT.h amclib_FP.h AMCLIB_PMSMBemfObsrvAB_A32.h AMCLIB_PMSMBemfObsrvAB_FLT.h AMCLIB_PMSMBemfObsrvDQ_A32.h AMCLIB_PMSMBemfObsrvDQ_FLT.h AMCLIB_TrackObsrv_F32.h AMCLIB_TrackObsrv_FLT.h amclib_types.h
  group rtcesl/CM7F_RTCESL_4.7_KEIL/GDFLIB/Include
    ../../../../../../../middleware/rtcesl/CM7F_RTCESL_4.7_KEIL/GDFLIB/Include/: gdflib.h GDFLIB_FilterExp_F32.h GDFLIB_FilterExp_FLT.h GDFLIB_FilterIIR1_F32.h GDFLIB_FilterIIR1_F32_Asmi.h GDFLIB_FilterIIR1_FLT.h GDFLIB_FilterIIR2_F32.h GDFLIB_FilterIIR2_FLT.h GDFLIB_FilterIIR3_F32.h GDFLIB_FilterIIR3_FLT.h GDFLIB_FilterIIR4_F32.h GDFLIB_FilterIIR4_FLT.h GDFLIB_FilterMA_A32.h GDFLIB_FilterMA_FLT.h gdflib_FP.h gdflib_types.h
  group rtcesl/CM7F_RTCESL_4.7_KEIL/GFLIB/Include
    ../../../../../../../middleware/rtcesl/CM7F_RTCESL_4.7_KEIL/GFLIB/Include/: gflib.h GFLIB_Acos_F16.h GFLIB_Acos_FLT.h GFLIB_Asin_F16.h GFLIB_Asin_FLT.h GFLIB_Atan_F32.h GFLIB_Atan_FLT.h GFLIB_AtanYX_F16.h GFLIB_AtanYX_FLT.h GFLIB_CtrlBetaIPDp_A32.h GFLIB_CtrlBetaIPDp_FLT.h GFLIB_CtrlBetaIPp_A32.h GFLIB_CtrlBetaIPp_FLT.h GFLIB_CtrlPIDp_A32.h GFLIB_CtrlPIDp_FLT.h GFLIB_CtrlPIp_A32.h GFLIB_CtrlPIp_FLT.h GFLIB_DFlexRamp_A32.h GFLIB_DFlexRamp_FLT.h GFLIB_DRamp_F16.h GFLIB_DRamp_F32.h GFLIB_DRamp_FLT.h GFLIB_FlexRamp_A32.h GFLIB_FlexRamp_FLT.h GFLIB_FlexSRamp_A32.h GFLIB_FlexSRamp_FLT.h gflib_FP.h GFLIB_Hyst_F16_Asmi.h GFLIB_Hyst_FLT.h GFLIB_Integrator_A32.h GFLIB_Integrator_FLT.h GFLIB_Limit_F16.h GFLIB_Limit_F32.h GFLIB_Limit_FLT.h GFLIB_LowerLimit_F16.h GFLIB_LowerLimit_F32.h GFLIB_LowerLimit_FLT.h GFLIB_Lut_F16_Asmi.h GFLIB_Lut_F32.h GFLIB_Lut_FLT.h GFLIB_LutPer_F16_Asmi.h GFLIB_LutPer_F32.h GFLIB_LutPer_FLT.h GFLIB_Ramp_F16.h GFLIB_Ramp_F32.h GFLIB_Ramp_FLT.h GFLIB_SinCos_F32.h GFLIB_SinCos_FLT.h GFLIB_Sqrt_F16.h GFLIB_Sqrt_F32.h GFLIB_Sqrt_FLT_Asmi.h GFLIB_Tan_F32.h GFLIB_Tan_FLT.h gflib_types.h GFLIB_UpperLimit_F16.h GFLIB_UpperLimit_F32.h GFLIB_UpperLimit_FLT.h GFLIB_VectorLimit_F16.h GFLIB_VectorLimit_FLT.h
  group rtcesl/CM7F_RTCESL_4.7_KEIL/GMCLIB/Include
    ../../../../../../../middleware/rtcesl/CM7F_RTCESL_4.7_KEIL/GMCLIB/Include/: gmclib.h GMCLIB_Clark_F16_Asmi.h GMCLIB_Clark_FLT.h GMCLIB_Decoupling_A32.h GMCLIB_DTCompLut1D_F16.h GMCLIB_Decoupling_FLT.h GMCLIB_ElimDcBusRip_A32_Asmi.h GMCLIB_ElimDcBusRip_F16_Asmi.h GMCLIB_ElimDcBusRip_FLT.h gmclib_FP.h GMCLIB_Park_F16_Asmi.h GMCLIB_Park_FLT.h GMCLIB_Svm_F16.h gmclib_types.h
  group rtcesl/CM7F_RTCESL_4.7_KEIL/MLIB/Include
    ../../../../../../../middleware/rtcesl/CM7F_RTCESL_4.7_KEIL/MLIB/Include/: asm_mac.h mlib.h MLIB_Abs_F16.h MLIB_Abs_F16_Asmi.h MLIB_Abs_F32.h MLIB_Abs_F32_Asmi.h MLIB_Abs_FLT.h MLIB_Abs_FLT_Asmi.h MLIB_Add_A32.h MLIB_Add_F16.h MLIB_Add_F16_Asmi.h MLIB_Add_F32.h MLIB_Add_F32_Asmi.h MLIB_Add_FLT.h MLIB_Add4_F16_Asmi.h MLIB_Add4_F32_Asmi.h MLIB_Add4_FLT.h MLIB_BiShift_F16.h MLIB_BiShift_F32.h MLIB_Clb_F16.h MLIB_Clb_F32.h MLIB_Conv_F32.h MLIB_Conv_FLT_Asmi.h MLIB_ConvSc_FLT_Asmi.h MLIB_Div_A32.h MLIB_Div_F16.h MLIB_Div_F32.h MLIB_Div_FLT.h MLIB_Div1Q_A32.h MLIB_Div1Q_F16.h MLIB_Div1Q_F32.h mlib_FP.h MLIB_Log2_U16.h MLIB_Mac_A32.h MLIB_Mac_F16_Asmi.h MLIB_Mac_F32.h MLIB_Mac_F32_Asmi.h MLIB_Mac_FLT.h MLIB_Mac4_F32.h MLIB_Mac4_F32_Asmi.h MLIB_Mac4_FLT.h MLIB_Mac4Rnd_F16_Asmi.h MLIB_Mac4Rnd_F32.h MLIB_Mac4Rnd_F32_Asmi.h MLIB_MacRnd_A32.h MLIB_MacRnd_F16_Asmi.h MLIB_MacRnd_F32.h MLIB_MacRnd_F32_Asmi.h MLIB_Mnac_A32.h MLIB_Mnac_F16_Asmi.h MLIB_Mnac_F32.h MLIB_Mnac_F32_Asmi.h MLIB_Mnac_FLT.h MLIB_MnacRnd_A32.h MLIB_MnacRnd_F16_Asmi.h MLIB_MnacRnd_F32.h MLIB_MnacRnd_F32_Asmi.h MLIB_Msu_A32.h MLIB_Msu_F16_Asmi.h MLIB_Msu_F32_Asmi.h MLIB_Msu_FLT.h MLIB_Msu4_F32.h MLIB_Msu4_F32_Asmi.h MLIB_Msu4_FLT.h MLIB_Msu4Rnd_F16.h MLIB_Msu4Rnd_F16_Asmi.h MLIB_Msu4Rnd_F32.h MLIB_Msu4Rnd_F32_Asmi.h MLIB_MsuRnd_A32.h MLIB_MsuRnd_F16_Asmi.h MLIB_MsuRnd_F32.h MLIB_MsuRnd_F32_Asmi.h MLIB_Mul_A32.h MLIB_Mul_A32_Asmi.h MLIB_Mul_F16.h MLIB_Mul_F16_Asmi.h MLIB_Mul_F32.h MLIB_Mul_F32_Asmi.h MLIB_Mul_FLT.h MLIB_MulRnd_A32.h MLIB_MulRnd_A32_Asmi.h MLIB_MulRnd_F16.h MLIB_MulRnd_F16_Asmi.h MLIB_MulRnd_F32.h MLIB_MulRnd_F32_Asmi.h MLIB_Neg_F16.h MLIB_Neg_F16_Asmi.h MLIB_Neg_F32.h MLIB_Neg_F32_Asmi.h MLIB_Neg_FLT.h MLIB_Rcp_A32.h MLIB_Rcp1Q_A32.h MLIB_Rnd_F32.h MLIB_Rnd_F32_Asmi.h MLIB_Sat_A32_Asmi.h MLIB_Shift_F16.h MLIB_Shift_F16_Asmi.h MLIB_Shift_F32.h MLIB_Shift_F32_Asmi.h MLIB_Sign_F16_Asmi.h MLIB_Sign_F32_Asmi.h MLIB_Sign_FLT_Asmi.h MLIB_Sub_A32.h MLIB_Sub_F16.h MLIB_Sub_F16_Asmi.h MLIB_Sub_F32.h MLIB_Sub_F32_Asmi.h MLIB_Sub_F64.h MLIB_Sub_FLT.h MLIB_Sub4_F16_Asmi.h MLIB_Sub4_F32_Asmi.h MLIB_Sub4_FLT.h mlib_types.h RTCESL_cfg.h
  group motor_control/pmsm/pmsm_float/mc_drivers
    ../../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_drivers/: mcdrv_adc_imxrt117x.h mcdrv_adc_imxrt117x.c mcdrv_pwm3ph_pwma.c mcdrv_pwm3ph_pwma.h mcdrv_enc_qd.c mcdrv_enc_qd.h
  group motor_control/pmsm/pmsm_float/mc_algorithms/mcaa_lib/cm7f_mdk/Include
    ../../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_algorithms/mcaa_lib/cm7f_mdk/Include/: mcaa_estimrl.h mcaa_lib.h
  group motor_control/freemaster/pmsm_float/fm_control
    ../../../../../../../middleware/motor_control/freemaster/pmsm_float/fm_control/: control_page_config.js control_page_scripts.js FM_control_M1.html jquery-1.11.1.min.js jqxbuttons.js jqxcore.js jqxdraw.js jqxgauge.js jqxlistmenu.js jqxmenu.js jqxnotification.js jqxpanel.js jqxradiobutton.js jqxscrollbar.js jqxslider.js jqxswitchbutton.js jqxtooltip.js jqxwindow.js logo.png
  group motor_control/freemaster/pmsm_float/fm_control/styles/images
    ../../../../../../../middleware/motor_control/freemaster/pmsm_float/fm_control/styles/images/: backgroundTop.png backImage.png bg_black.png bg_black_horizontal.png bg_blackhover.png bg_blackhover_horizontal.png bg_blackpressed.png bg_blackpressed_horizontal.png bg_blueenergy.png bg_darkblue.png bg_darkbluehover.png bg_darkbluepressed.png black_gradient.png blackbackground.png check_black.png check_blue.png check_blue_indeterminate.png check_disabled.png check_indeterminate_black.png check_indeterminate_disabled.png check_indeterminate_white.png check_lightblue.png check_lightblue_indeterminate.png check_white.png close.png close_black.png close_blue.png close_white.png crosshair.png crosshair-white.png darkred_gradient.png drag.png dragcancel.png error.png filter.png html_editor.png html_editor_white.png icon-calendar.png icon-calendar-white.png icon-cancel.png icon-cancel-white.png icon-delete.png icon-delete-white.png icon-down.png icon-down-blue.png icon-down-transparent.png icon-down-white.png icon-edit.png icon-edit-white.png icon-first.png icon-first-blue.png icon-first-transparent.png icon-first-white.png icon-last.png icon-last-blue.png icon-last-transparent.png icon-last-white.png icon-left.png icon-left-blue.png icon-left-transparent.png icon-left-white.png icon-menu-minimized.png icon-menu-minimized-white.png icon-right.png icon-right-blue.png icon-right-transparent.png icon-right-white.png icon-save.png icon-save-white.png icon-showpassword.png icon-showpassword-white.png icon-up.png icon-up-blue.png icon-up-transparent.png icon-up-white.png info.png loader.gif loader-small.gif mail.png menubutton.png metro-icon-down.png metro-icon-down-white.png metro-icon-first.png metro-icon-first-white.png metro-icon-last.png metro-icon-last-white.png metro-icon-left.png metro-icon-left-white.png metro-icon-right.png metro-icon-right - Copy.png metro-icon-right-white.png metro-icon-up.png metro-icon-up-white.png multi-arrow.gif office-icon-down.png office-icon-first.png office-icon-last.png office-icon-left.png office-icon-right.png office-icon-up.png plus.png plus_white.png pointer.png rangebar_classic.png rangebar_darkblue.png rangebar_shinyblack.png rangebar_summer.png red_arrow_down.png red_arrow_up.png red_gradient.png roundbg_check_black.png roundbg_check_disabled.png roundbg_check_indeterminate.png roundbg_check_white.png roundbg_classic_hover.png roundbg_classic_normal.png roundbg_disabled.png search.png search_white.png sortasc.png sortascbutton.png sortdesc.png sortdescbutton.png sortremove.png star.png star_disabled.png star_hover.png success.png tick.png time.png track_classic.png track_darkblue.png track_shinyblack.png track_summer.png warning.png wp_check_indeterminate_white.png wp_check_white.png
  group motor_control/freemaster/pmsm_float/fm_control/styles
    ../../../../../../../middleware/motor_control/freemaster/pmsm_float/fm_control/styles/: jqx.energyblue jqx.base.css jqx.energyblue.css jqx.energyblue.txt
  group motor_control/freemaster/pmsm_float/mcat/assets
    ../../../../../../../middleware/motor_control/freemaster/pmsm_float/mcat/assets/: NXP_logo_RGB_web.jpg nxp-logo-small-121x52.png speedfocwolswbemf.gif
  group motor_control/freemaster/pmsm_float/mcat/css
    ../../../../../../../middleware/motor_control/freemaster/pmsm_float/mcat/css/: app.css
  group motor_control/freemaster/pmsm_float/mcat/js
    ../../../../../../../middleware/motor_control/freemaster/pmsm_float/mcat/js/: chunk.js chunk.js.map mcat.js mcat.js.map
  group motor_control/freemaster/pmsm_float/mcat/license
    ../../../../../../../middleware/motor_control/freemaster/pmsm_float/mcat/license/: LA_OPT_NXP_Software_License.txt SW-Content-Register.txt
  group motor_control/freemaster/pmsm_float/mcat
    ../../../../../../../middleware/motor_control/freemaster/pmsm_float/mcat/: freemaster-client.js index.html init.js simple-jsonrpc-js.js m1_pmsm_appconfig.h
  group motor_control/freemaster/pmsm_float/mcat/bootstrap-5.1.1-dist/css
    ../../../../../../../middleware/motor_control/freemaster/pmsm_float/mcat/bootstrap-5.1.1-dist/css/: bootstrap.css bootstrap.css.map bootstrap.min.css bootstrap.min.css.map bootstrap.rtl.css bootstrap.rtl.css.map bootstrap.rtl.min.css bootstrap.rtl.min.css.map bootstrap-grid.css bootstrap-grid.css.map bootstrap-grid.min.css bootstrap-grid.min.css.map bootstrap-grid.rtl.css bootstrap-grid.rtl.css.map bootstrap-grid.rtl.min.css bootstrap-grid.rtl.min.css.map bootstrap-reboot.css bootstrap-reboot.css.map bootstrap-reboot.min.css bootstrap-reboot.min.css.map bootstrap-reboot.rtl.css bootstrap-reboot.rtl.css.map bootstrap-reboot.rtl.min.css bootstrap-reboot.rtl.min.css.map bootstrap-utilities.css bootstrap-utilities.css.map bootstrap-utilities.min.css bootstrap-utilities.min.css.map bootstrap-utilities.rtl.css bootstrap-utilities.rtl.css.map bootstrap-utilities.rtl.min.css bootstrap-utilities.rtl.min.css.map
  group motor_control/freemaster/pmsm_float/mcat/bootstrap-5.1.1-dist/js
    ../../../../../../../middleware/motor_control/freemaster/pmsm_float/mcat/bootstrap-5.1.1-dist/js/: bootstrap.js bootstrap.bundle.js bootstrap.bundle.js.map bootstrap.bundle.min.js bootstrap.bundle.min.js.map bootstrap.esm.js bootstrap.esm.js.map bootstrap.esm.min.js bootstrap.esm.min.js.map bootstrap.js.map bootstrap.min.js bootstrap.min.js.map
  group motor_control/freemaster/pmsm_float
    ../../../../../../../middleware/motor_control/freemaster/pmsm_float/: readme.txt
  group motor_control/pmsm/pmsm_float/mc_identification
    ../../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_identification/: hall_calib.c hall_calib.h ke_measure.c ke_measure.h mech_measure.c mech_measure.h mid_auxiliary.c mid_auxiliary.h mid_def.h mid_mc_api_connector.c mid_mc_api_connector.h mid_sm_states.c mid_sm_states.h pp_measure.c pp_measure.h
  group motor_control/pmsm/pmsm_float/mc_algorithms
    ../../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_algorithms/: pmsm_control.c pmsm_control.h
  group motor_control/pmsm/pmsm_float/state_machine
    ../../../../../../../middleware/motor_control/pmsm/pmsm_float/state_machine/: state_machine.c state_machine.h
  group motor_control/pmsm/pmsm_float/mc_state_machine
    ../../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_state_machine/: m1_sm_snsless_enc.c m1_sm_snsless_enc.h sm_common_enc.h
  group motor_control/pmsm/pmsm_float
    ../../../../../../../middleware/motor_control/pmsm/pmsm_float/: fm_tsa_pmsm.h fm_tsa_pmsm.c
  group device
    ../../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../../devices/MIMXRT1176/arm/: startup_MIMXRT1176_cm7.S
  group xip
    ../../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
  group freemaster
    ../../../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_defcfg.h freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h freemaster_can.c freemaster_can.h freemaster_sha.c freemaster_pdbdm.c freemaster_serial.c freemaster_serial.h freemaster_net.c freemaster_net.h
  group freemaster/platforms
    ../../../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group freemaster/drivers
    ../../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mscan.c freemaster_mscan.h freemaster_mcan.c freemaster_mcan.h
    ../../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_usb.c freemaster_serial_usb.h
    ../../../../../../../middleware/freemaster/src/drivers/mcuxsdk/network/: freemaster_net_segger_rtt.c freemaster_net_segger_rtt.h freemaster_net_lwip_udp.c freemaster_net_lwip_udp.h freemaster_net_lwip_tcp.c freemaster_net_lwip_tcp.h
  group utilities
    ../../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
target mc_pmsm flexspi_nor_sdram_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: mc_pmsm.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, DEBUG, CPU_MIMXRT1176DVMAA_cm7, USB_STACK_BM, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.scf
  link misc: ../../../../../../../middleware/rtcesl/CM7F_RTCESL_4.7_KEIL/AMCLIB/AMCLIB.lib ../../../../../../../middleware/rtcesl/CM7F_RTCESL_4.7_KEIL/GFLIB/GFLIB.lib ../../../../../../../middleware/rtcesl/CM7F_RTCESL_4.7_KEIL/GDFLIB/GDFLIB.lib ../../../../../../../middleware/rtcesl/CM7F_RTCESL_4.7_KEIL/GMCLIB/GMCLIB.lib ../../../../../../../middleware/rtcesl/CM7F_RTCESL_4.7_KEIL/MLIB/MLIB.lib ../../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_algorithms/mcaa_lib/cm7f_mdk/mcaa_lib.lib --remove --entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
target mc_pmsm flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: mc_pmsm.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1176DVMAA_cm7, USB_STACK_BM, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor.scf
  link misc: as above
target mc_pmsm sdram_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: mc_pmsm.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, DEBUG, CPU_MIMXRT1176DVMAA_cm7, USB_STACK_BM, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_sdram.scf
  link misc: as above
target mc_pmsm release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: mc_pmsm.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1176DVMAA_cm7, USB_STACK_BM, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_ram.scf
  link misc: as above
target mc_pmsm flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: mc_pmsm.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, CPU_MIMXRT1176DVMAA_cm7, USB_STACK_BM, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.scf
  link misc: as above
target mc_pmsm flexspi_nor_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: mc_pmsm.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1176DVMAA_cm7, USB_STACK_BM, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor.scf
  link misc: as above
target mc_pmsm sdram_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: mc_pmsm.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, CPU_MIMXRT1176DVMAA_cm7, USB_STACK_BM, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_sdram.scf
  link misc: as above
