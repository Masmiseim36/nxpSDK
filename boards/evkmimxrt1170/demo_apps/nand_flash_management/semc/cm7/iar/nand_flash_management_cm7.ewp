# IAR project nand_flash_management_cm7.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; PRINTF_FLOAT_ENABLE=1; CACHE_MAINTAIN=1; CPU_MIMXRT1176DVMAA_cm7; MCUXPRESSO_SDK; DEBUG_CONSOLE_RX_ENABLE=0; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../..; ..; ../../../../../../../components/flash/nand/semc; ../../../../../../../middleware/dhara/dhara; ../../../../../../../middleware/dhara/ecc; ../../../../../../../middleware/fatfs/source/fsl_nand_disk; ../../../../../../../middleware/fatfs/source; ../../../../../../../devices/MIMXRT1176/utilities/shell; ../../../../../../../devices/MIMXRT1176/drivers; ../../../../../../../devices/MIMXRT1176; ../../../../../../../devices/MIMXRT1176/utilities/debug_console; ../../../../../../../components/uart; ../../../../../../../components/serial_manager; ../../../../../../../components/lists; ../../../../../../../devices/MIMXRT1176/utilities; ../../../../../../../devices/MIMXRT1176/xip; ../../../../../xip; ../../../../../../../devices/MIMXRT1176/drivers/cm7; ../../../../../../../components/flash/nand; ../../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F; ../../../../../../../devices/MIMXRT1176/utilities/str; ../../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../../../../../../../rtos/freertos/freertos-kernel/include
  ILINK.IlinkOutputFile: nand_flash_management_cm7.out
  ILINK.IlinkConfigDefines: __stack_size__=0x4000; __heap_size__=0x4000
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; PRINTF_FLOAT_ENABLE=1; CACHE_MAINTAIN=1; CPU_MIMXRT1176DVMAA_cm7; MCUXPRESSO_SDK; DEBUG_CONSOLE_RX_ENABLE=0; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; PRINTF_FLOAT_ENABLE=1; CACHE_MAINTAIN=1; CPU_MIMXRT1176DVMAA_cm7; MCUXPRESSO_SDK; DEBUG_CONSOLE_RX_ENABLE=0; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; PRINTF_FLOAT_ENABLE=1; CACHE_MAINTAIN=1; CPU_MIMXRT1176DVMAA_cm7; MCUXPRESSO_SDK; DEBUG_CONSOLE_RX_ENABLE=0; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
  group source
    ../: nand_flash_management.c dhara_nand_device.c dhara_nand_config.h ffconf.h FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.md
  group evkmimxrt1170
    ../: evkmimxrt1170_connect_cm4_cm7side.jlinkscript
  group nand_flash
    ../../../../../../../components/flash/nand/semc/: fsl_semc_nand_flash.c fsl_semc_nand_flash.h
    ../../../../../../../components/flash/nand/: fsl_nand_flash.h
  group dhara/src
    ../../../../../../../middleware/dhara/dhara/: map.c journal.c error.c
    ../../../../../../../middleware/dhara/ecc/: hamming.c
  group dhara/inc
    ../../../../../../../middleware/dhara/dhara/: map.h journal.h error.h bytes.h nand.h
    ../../../../../../../middleware/dhara/ecc/: hamming.h
  group freertos/freertos-kernel
    ../../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/portable
    ../../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos-kernel/portable/IAR/ARM_CM4F
    ../../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos-kernel/include
    ../../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group fatfs/source
    ../../../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_nand_disk
    ../../../../../../../middleware/fatfs/source/fsl_nand_disk/: fsl_nand_disk.c fsl_nand_disk.h
  group utilities
    ../../../../../../../devices/MIMXRT1176/utilities/shell/: fsl_shell.c fsl_shell.h
    ../../../../../../../devices/MIMXRT1176/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/MIMXRT1176/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
  group drivers
    ../../../../../../../devices/MIMXRT1176/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_gpc.h fsl_gpc.c fsl_soc_src.h fsl_soc_src.c fsl_mu.h fsl_mu.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_semc.h fsl_semc.c fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group device
    ../../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group xip
    ../../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
