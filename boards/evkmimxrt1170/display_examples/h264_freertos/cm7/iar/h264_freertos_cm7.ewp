# IAR project h264_freertos_cm7.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_SDRAM; XIP_BOOT_HEADER_DCD_ENABLE=1; DATA_SECTION_IS_CACHEABLE=1; DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1176DVMAA_cm7; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; SD_ENABLED; SDK_OS_FREE_RTOS; __NXP_MSDK__
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.IExtraOptions: --diag_suppress Pe815,Pe111,Pe186,Pe068,Pe177
  ICCARM.CCIncludePath2: ..; ../freertos_libraries/abstractions/posix/include; ../freertos_libraries/freertos_plus/standard/freertos_plus_posix/include; ../freertos_libraries/c_sdk/standard/common/include/private; ../../../../../../components/video; ../../../../../../components/video/display; ../../../../../../components/video/display/rm68191; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../components/video/display/mipi_dsi_cmd; ../../../../../../components/video/display/rm68200; ../../../../../../components/video/display/dc/lcdifv2; ../../../../../../components/gt911; ../../../../../../components/video/display/dc/elcdif; ../../../../../../middleware/sdmmc/host/usdhc; ../../../../../../middleware/sdmmc/sd; ../../../../../../devices/MIMXRT1176/utilities/str; ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite; ../../../../../../components/video/display/hx8394; ../../../../../../components/gpio; ../../../../../../middleware/fatfs/source/fsl_sd_disk; ../../../../../../middleware/fatfs/source; ../../../../../../components/video/display/fbdev; ../../../../../../middleware/openh264/codec/decoder/core/inc; ../../../../../../middleware/openh264/codec/decoder/plus/inc; ../../../../../../devices/MIMXRT1176; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1176/xip; ../../../../xip; ../../../../../../devices/MIMXRT1176/drivers/cm7; ../../../../../../components/video/display/dc; ../../../../../../middleware/sdmmc/common; ../../../../../../middleware/sdmmc/osa; ../../../../../../components/osa; ../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F; ../../../../../../middleware/openh264/codec/api/svc; ../../../../../../middleware/openh264/codec/common/inc; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: h264_freertos_cm7.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x1800000
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_SDRAM; XIP_BOOT_HEADER_DCD_ENABLE=1; DATA_SECTION_IS_CACHEABLE=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; SD_ENABLED; SDK_OS_FREE_RTOS; __NXP_MSDK__
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: h264_freertos.c ffconf.h FreeRTOS_POSIX_portable.h display.c display.h h264_dec.h h264_dec.cpp sdcard.c sdcard.h FreeRTOSConfig.h
  group source/freertos_libraries/abstractions/posix/include/FreeRTOS_POSIX
    ../freertos_libraries/abstractions/posix/include/FreeRTOS_POSIX/: errno.h fcntl.h mqueue.h pthread.h sched.h semaphore.h signal.h time.h unistd.h utils.h
  group source/freertos_libraries/abstractions/posix/include/FreeRTOS_POSIX/sys
    ../freertos_libraries/abstractions/posix/include/FreeRTOS_POSIX/sys/: types.h
  group source/freertos_libraries/freertos_plus/standard/freertos_plus_posix/include
    ../freertos_libraries/freertos_plus/standard/freertos_plus_posix/include/: FreeRTOS_POSIX.h FreeRTOS_POSIX_internal.h FreeRTOS_POSIX_portable_default.h FreeRTOS_POSIX_types.h
  group source/freertos_libraries/freertos_plus/standard/freertos_plus_posix/source
    ../freertos_libraries/freertos_plus/standard/freertos_plus_posix/source/: FreeRTOS_POSIX_clock.c FreeRTOS_POSIX_mqueue.c FreeRTOS_POSIX_pthread.c FreeRTOS_POSIX_pthread_barrier.c FreeRTOS_POSIX_pthread_cond.c FreeRTOS_POSIX_pthread_mutex.c FreeRTOS_POSIX_sched.c FreeRTOS_POSIX_semaphore.c FreeRTOS_POSIX_timer.c FreeRTOS_POSIX_unistd.c FreeRTOS_POSIX_utils.c
  group source/freertos_libraries/c_sdk/standard/common/include/private
    ../freertos_libraries/c_sdk/standard/common/include/private/: iot_doubly_linked_list.h
  group board
    ../: display_support.h display_support.c sdmmc_config.h sdmmc_config.c pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group evkmimxrt1170
    ../: evkmimxrt1170_connect_cm4_cm7side.jlinkscript
  group doc
    ../: readme.txt
  group video
    ../../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../../components/video/display/: fsl_display.h
    ../../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
    ../../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../../components/video/display/dc/lcdifv2/: fsl_dc_fb_lcdifv2.h fsl_dc_fb_lcdifv2.c
    ../../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.h fsl_dc_fb_elcdif.c
    ../../../../../../components/video/display/hx8394/: fsl_hx8394.h fsl_hx8394.c
    ../../../../../../components/video/display/fbdev/: fsl_fbdev.h fsl_fbdev.c
    ../../../../../../components/video/display/dc/: fsl_dc_fb.h
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_lpi2c.c fsl_lpi2c.h fsl_soc_src.h fsl_soc_src.c fsl_pxp.c fsl_pxp.h fsl_elcdif.c fsl_elcdif.h fsl_usdhc.c fsl_usdhc.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_soc_mipi_csi2rx.h fsl_soc_mipi_csi2rx.c fsl_lcdifv2.c fsl_lcdifv2.h fsl_memory.h fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group touchpanel
    ../../../../../../components/gt911/: fsl_gt911.h fsl_gt911.c
  group sdmmc/host
    ../../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt ChangeLogKSDK.txt
    ../../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group sdmmc/src
    ../../../../../../middleware/sdmmc/sd/: fsl_sd.c
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../../middleware/sdmmc/sd/: fsl_sd.h
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sd
    ../../../../../../middleware/sdmmc/sd/: ChangeLogKSDK.txt
  group sdmmc/osa
    ../../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group component/gpio
    ../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h fsl_os_abstraction_config.h
  group fatfs/source
    ../../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_sd_disk
    ../../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos-kernel/portable/IAR/ARM_CM4F
    ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group openh264/codec/decoder/core/inc
    ../../../../../../middleware/openh264/codec/decoder/core/inc/: au_parser.h bit_stream.h cabac_decoder.h deblocking.h dec_frame.h dec_golomb.h decode_mb_aux.h decode_slice.h decoder.h decoder_context.h decoder_core.h error_code.h error_concealment.h fmo.h get_intra_predictor.h manage_dec_ref.h mb_cache.h memmgr_nal_unit.h mv_pred.h nal_prefix.h nalu.h parameter_sets.h parse_mb_syn_cabac.h parse_mb_syn_cavlc.h pic_queue.h picture.h rec_mb.h slice.h vlc_decoder.h wels_common_basis.h wels_const.h wels_decoder_thread.h
  group openh264/codec/decoder/core/src
    ../../../../../../middleware/openh264/codec/decoder/core/src/: au_parser.cpp bit_stream.cpp cabac_decoder.cpp deblocking.cpp decode_mb_aux.cpp decode_slice.cpp decoder.cpp decoder_core.cpp decoder_data_tables.cpp error_concealment.cpp fmo.cpp get_intra_predictor.cpp manage_dec_ref.cpp memmgr_nal_unit.cpp mv_pred.cpp parse_mb_syn_cabac.cpp parse_mb_syn_cavlc.cpp pic_queue.cpp rec_mb.cpp wels_decoder_thread.cpp
  group openh264/codec/decoder/plus/inc
    ../../../../../../middleware/openh264/codec/decoder/plus/inc/: welsDecoderExt.h
  group openh264/codec/decoder/plus/src
    ../../../../../../middleware/openh264/codec/decoder/plus/src/: welsDecoderExt.cpp
  group openh264/codec/api/svc
    ../../../../../../middleware/openh264/codec/api/svc/: codec_api.h codec_app_def.h codec_def.h codec_ver.h
  group openh264/codec/common/inc
    ../../../../../../middleware/openh264/codec/common/inc/: asmdefs_mmi.h copy_mb.h cpu.h cpu_core.h crt_util_safe_x.h deblocking_common.h expand_pic.h golomb_common.h intra_pred_common.h ls_defines.h macros.h mc.h measure_time.h memory_align.h sad_common.h typedefs.h utils.h version.h wels_common_defs.h wels_const_common.h welsCodecTrace.h WelsList.h WelsLock.h WelsTask.h WelsTaskThread.h WelsThread.h WelsThreadLib.h WelsThreadPool.h
  group openh264/codec/common/src
    ../../../../../../middleware/openh264/codec/common/src/: common_tables.cpp copy_mb.cpp cpu.cpp crt_util_safe_x.cpp deblocking_common.cpp expand_pic.cpp intra_pred_common.cpp mc.cpp memory_align.cpp sad_common.cpp utils.cpp welsCodecTrace.cpp WelsTaskThread.cpp WelsThread.cpp WelsThreadLib.cpp WelsThreadPool.cpp
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group startup
    ../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group xip
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
