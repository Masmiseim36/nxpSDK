# Keil uVision project sd_jpeg_cm7.uvprojx, settings and files
target sd_jpeg_cm7 sdram_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: sd_jpeg_cm7.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, DEBUG, CPU_MIMXRT1176DVMAA_cm7, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SDK_DEBUGCONSOLE_UART, SD_ENABLED, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../components/video/display/dc/elcdif;../../../../../../components/video/display/dc/lcdifv2;../../../../../../devices/MIMXRT1176/drivers;../../../../../../components/video/display/rm68191;../../../../../../components/video/display/rm68200;../../../../../../components/video/display/mipi_dsi_cmd;../../../../../../middleware/sdmmc/sd;../../../../../../middleware/sdmmc/common;../../../../../../middleware/sdmmc/host/usdhc;../../../../../../devices/MIMXRT1176/utilities/debug_console_lite;../../../../../../components/video/display/hx8394;../../../../../../middleware/libjpeg/inc;../../../../../../middleware/fatfs/source;../../../../../../middleware/fatfs/source/fsl_sd_disk;../../../../../../components/video;../../../../../../components/video/display/dc;../../../../../../devices/MIMXRT1176;../../../../../../components/uart;../../../../../../components/lists;../../../../../../devices/MIMXRT1176/xip;../../../../xip;../../../../../../devices/MIMXRT1176/drivers/cm7;../../../../../../CMSIS/Core/Include;../../../../../../components/video/display;../../../../../../middleware/sdmmc/osa;../../../../../../components/osa
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_sdram.scf
  link misc: --remove --entry=Reset_Handler --predefine="-D__stack_size__=0x1000" --predefine="-D__heap_size__=0x20000"
  group source
    ../: sd_jpeg.c jconfig.h ffconf.h
  group board
    ../: display_support.h display_support.c sdmmc_config.h sdmmc_config.c pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.txt
  group evkmimxrt1170
    ../: evkmimxrt1170_connect_cm4_cm7side.jlinkscript
  group video
    ../../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.h fsl_dc_fb_elcdif.c
    ../../../../../../components/video/display/dc/lcdifv2/: fsl_dc_fb_lcdifv2.h fsl_dc_fb_lcdifv2.c
    ../../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
    ../../../../../../components/video/display/hx8394/: fsl_hx8394.h fsl_hx8394.c
    ../../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../../components/video/display/dc/: fsl_dc_fb.h
    ../../../../../../components/video/display/: fsl_display.h
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_soc_src.h fsl_soc_src.c fsl_elcdif.c fsl_elcdif.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_usdhc.c fsl_usdhc.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_anatop_ai.h fsl_anatop_ai.c fsl_memory.h fsl_lcdifv2.c fsl_lcdifv2.h fsl_soc_mipi_csi2rx.h fsl_soc_mipi_csi2rx.c
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group sdmmc/src
    ../../../../../../middleware/sdmmc/sd/: fsl_sd.c
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../../middleware/sdmmc/sd/: fsl_sd.h
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sd
    ../../../../../../middleware/sdmmc/sd/: ChangeLogKSDK.txt
  group sdmmc/host
    ../../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt
    ../../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group libjpeg/inc
    ../../../../../../middleware/libjpeg/inc/: cderror.h cdjpeg.h jdct.h jerror.h jinclude.h jmemsys.h jmorecfg.h jpegint.h jpeglib.h jversion.h transupp.h
  group libjpeg/src
    ../../../../../../middleware/libjpeg/src/: jaricom.c jcapimin.c jcapistd.c jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcprepct.c jcsample.c jctrans.c jdapimin.c jdapistd.c jdarith.c jdatadst.c jdatasrc.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jdtrans.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jmemmgr.c jmemnobs.c jquant1.c jquant2.c jutils.c
  group fatfs/source
    ../../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_sd_disk
    ../../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMXRT1176/arm/: startup_MIMXRT1176_cm7.S
  group xip
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group sdmmc/osa
    ../../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.c
target sd_jpeg_cm7 flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: sd_jpeg_cm7.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_SDRAM, XIP_BOOT_HEADER_DCD_ENABLE=1, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1176DVMAA_cm7, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SDK_DEBUGCONSOLE_UART, SD_ENABLED, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.scf
  link misc: --remove --entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-D__stack_size__=0x1000" --predefine="-D__heap_size__=0x20000"
target sd_jpeg_cm7 sdram_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: sd_jpeg_cm7.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, CPU_MIMXRT1176DVMAA_cm7, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SDK_DEBUGCONSOLE_UART, SD_ENABLED, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_sdram.scf
  link misc: as above
target sd_jpeg_cm7 flexspi_nor_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: sd_jpeg_cm7.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_SDRAM, XIP_BOOT_HEADER_DCD_ENABLE=1, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1176DVMAA_cm7, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SDK_DEBUGCONSOLE_UART, SD_ENABLED, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.scf
  link misc: as above
