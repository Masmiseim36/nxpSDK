# IAR project pxp_fill_rectangle_cm4.ewp, settings and files
configuration sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M4 NXP MIMXRT1176xxxA_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; DEBUG; CPU_MIMXRT1176DVMAA_cm4; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../../components/video; ../../../../../../../components/video/display; ../../../../../../../components/video/display/rm68191; ../../../../../../../devices/MIMXRT1176/drivers; ../../../../../../../components/video/display/mipi_dsi_cmd; ../../../../../../../components/video/display/rm68200; ../../../../../../../components/video/display/dc/lcdifv2; ../../../../../../../components/video/display/dc/elcdif; ../../../../../../../devices/MIMXRT1176/utilities/debug_console_lite; ../../../../../../../components/video/display/hx8394; ../../../../../../../components/video/display/dc; ../../../../../../../devices/MIMXRT1176; ../../../../../../../components/uart; ../../../../../../../components/lists; ../../../../../../../devices/MIMXRT1176/xip; ../../../../../xip; ../../../../../../../devices/MIMXRT1176/drivers/cm4; ../../../../../xmcd; ../../../../../../../devices/MIMXRT1176/utilities/str; ../../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: pxp_fill_rectangle_cm4.out
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm4_sdram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=0; XIP_BOOT_HEADER_DCD_ENABLE=0; XIP_BOOT_HEADER_XMCD_ENABLE=0; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm4; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm4_flexspi_nor_sdram.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm4; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=0; XIP_BOOT_HEADER_DCD_ENABLE=0; XIP_BOOT_HEADER_XMCD_ENABLE=0; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm4; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm4_flexspi_nor_sdram.icf
  group source
    ../: pxp_fill_rectangle.c
  group board
    ../: pin_mux.c pin_mux.h display_support.h display_support.c board.c board.h clock_config.c clock_config.h dcd.c dcd.h
    ../../../../../xmcd/: xmcd.c xmcd.h
  group doc
    ../: readme.md
  group evkmimxrt1170
    ../: evkmimxrt1170_connect_cm4_cm4side_sdram.jlinkscript
  group video
    ../../../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../../../components/video/display/: fsl_display.h
    ../../../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
    ../../../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../../../components/video/display/dc/lcdifv2/: fsl_dc_fb_lcdifv2.h fsl_dc_fb_lcdifv2.c
    ../../../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.h fsl_dc_fb_elcdif.c
    ../../../../../../../components/video/display/hx8394/: fsl_hx8394.h fsl_hx8394.c
    ../../../../../../../components/video/display/dc/: fsl_dc_fb.h
  group drivers
    ../../../../../../../devices/MIMXRT1176/drivers/: fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_soc_src.h fsl_soc_src.c fsl_elcdif.c fsl_elcdif.h fsl_gpio.h fsl_gpio.c fsl_pxp.c fsl_pxp.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_soc_mipi_dsi.h fsl_soc_mipi_csi2rx.h fsl_soc_mipi_csi2rx.c fsl_lcdifv2.c fsl_lcdifv2.h fsl_memory.h fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../../devices/MIMXRT1176/drivers/cm4/: fsl_cache.c fsl_cache.h
  group utilities
    ../../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c fsl_assert.h
    ../../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
  group device
    ../../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm4.h MIMXRT1176_cm4_features.h system_MIMXRT1176_cm4.c system_MIMXRT1176_cm4.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm4.s
  group xip
    ../../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
