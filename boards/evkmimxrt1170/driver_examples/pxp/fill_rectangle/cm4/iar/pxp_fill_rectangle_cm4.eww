<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>pxp_fill_rectangle_cm4</project>
        <configuration>flexspi_nor_sdram_debug</configuration>
      </member>
      <member>
        <project>pxp_fill_rectangle_cm4</project>
        <configuration>flexspi_nor_sdram_release</configuration>
      </member>
      <member>
        <project>pxp_fill_rectangle_cm4</project>
        <configuration>sdram_debug</configuration>
      </member>
      <member>
        <project>pxp_fill_rectangle_cm4</project>
        <configuration>sdram_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_sdram_debug</name>
      <member>
        <project>pxp_fill_rectangle_cm4</project>
        <configuration>flexspi_nor_sdram_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_sdram_release</name>
      <member>
        <project>pxp_fill_rectangle_cm4</project>
        <configuration>flexspi_nor_sdram_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdram_debug</name>
      <member>
        <project>pxp_fill_rectangle_cm4</project>
        <configuration>sdram_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdram_release</name>
      <member>
        <project>pxp_fill_rectangle_cm4</project>
        <configuration>sdram_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/pxp_fill_rectangle_cm4.ewp</path>
  </project>
</workspace>
