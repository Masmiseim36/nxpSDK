# Keil uVision project cmsis_nn_kws_cm7.uvprojx, settings and files
target cmsis_nn_kws_cm7 flexspi_nor_sdram_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: cmsis_nn_kws_cm7.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, DEBUG, __USE_C99_MATH, CPU_MIMXRT1176DVMAA_cm7, BOARD_USE_CODEC=1, SDK_DEBUGCONSOLE_UART, ARM_MATH_CM7, __FPU_PRESENT=1, SDK_I2C_BASED_COMPONENT_USED=1, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8960_ENABLE
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ../../../../../middleware/eiq/cmsis-nn/Examples/kws/KWS;../../../../../middleware/eiq/cmsis-nn/Examples/kws/KWS_NN;../../../../../middleware/eiq/cmsis-nn/Examples/kws/local_NN;../../../../../middleware/eiq/cmsis-nn/Examples/kws/MFCC;../../../../../middleware/eiq/cmsis-nn/Examples/kws;../../../../../middleware/eiq/cmsis-nn/Examples/common/source;..;../../../../../components/codec/wm8960;../../../../../components/codec;../../../../../devices/MIMXRT1176/drivers;../../../../../components/codec/port/wm8960;../../../../../components/codec/i2c;../../../../../components/i2c;../../../../../devices/MIMXRT1176/utilities/debug_console_lite;../../../../../middleware/eiq/common/audio;../../../../../middleware/eiq/cmsis-nn/Include;../../../../../components/lists;../../../../../components/uart;../../../../../devices/MIMXRT1176;../../../../../CMSIS/Include;../../../../../devices/MIMXRT1176/xip;../../../xip;../../../../../middleware/eiq/common
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: ../../../../../devices/MIMXRT1176/arm/MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.scf
  link misc: ../../../../../CMSIS/DSP/Lib/ARM/arm_cortexM7lfdp_math.lib --remove --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-D__stack_size__=0x10000" --predefine="-D__heap_size__=0x800000"
  group source
    ../../../../../middleware/eiq/cmsis-nn/Examples/kws/: audio_data.h main.cpp
    ../../../../../middleware/eiq/common/: timer.h timer.c eiq_common.h eiq_iui.h eiq_iworker.h
  group doc
    ../../../../../middleware/eiq/cmsis-nn/Examples/kws/: off.wav right.wav
    ../: readme.txt
  group KWS
    ../../../../../middleware/eiq/cmsis-nn/Examples/kws/KWS/: kws.cpp kws.h kws_dnn.cpp kws_dnn.h kws_ds_cnn.cpp kws_ds_cnn.h
  group KWS_NN
    ../../../../../middleware/eiq/cmsis-nn/Examples/kws/KWS_NN/: dnn.cpp dnn.h dnn_weights.h ds_cnn.cpp ds_cnn.h ds_cnn_weights.h nn.cpp nn.h
  group local_NN
    ../../../../../middleware/eiq/cmsis-nn/Examples/kws/local_NN/: arm_avepool_q7_HWC_nonsquare.c local_NN.h
  group MFCC
    ../../../../../middleware/eiq/cmsis-nn/Examples/kws/MFCC/: mfcc.cpp mfcc.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
    ./: retarget.c
  group codec
    ../../../../../components/codec/wm8960/: fsl_wm8960.h fsl_wm8960.c
    ../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../components/codec/port/wm8960/: fsl_codec_adapter.c fsl_codec_adapter.h
    ../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
  group drivers
    ../../../../../devices/MIMXRT1176/drivers/: fsl_common.h fsl_common.c fsl_sai.h fsl_sai.c fsl_lpuart.h fsl_lpuart.c fsl_dcdc.h fsl_dcdc.c fsl_pmu.h fsl_pmu.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_anatop_ai.h fsl_anatop_ai.c
  group component/i2c
    ../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group utilities
    ../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group source/audio
    ../../../../../middleware/eiq/common/audio/: eiq_micro.c eiq_audio_worker.c eiq_speaker_conf.c eiq_speaker.c eiq_audio_worker.h eiq_speaker_conf.h audio.h eiq_micro.h eiq_micro_conf.h eiq_speaker.h
  group eiq/cmsis-nn/Include
    ../../../../../middleware/eiq/cmsis-nn/Include/: arm_nnsupportfunctions.h arm_nnfunctions.h arm_nn_tables.h
  group eiq/cmsis-nn/Source/ActivationFunctions
    ../../../../../middleware/eiq/cmsis-nn/Source/ActivationFunctions/: arm_relu_q15.c arm_relu_q7.c arm_nn_activations_q7.c arm_nn_activations_q15.c
  group eiq/cmsis-nn/Source/ConvolutionFunctions
    ../../../../../middleware/eiq/cmsis-nn/Source/ConvolutionFunctions/: arm_convolve_HWC_q7_basic.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_convolve_HWC_q7_basic_nonsquare.c arm_depthwise_separable_conv_HWC_q7.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q7_RGB.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_convolve_HWC_q15_basic.c arm_depthwise_conv_u8_basic_ver1.c arm_convolve_HWC_q7_fast.c arm_nn_mat_mult_kernel_q7_q15.c
  group eiq/cmsis-nn/Source/FullyConnectedFunctions
    ../../../../../middleware/eiq/cmsis-nn/Source/FullyConnectedFunctions/: arm_fully_connected_q7.c arm_fully_connected_q15_opt.c arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_q7_opt.c arm_fully_connected_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c
  group eiq/cmsis-nn/Source/NNSupportFunctions
    ../../../../../middleware/eiq/cmsis-nn/Source/NNSupportFunctions/: arm_nn_mult_q15.c arm_nntables.c arm_nn_mult_q7.c arm_q7_to_q15_reordered_no_shift.c arm_q7_to_q15_no_shift.c
  group eiq/cmsis-nn/Source/PoolingFunctions
    ../../../../../middleware/eiq/cmsis-nn/Source/PoolingFunctions/: arm_pool_q7_HWC.c
  group eiq/cmsis-nn/Source/SoftmaxFunctions
    ../../../../../middleware/eiq/cmsis-nn/Source/SoftmaxFunctions/: arm_softmax_q7.c arm_softmax_q15.c
  group eiq/cmsis-nn
    ../../../../../middleware/eiq/cmsis-nn/: readme.txt LICENSE.txt ChangeLogKSDK.txt
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group device
    ../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group startup
    ../../../../../devices/MIMXRT1176/arm/: startup_MIMXRT1176_cm7.S
  group xip
    ../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
target cmsis_nn_kws_cm7 flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: cmsis_nn_kws_cm7.out
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, __USE_C99_MATH, CPU_MIMXRT1176DVMAA_cm7, BOARD_USE_CODEC=1, SDK_DEBUGCONSOLE_UART, ARM_MATH_CM7, __FPU_PRESENT=1, SDK_I2C_BASED_COMPONENT_USED=1, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8960_ENABLE
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: as above
  link misc: as above
