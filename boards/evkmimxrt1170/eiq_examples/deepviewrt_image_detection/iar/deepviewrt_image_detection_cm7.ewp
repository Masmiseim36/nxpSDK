# IAR project deepviewrt_image_detection_cm7.ewp, settings and files
configuration flexspi_nor_sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1176DVMAA_cm7; _POSIX_C_SOURCE=200809L; ARM_MATH_CM7; __FPU_PRESENT=1; USE_SDRAM; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SDK_DEBUGCONSOLE=1; SKIP_SYSCLK_INIT; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pe111,Pe191,Pe167,Pe177,Pe236,Pe546,Pe550
  ICCARM.IExtraOptions: --diag_suppress Pa082,Pa050
  ICCARM.CCIncludePath2: ../source; ..; ../../../../../devices/MIMXRT1176/drivers/cm7; ../../../../../devices/MIMXRT1176/drivers; ../../../../../middleware/eiq/deepviewrt/include; ../../../../../components/lists; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../devices/MIMXRT1176/utilities/str; ../../../../../devices/MIMXRT1176/utilities/debug_console; ../../../../../devices/MIMXRT1176; ../../../../../devices/MIMXRT1176/xip; ../../../xip; ../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ../source
  ILINK.IlinkOutputFile: deepviewrt_image_detection_cm7.out
  ILINK.IlinkKeepSymbols: model_rtm_start; sample_img_start
  ILINK.IlinkConfigDefines: __stack_size__=0x10000; __heap_size__=0x1000000
  ILINK.IlinkIcfFile: ../../../../../middleware/eiq/deepviewrt/boards/evkmimxrt1170/modelrunner/MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
  ILINK.IlinkExtraOptions: --diag_suppress=Lt009
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/eiq/deepviewrt/lib/deepview-rt-iar.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1176DVMAA_cm7; _POSIX_C_SOURCE=200809L; ARM_MATH_CM7; __FPU_PRESENT=1; USE_SDRAM; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SDK_DEBUGCONSOLE=1; SKIP_SYSCLK_INIT; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  group source
    ../: main.c
  group source/data
    ../source/data/: horse.jpg
  group source/models
    ../source/models/: mobilenet_ssd_v1_1.00_trimmed_quant_anchors.rtm mobilenet_ssd_v2_lite_quant_anchors.rtm
  group board
    ../: pin_mux.h pin_mux.c cr_section_macros.h board_init.h board_init.c clock_config.c clock_config.h dcd.c dcd.h board.c board.h
    ./: retarget.c
  group doc
    ../doc/: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
    ../../../../../devices/MIMXRT1176/drivers/: fsl_semc.h fsl_semc.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_iomuxc.h fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_anatop_ai.h fsl_anatop_ai.c
  group eiq/deepviewrt
    ../../../../../middleware/eiq/deepviewrt/: readme.txt
  group eiq/deepviewrt/include
    ../../../../../middleware/eiq/deepviewrt/include/: deepview_ops.h deepview_rpc.h deepview_rt.h mathrt.h stb_image.h stb_image_resize.h stb_image_write.h
  group eiq/deepviewrt/lib
    ../../../../../middleware/eiq/deepviewrt/lib/: LICENSE.txt
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group utilities
    ../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1176/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1176/utilities/: fsl_assert.c
  group device
    ../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group startup
    ../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group xip
    ../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
