# IAR project glow_cifar10_camera_cm7.ewp, settings and files
configuration flexspi_nor_sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=0; XIP_BOOT_HEADER_XMCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; SDK_DEBUGCONSOLE_UART; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; CR_INTEGER_PRINTF; CMSIS_NN; ARM_MATH_CM7; __FPU_PRESENT=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; SDK_DEBUGCONSOLE=1; SDK_I2C_BASED_COMPONENT_USED=1; DISABLEFLOAT16; EIQ_GUI_PRINTF; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pe167
  ICCARM.IExtraOptions: --diag_suppress Pa082,Pa050
  ICCARM.CCIncludePath2: ../source/image; ../source/video; ../eiq/cmsis_nn/Include; ../source; ../board; ../../../../../middleware/eiq/glow/examples/cifar10_camera/evkmimxrt1170; ..; ../../../../../devices/MIMXRT1176/utilities/str; ../../../../../devices/MIMXRT1176/utilities/debug_console_lite; ../../../../../devices/MIMXRT1176; ../../../../../components/video/display/mipi_dsi_cmd; ../../../../../devices/MIMXRT1176/drivers; ../../../../../components/video/display/rm68191; ../../../../../components/video/display/rm68200; ../../../../../components/video/display/hx8394; ../../../../../components/video/display; ../../../../../components/video/camera/device; ../../../../../components/video/camera; ../../../../../components/video; ../../../../../components/video/camera/receiver; ../../../../../components/video/camera/device/sccb; ../../../../../components/video/camera/device/ov5640; ../../../../../components/video/i2c; ../../../../../components/video/camera/receiver/csi; ../../../../../components/video/display/dc; ../../../../../components/video/display/dc/elcdif; ../../../../../components/video/display/dc/lcdifv2; ../../../../../CMSIS/DSP/Include; ../../../../../CMSIS/DSP/PrivateInclude; ../../../../../CMSIS/DSP/Source/DistanceFunctions; ../../../../../middleware/eiq/common; ../../../../../middleware/eiq/common/video; ../../../../../middleware/eiq/common/gprintf; ../../../../../middleware/eiq/glow/bundle_utils; ../../../../../components/lists; ../../../../../components/uart; ../../../../../devices/MIMXRT1176/xip; ../../../xip; ../../../../../CMSIS/Core/Include; ../../../xmcd
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: glow_cifar10_camera_cm7.out
  ILINK.IlinkConfigDefines: __stack_size__=0x10000; __heap_size__=0x80000
  ILINK.IlinkIcfFile: ../../../../../devices/MIMXRT1176/iar/MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
  ILINK.IlinkExtraOptions: --diag_suppress=Lt009
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=0; XIP_BOOT_HEADER_XMCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; SDK_DEBUGCONSOLE_UART; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; CR_INTEGER_PRINTF; CMSIS_NN; ARM_MATH_CM7; __FPU_PRESENT=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; SDK_DEBUGCONSOLE=1; SDK_I2C_BASED_COMPONENT_USED=1; DISABLEFLOAT16; EIQ_GUI_PRINTF; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../source/: labels.h parameter.h weights.h cifar10.h cifar10.o cifar10.weights.bin cifar10.weights.txt glow_cifar10_camera.c image.c image.h timer.c timer.h
    ../../../../../middleware/eiq/common/: eiq_common.h eiq_iui.h eiq_iworker.h
  group source/image
    ../source/image/: demo_config.h image_data.h image.h image_capture.c image_conv_rotate.c image_decode_raw.c image_resize_nearest.c image_draw.c image_utils.h
  group source/video
    ../../../../../middleware/eiq/common/video/camera/RM68191_RM68200/: eiq_camera_conf.c
    ../../../../../middleware/eiq/common/video/display/RK055AHD091_RK055IQH091/: eiq_display_conf.c
    ../../../../../middleware/eiq/common/video/: eiq_camera.c eiq_display.c eiq_pxp.c eiq_video_worker.c eiq_camera.h eiq_camera_conf.h eiq_display.h eiq_display_conf.h eiq_pxp.h eiq_video_worker.h
  group source/gprintf
    ../../../../../middleware/eiq/common/gprintf/: chgui.c chgui.h font.h
  group board
    ../board/: board_init.h board_init.c
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h peripherals.h peripherals.c dcd.c dcd.h
    ../../../xmcd/: xmcd.c xmcd.h
  group eiq/cmsis_nn
    ../eiq/cmsis_nn/: LICENSE.txt
  group eiq/cmsis_nn/Include
    ../eiq/cmsis_nn/Include/: arm_nn_tables.h arm_nnfunctions.h arm_nnsupportfunctions.h
  group eiq/glow
    ../../../../../middleware/eiq/glow/: readme.txt LICENSE.txt
  group eiq/glow/bundle_utils
    ../../../../../middleware/eiq/glow/bundle_utils/: glow_bundle_utils.h glow_bundle_utils.c
  group eiq/glow/examples/common
    ../../../../../middleware/eiq/glow/examples/common/: glow_process_image.py
  group doc
    ../doc/: readme.txt board.readme
  group scripts
    ../scripts/: glow_process_image.py glow_process_sound.py glow_show_detections.py glow_show_segmentation.py
  group utilities
    ../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group device
    ../../../../../devices/MIMXRT1176/: system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h
  group video
    ../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
    ../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../components/video/display/hx8394/: fsl_hx8394.h fsl_hx8394.c
    ../../../../../components/video/display/: fsl_display.h
    ../../../../../components/video/camera/device/: fsl_camera_device.h
    ../../../../../components/video/camera/: fsl_camera.h
    ../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../components/video/camera/receiver/: fsl_camera_receiver.h
    ../../../../../components/video/camera/device/sccb/: fsl_sccb.h fsl_sccb.c
    ../../../../../components/video/camera/device/ov5640/: fsl_ov5640.h fsl_ov5640.c
    ../../../../../components/video/i2c/: fsl_video_i2c.h fsl_video_i2c.c
    ../../../../../components/video/camera/receiver/csi/: fsl_csi_camera_adapter.h fsl_csi_camera_adapter.c
    ../../../../../components/video/display/dc/: fsl_dc_fb.h
    ../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.h fsl_dc_fb_elcdif.c
    ../../../../../components/video/display/dc/lcdifv2/: fsl_dc_fb_lcdifv2.h fsl_dc_fb_lcdifv2.c
  group drivers
    ../../../../../devices/MIMXRT1176/drivers/: fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_mipi_csi2rx.c fsl_mipi_csi2rx.h fsl_csi.c fsl_csi.h fsl_elcdif.c fsl_elcdif.h fsl_pxp.c fsl_pxp.h fsl_lpi2c.c fsl_lpi2c.h fsl_soc_src.h fsl_soc_src.c fsl_soc_mipi_csi2rx.h fsl_soc_mipi_csi2rx.c fsl_lpuart.h fsl_lpuart.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_iomuxc.h fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_anatop_ai.h fsl_anatop_ai.c fsl_memory.h fsl_lcdifv2.c fsl_lcdifv2.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
  group CMSIS/DSP/Include
    ../../../../../CMSIS/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h arm_common_tables_f16.h arm_const_structs_f16.h arm_helium_utils.h arm_math_f16.h arm_math_memory.h arm_math_types.h arm_math_types_f16.h arm_mve_tables.h arm_mve_tables_f16.h arm_vec_math.h arm_vec_math_f16.h
  group CMSIS/DSP/Include/dsp
    ../../../../../CMSIS/DSP/Include/dsp/: basic_math_functions.h basic_math_functions_f16.h bayes_functions.h bayes_functions_f16.h complex_math_functions.h complex_math_functions_f16.h controller_functions.h controller_functions_f16.h distance_functions.h distance_functions_f16.h fast_math_functions.h fast_math_functions_f16.h filtering_functions.h filtering_functions_f16.h interpolation_functions.h interpolation_functions_f16.h matrix_functions.h matrix_functions_f16.h none.h quaternion_math_functions.h statistics_functions.h statistics_functions_f16.h support_functions.h support_functions_f16.h svm_defines.h svm_functions.h svm_functions_f16.h transform_functions.h transform_functions_f16.h utils.h
  group CMSIS/DSP/PrivateInclude
    ../../../../../CMSIS/DSP/PrivateInclude/: arm_sorting.h arm_vec_fft.h arm_vec_filtering.h
  group CMSIS/DSP/Source/BasicMathFunctions
    ../../../../../CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
  group CMSIS/DSP/Source/BayesFunctions
    ../../../../../CMSIS/DSP/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
  group CMSIS/DSP/Source/CommonTables
    ../../../../../CMSIS/DSP/Source/CommonTables/: CommonTables.c CommonTablesF16.c
  group CMSIS/DSP/Source/ComplexMathFunctions
    ../../../../../CMSIS/DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
  group CMSIS/DSP/Source/ControllerFunctions
    ../../../../../CMSIS/DSP/Source/ControllerFunctions/: ControllerFunctions.c
  group CMSIS/DSP/Source/DistanceFunctions
    ../../../../../CMSIS/DSP/Source/DistanceFunctions/: DistanceFunctions.c arm_boolean_distance_template.h DistanceFunctionsF16.c
  group CMSIS/DSP/Source/FastMathFunctions
    ../../../../../CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
  group CMSIS/DSP/Source/FilteringFunctions
    ../../../../../CMSIS/DSP/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
  group CMSIS/DSP/Source/InterpolationFunctions
    ../../../../../CMSIS/DSP/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
  group CMSIS/DSP/Source/MatrixFunctions
    ../../../../../CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
  group CMSIS/DSP/Source/QuaternionMathFunctions
    ../../../../../CMSIS/DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
  group CMSIS/DSP/Source/SVMFunctions
    ../../../../../CMSIS/DSP/Source/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
  group CMSIS/DSP/Source/StatisticsFunctions
    ../../../../../CMSIS/DSP/Source/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
  group CMSIS/DSP/Source/SupportFunctions
    ../../../../../CMSIS/DSP/Source/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
  group CMSIS/DSP/Source/TransformFunctions
    ../../../../../CMSIS/DSP/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group startup
    ../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group xip
    ../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
