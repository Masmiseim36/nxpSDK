# IAR project glow_multicore_secure_ml_cm4.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M4 NXP MIMXRT1176xxxA_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1176DVMAA_cm4; ARM_MATH_CM4; __FPU_PRESENT=1; SDK_I2C_BASED_COMPONENT_USED=1; __SEMIHOST_HARDFAULT_DISABLE=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pe167,Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../middleware/eiq/glow/examples/multicore_secure_ml/m4; ../../../../../../middleware/multicore/erpc/erpc_c/infra; ../../../../../../middleware/multicore/erpc/erpc_c/port; ../../../../../../middleware/multicore/erpc/erpc_c/config; ../../../../../../middleware/multicore/erpc/erpc_c/setup; ../../../../../../middleware/multicore/erpc/erpc_c/transports; ../../../../../../middleware/eiq/common/image; ../../../../../../middleware/eiq/glow/examples/multicore_secure_ml/erpc; ../../../../../../middleware/eiq/glow/examples/multicore_secure_ml/source; ../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F; ../../../../../../middleware/multicore/mcmgr/src; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../devices/MIMXRT1176/utilities/str; ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite; ../../../../../../devices/MIMXRT1176/drivers/cm4; ../../../../../../middleware/eiq/glow/bundle_utils; ../../../../../../components/lists; ../../../../../../components/uart; ../../../../../../devices/MIMXRT1176; ../../../../../../devices/MIMXRT1176/xip; ../../../../xip; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ../../../../../../middleware/eiq/glow/examples/multicore_secure_ml/source
  ILINK.IlinkOutputFile: glow_multicore_secure_ml_cm4.out
  ILINK.IlinkConfigDefines: __heap_size__=0x8000
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm4_sdram.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free; --diag_suppress=Lt009
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1176DVMAA_cm4; ARM_MATH_CM4; __FPU_PRESENT=1; SDK_I2C_BASED_COMPONENT_USED=1; __SEMIHOST_HARDFAULT_DISABLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../: board_init.c board_init.h board.c board.h pin_mux.c pin_mux.h clock_config.c clock_config.h peripherals.h peripherals.c dcd.c dcd.h
  group source
    ../source/: demo_info.h eiq_common.h eiq_iui.h eiq_iworker.h
    ../../../../../../middleware/eiq/glow/examples/multicore_secure_ml/m4/: app.h hardware_init.c main_m4.c
    ../../../../../../middleware/eiq/glow/examples/multicore_secure_ml/source/: erpc_config.h input_image.inc FreeRTOSConfig.h
    ../../../../../../middleware/multicore/erpc/erpc_c/config/: erpc_config.h
  group source/image
    ../../../../../../middleware/eiq/glow/examples/multicore_secure_ml/m4/: demo_config.h image_data.h
    ../source/image/: image.h image_utils.h image_draw.c image_resize_nearest.c image_decode_raw.c image_conv.c
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F/: portmacro.h portasm.s port.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: FreeRTOS.h StackMacros.h atomic.h croutine.h deprecated_definitions.h event_groups.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
  group freerots/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freerots/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: heap_2.c
  group mcmgr
    ../../../../../../middleware/multicore/mcmgr/src/: mcmgr.h mcmgr_internal_core_api.h mcmgr.c mcmgr_mu_internal.c mcmgr_internal_core_api_imxrt1170.c
  group erpc/service
    ../../../../../../middleware/eiq/glow/examples/multicore_secure_ml/erpc/: secure_ml.h secure_ml.erpc secure_ml_client.cpp
  group erpc/setup
    ../../../../../../middleware/multicore/erpc/erpc_c/setup/: erpc_setup_mu.cpp erpc_client_setup.cpp erpc_setup_mbf_dynamic.cpp erpc_arbitrated_client_setup.h erpc_client_setup.h erpc_mbf_setup.h erpc_server_setup.h erpc_transport_setup.h
  group erpc/transports
    ../../../../../../middleware/multicore/erpc/erpc_c/transports/: erpc_mu_transport.cpp erpc_dspi_master_transport.hpp erpc_dspi_slave_transport.hpp erpc_i2c_slave_transport.hpp erpc_inter_thread_buffer_transport.hpp erpc_lpi2c_slave_transport.hpp erpc_lpspi_slave_transport.hpp erpc_mu_transport.hpp erpc_rpmsg_linux_transport.hpp erpc_rpmsg_lite_base.hpp erpc_rpmsg_lite_rtos_transport.hpp erpc_rpmsg_lite_transport.hpp erpc_rpmsg_tty_rtos_transport.hpp erpc_serial_transport.hpp erpc_spi_master_transport.hpp erpc_spi_slave_transport.hpp erpc_spidev_master_transport.hpp erpc_tcp_transport.hpp erpc_uart_cmsis_transport.hpp erpc_uart_zephyr_transport.hpp erpc_usb_cdc_transport.hpp
  group erpc/port
    ../../../../../../middleware/multicore/erpc/erpc_c/port/: erpc_port_freertos.cpp erpc_threading_freertos.cpp erpc_setup_extensions_freertos.cpp erpc_config_internal.h erpc_endianness_agnostic_example.h erpc_endianness_undefined.h erpc_port.h erpc_serial.h erpc_setup_extensions.h erpc_spidev.h erpc_sysgpio.h erpc_threading.h
  group erpc/infra
    ../../../../../../middleware/multicore/erpc/erpc_c/infra/: erpc_basic_codec.cpp erpc_client_manager.cpp erpc_crc16.cpp erpc_message_buffer.cpp erpc_message_loggers.cpp erpc_pre_post_action.cpp erpc_client_manager.h erpc_common.h erpc_pre_post_action.h erpc_version.h erpc_arbitrated_client_manager.hpp erpc_basic_codec.hpp erpc_client_server_common.hpp erpc_codec.hpp erpc_crc16.hpp erpc_framed_transport.hpp erpc_manually_constructed.hpp erpc_message_buffer.hpp erpc_message_loggers.hpp erpc_server.hpp erpc_simple_server.hpp erpc_static_queue.hpp erpc_transport.hpp erpc_transport_arbitrator.hpp erpc_utils.hpp
  group scripts
    ../scripts/: glow_process_image.py glow_process_sound.py glow_show_detections.py glow_show_segmentation.py
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_rdc.h fsl_rdc.c fsl_mu.h fsl_mu.c fsl_soc_src.h fsl_soc_src.c fsl_semc.h fsl_semc.c fsl_lpuart.h fsl_lpuart.c fsl_dcdc.h fsl_dcdc.c fsl_pmu.h fsl_pmu.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_gpio.h fsl_gpio.c fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../devices/MIMXRT1176/drivers/cm4/: fsl_cache.c fsl_cache.h
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c fsl_assert.h
  group eiq/glow
    ../../../../../../middleware/eiq/glow/: readme.txt LICENSE.txt
  group eiq/glow/bundle_utils
    ../../../../../../middleware/eiq/glow/bundle_utils/: glow_bundle_utils.h glow_bundle_utils.c
  group eiq/glow/examples/common
    ../../../../../../middleware/eiq/glow/examples/common/: glow_process_image.py
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm4.h MIMXRT1176_cm4_features.h system_MIMXRT1176_cm4.c system_MIMXRT1176_cm4.h
  group startup
    ../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm4.s
  group xip
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
  group doc
    ../: readme.md
