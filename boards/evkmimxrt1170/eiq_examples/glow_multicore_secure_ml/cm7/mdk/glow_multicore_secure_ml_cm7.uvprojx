# Keil uVision project glow_multicore_secure_ml_cm7.uvprojx, settings and files
target glow_multicore_secure_ml_cm7 flexspi_nor_sdram_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: glow_multicore_secure_ml_cm7.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=0, XIP_BOOT_HEADER_XMCD_ENABLE=1, USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, DEBUG, CORE1_IMAGE_COPY_TO_RAM, __SEMIHOST_HARDFAULT_DISABLE=1, CPU_MIMXRT1176DVMAA_cm7, ARM_MATH_CM7, __FPU_PRESENT=1, PRINTF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SDK_DEBUGCONSOLE=1, FSL_RTOS_BM, SKIP_SYSCLK_INIT, SDK_OS_BAREMETAL, MCUXPRESSO_SDK, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, SDK_I2C_BASED_COMPONENT_USED=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../middleware/eiq/glow/examples/multicore_secure_ml;../../../../../../middleware/multicore/erpc/erpc_c/infra;../../../../../../middleware/multicore/erpc/erpc_c/port;../../../../../../middleware/multicore/erpc/erpc_c/config;../../../../../../middleware/multicore/erpc/erpc_c/setup;../../../../../../middleware/multicore/erpc/erpc_c/transports;../../../../../../middleware/eiq/glow/examples/multicore_secure_ml/erpc;../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM7/r0p1;../../../../../../middleware/eiq/glow/examples/multicore_secure_ml/source;../../../../../../middleware/eiq/common;../../../../../../middleware/multicore/mcmgr/src;../../../../../../components/video/camera/device;../../../../../../components/video/camera/receiver;../../../../../../components/video/camera/device/sccb;../../../../../../components/video/camera/device/ov5640;../../../../../../components/video/display/rm68191;../../../../../../components/video/display/rm68200;../../../../../../components/video/display/hx8394;../../../../../../components/video/camera;../../../../../../components/video/camera/receiver/csi;../../../../../../devices/MIMXRT1176/drivers;../../../../../../components/video;../../../../../../components/video/display/dc;../../../../../../components/video/display/dc/elcdif;../../../../../../components/video/display/dc/lcdifv2;../../../../../../components/video/display;../../../../../../devices/MIMXRT1176/utilities/str;../../../../../../devices/MIMXRT1176/utilities/debug_console_lite;../../../../../../devices/MIMXRT1176/drivers/cm7;../../../../../../middleware/eiq/glow/bundle_utils;../../../../../../components/lists;../../../../../../components/uart;../../../../../../devices/MIMXRT1176;../../../../../../devices/MIMXRT1176/xip;../../../../xip;../../../../xmcd;../../../../../../components/video/display/mipi_dsi_cmd;../../../../../../CMSIS/Core/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../../cm4/mdk/debug
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.scf
  link misc: --remove --keep=*(*core1_code) --entry=Reset_Handler --diag_suppress 6314 --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-DXIP_BOOT_HEADER_DCD_ENABLE=0" --predefine="-DXIP_BOOT_HEADER_XMCD_ENABLE=1" --predefine="-D__heap_size__=0x80000"
  group board
    ../: pin_mux.c pin_mux.h dcd.c dcd.h board_init.c board_init.h board.c board.h clock_config.c clock_config.h peripherals.h peripherals.c
    ./: retarget.c
    ../../../../xmcd/: xmcd.c xmcd.h
  group source
    ../../../../../../middleware/eiq/glow/examples/multicore_secure_ml/m7/: main_m7.c app.h hardware_init.c
    ../../../../../../middleware/eiq/glow/examples/multicore_secure_ml/source/: lenet_mnist.h lenet_mnist.weights.bin lenet_mnist.weights.txt FreeRTOSConfig.h erpc_config.h
    ../source/: lenet_mnist.o
    ../../../../../../middleware/multicore/erpc/erpc_c/config/: erpc_config.h
  group mcmgr
    ../../../../../../middleware/multicore/mcmgr/src/: mcmgr.h mcmgr_internal_core_api.h mcmgr.c mcmgr_mu_internal.c mcmgr_internal_core_api_imxrt1170.c
  group freertos/freertos_kernel/portable/GCC/ARM_CM7/r0p1
    ../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM7/r0p1/: portmacro.h port.c
  group freerots/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: heap_2.c
  group freerots/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: FreeRTOS.h StackMacros.h atomic.h croutine.h deprecated_definitions.h event_groups.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
  group erpc/service
    ../../../../../../middleware/eiq/glow/examples/multicore_secure_ml/erpc/: secure_ml.h secure_ml_server.h secure_ml.erpc secure_ml_server.cpp
  group erpc/setup
    ../../../../../../middleware/multicore/erpc/erpc_c/setup/: erpc_setup_mu.cpp erpc_server_setup.cpp erpc_setup_mbf_dynamic.cpp erpc_arbitrated_client_setup.h erpc_client_setup.h erpc_mbf_setup.h erpc_server_setup.h erpc_transport_setup.h
  group erpc/transports
    ../../../../../../middleware/multicore/erpc/erpc_c/transports/: erpc_mu_transport.cpp erpc_dspi_master_transport.hpp erpc_dspi_slave_transport.hpp erpc_i2c_slave_transport.hpp erpc_inter_thread_buffer_transport.hpp erpc_lpi2c_slave_transport.hpp erpc_lpspi_slave_transport.hpp erpc_mu_transport.hpp erpc_rpmsg_linux_transport.hpp erpc_rpmsg_lite_base.hpp erpc_rpmsg_lite_rtos_transport.hpp erpc_rpmsg_lite_transport.hpp erpc_rpmsg_tty_rtos_transport.hpp erpc_serial_transport.hpp erpc_spi_master_transport.hpp erpc_spi_slave_transport.hpp erpc_spidev_master_transport.hpp erpc_tcp_transport.hpp erpc_uart_cmsis_transport.hpp erpc_uart_zephyr_transport.hpp erpc_usb_cdc_transport.hpp
  group erpc/port
    ../../../../../../middleware/multicore/erpc/erpc_c/port/: erpc_port_freertos.cpp erpc_threading_freertos.cpp erpc_setup_extensions_freertos.cpp erpc_config_internal.h erpc_endianness_agnostic_example.h erpc_endianness_undefined.h erpc_port.h erpc_serial.h erpc_setup_extensions.h erpc_spidev.h erpc_sysgpio.h erpc_threading.h
  group erpc/infra
    ../../../../../../middleware/multicore/erpc/erpc_c/infra/: erpc_basic_codec.cpp erpc_server.cpp erpc_simple_server.cpp erpc_crc16.cpp erpc_message_buffer.cpp erpc_message_loggers.cpp erpc_pre_post_action.cpp erpc_client_manager.h erpc_common.h erpc_pre_post_action.h erpc_version.h erpc_arbitrated_client_manager.hpp erpc_basic_codec.hpp erpc_client_server_common.hpp erpc_codec.hpp erpc_crc16.hpp erpc_framed_transport.hpp erpc_manually_constructed.hpp erpc_message_buffer.hpp erpc_message_loggers.hpp erpc_server.hpp erpc_simple_server.hpp erpc_static_queue.hpp erpc_transport.hpp erpc_transport_arbitrator.hpp erpc_utils.hpp
  group scripts
    ../scripts/: glow_process_image.py glow_process_sound.py glow_show_detections.py glow_show_segmentation.py
  group video
    ../../../../../../components/video/camera/device/: fsl_camera_device.h
    ../../../../../../components/video/camera/receiver/: fsl_camera_receiver.h
    ../../../../../../components/video/camera/device/sccb/: fsl_sccb.h fsl_sccb.c
    ../../../../../../components/video/camera/device/ov5640/: fsl_ov5640.h fsl_ov5640.c
    ../../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../../components/video/display/hx8394/: fsl_hx8394.h fsl_hx8394.c
    ../../../../../../components/video/camera/: fsl_camera.h
    ../../../../../../components/video/camera/receiver/csi/: fsl_csi_camera_adapter.h fsl_csi_camera_adapter.c
    ../../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../../components/video/display/dc/: fsl_dc_fb.h
    ../../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.h fsl_dc_fb_elcdif.c
    ../../../../../../components/video/display/dc/lcdifv2/: fsl_dc_fb_lcdifv2.h fsl_dc_fb_lcdifv2.c
    ../../../../../../components/video/display/: fsl_display.h
    ../../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_csi.c fsl_csi.h fsl_elcdif.c fsl_elcdif.h fsl_pxp.c fsl_pxp.h fsl_gpio.h fsl_gpio.c fsl_lpi2c.c fsl_lpi2c.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_mipi_csi2rx.c fsl_mipi_csi2rx.h fsl_soc_mipi_csi2rx.h fsl_soc_mipi_csi2rx.c fsl_soc_src.h fsl_soc_src.c fsl_gpc.h fsl_gpc.c fsl_pgmc.h fsl_pgmc.c fsl_lpuart.h fsl_lpuart.c fsl_clock.h fsl_clock.c fsl_rdc.h fsl_rdc.c fsl_semc.h fsl_semc.c fsl_mu.h fsl_mu.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_iomuxc.h fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_memory.h fsl_lcdifv2.c fsl_lcdifv2.h fsl_soc_mipi_dsi.h fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c fsl_assert.h
    ../../../../../../devices/MIMXRT1176/utilities/incbin/: fsl_incbin.S
  group eiq/glow/bundle_utils
    ../../../../../../middleware/eiq/glow/bundle_utils/: glow_bundle_utils.h glow_bundle_utils.c
  group eiq/glow
    ../../../../../../middleware/eiq/glow/: readme.txt LICENSE.txt
  group eiq/glow/examples/common
    ../../../../../../middleware/eiq/glow/examples/common/: glow_process_image.py
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group startup
    ../../../../../../devices/MIMXRT1176/arm/: startup_MIMXRT1176_cm7.S
  group xip
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
  group doc
    ../: readme.md
target glow_multicore_secure_ml_cm7 flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: glow_multicore_secure_ml_cm7.out
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=0, XIP_BOOT_HEADER_XMCD_ENABLE=1, USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, CORE1_IMAGE_COPY_TO_RAM, __SEMIHOST_HARDFAULT_DISABLE=1, CPU_MIMXRT1176DVMAA_cm7, ARM_MATH_CM7, __FPU_PRESENT=1, PRINTF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SDK_DEBUGCONSOLE=1, FSL_RTOS_BM, SKIP_SYSCLK_INIT, SDK_OS_BAREMETAL, MCUXPRESSO_SDK, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, SDK_I2C_BASED_COMPONENT_USED=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../../cm4/mdk/release
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.scf
  link misc: as above
