# IAR project tensorflow_lite_kws_cm7.ewp, settings and files
configuration flexspi_nor_sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; SDK_DEBUGCONSOLE_UART; FLATBUFFERS_LITTLEENDIAN; GEMMLOWP_MCU; TFLITE_MCU; ARM_MATH_CM7; __FPU_PRESENT=1; SDK_I2C_BASED_COMPONENT_USED=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE
  ICCARM.CCDiagSuppress: Pe167,Pa082,Pa089,Pa093,Pe111,Pe549,Pe550,Pe186,Pe611,Pe815
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.CCIncludePath2: ../../../../../middleware/eiq/tensorflow-lite/examples/kws; ../../../../../middleware/eiq/tensorflow-lite/examples/common/audio; ../../../../../middleware/eiq/common/model; ..; ../../../../../components/codec/wm8960; ../../../../../components/codec; ../../../../../devices/MIMXRT1176/drivers; ../../../../../components/codec/port/wm8960; ../../../../../components/codec/i2c; ../../../../../components/i2c; ../../../../../devices/MIMXRT1176/utilities/debug_console_lite; ../../../../../middleware/eiq/common/audio; ../../../../../middleware/eiq/tensorflow-lite; ../../../../../middleware/eiq/tensorflow-lite/third_party; ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include; ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp; ../../../../../components/lists; ../../../../../components/uart; ../../../../../devices/MIMXRT1176; ../../../../../CMSIS/Include; ../../../../../devices/MIMXRT1176/xip; ../../../xip; ../../../../../middleware/eiq/common
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: tensorflow_lite_kws_cm7.out
  ILINK.IlinkConfigDefines: __stack_size__=0x10000; __heap_size__=0x800000
  ILINK.IlinkIcfFile: ../../../../../devices/MIMXRT1176/iar/MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
  ILINK.IlinkExtraOptions: --diag_suppress=Lt049
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/eiq/tensorflow-lite/lib/cm7/iar/libtensorflow-lite.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; SDK_DEBUGCONSOLE_UART; FLATBUFFERS_LITTLEENDIAN; GEMMLOWP_MCU; TFLITE_MCU; ARM_MATH_CM7; __FPU_PRESENT=1; SDK_I2C_BASED_COMPONENT_USED=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../../../../../middleware/eiq/common/: board_init.h
    ../: pin_mux.c pin_mux.h board.c board.h board_init.c clock_config.c clock_config.h dcd.c dcd.h
    ./: retarget.c
  group source
    ../../../../../middleware/eiq/common/: demo_info.h timer.h timer.c eiq_common.h eiq_iui.h eiq_iworker.h
    ../../../../../middleware/eiq/tensorflow-lite/examples/kws/: audio_data.h demo_config.h demo_info.cpp labels.h main.cpp
  group source/model
    ../../../../../middleware/eiq/common/model/: get_top_n.cpp get_top_n.h model.h output_postproc.h
    ../../../../../middleware/eiq/tensorflow-lite/examples/common/model/: model.cpp output_postproc.cpp
    ../../../../../middleware/eiq/tensorflow-lite/examples/kws/: model_data.h model_ds_cnn_ops.cpp
  group source/audio
    ../../../../../middleware/eiq/tensorflow-lite/examples/common/audio/: audio_capture.cpp kws_mfcc.cpp kws_mfcc.hpp mfcc.cpp mfcc.hpp
    ../../../../../middleware/eiq/common/audio/: eiq_micro.c eiq_audio_worker.c eiq_speaker_conf.c eiq_speaker.c eiq_audio_worker.h eiq_speaker_conf.h audio.h eiq_micro.h eiq_micro_conf.h eiq_speaker.h
  group doc
    ../../../../../middleware/eiq/tensorflow-lite/examples/kws/: ds_cnn_s.tflite off.wav right.wav
    ../: readme.txt
  group codec
    ../../../../../components/codec/wm8960/: fsl_wm8960.h fsl_wm8960.c
    ../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../components/codec/port/wm8960/: fsl_codec_adapter.c fsl_codec_adapter.h
    ../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
  group drivers
    ../../../../../devices/MIMXRT1176/drivers/: fsl_common.h fsl_common.c fsl_sai.h fsl_sai.c fsl_lpuart.h fsl_lpuart.c fsl_dcdc.h fsl_dcdc.c fsl_pmu.h fsl_pmu.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_anatop_ai.h fsl_anatop_ai.c
  group component/i2c
    ../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group utilities
    ../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group eiq/tensorflow-lite/tensorflow/core/public
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/core/public/: version.h session.h
  group eiq/tensorflow-lite/tensorflow/core/util
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/core/util/: stat_summarizer_options.h stats_calculator.h
  group eiq/tensorflow-lite/tensorflow/lite
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/: graph_info.h configuration.h stderr_reporter.h op_resolver.h interpreter.h simple_memory_arena.h allocation.h context.h string_type.h mutable_op_resolver.h string_util.h interpreter_builder.h builtin_op_data.h minimal_logging.h memory_planner.h arena_planner.h tflite_with_xnnpack_optional.h model.h optional_debug_tools.h version.h builtin_ops.h type_to_tflitetype.h error_reporter.h external_cpu_backend_context.h model_builder.h util.h context_util.h
  group eiq/tensorflow-lite/tensorflow/lite/c
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/c/: common.h c_api_internal.h c_api.h builtin_op_data.h
  group eiq/tensorflow-lite/tensorflow/lite/core
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/: subgraph.h macros.h
  group eiq/tensorflow-lite/tensorflow/lite/core/api
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/api/: op_resolver.h tensor_utils.h profiler.h flatbuffer_conversions.h error_reporter.h
  group eiq/tensorflow-lite/tensorflow/lite/experimental/resource
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/experimental/resource/: resource_variable.h resource_base.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/: fully_connected.h lstm_shared.h custom_ops_register.h op_macros.h cpu_backend_gemm_eigen.h kernel_util.h eigen_support.h dequantize.h cpu_backend_threadpool.h register.h cpu_backend_context.h register_ref.h cpu_backend_gemm_gemmlowp.h cpu_backend_gemm_params.h cpu_backend_gemm.h padding.h cpu_backend_gemm_ruy.h builtin_op_kernels.h cpu_backend_gemm_custom_gemv.h lstm_eval.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops/: fully_connected.h pooling.h depthwise_conv.h dequantize.h l2normalization.h add.h tanh.h log_softmax.h conv.h mul.h mean.h transpose_conv.h logistic.h
  group eiq/tensorflow-lite/tensorflow/lite/profiling
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/profiling/: buffered_profiler.h time.h profile_summarizer.h platform_profiler.h memory_info.h profiler.h profile_buffer.h noop_profiler.h profile_summary_formatter.h
  group eiq/tensorflow-lite/tensorflow/lite/schema
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/schema/: schema_generated.h
  group eiq/tensorflow-lite/tensorflow/lite/tools
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/tools/: logging.h command_line_flags.h tool_params.h
  group eiq/tensorflow-lite/tensorflow/lite/tools/benchmark
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/tools/benchmark/: benchmark_params.h benchmark_tflite_model.h benchmark_model.h benchmark_utils.h profiling_listener.h
  group eiq/tensorflow-lite/tensorflow/lite/tools/delegates
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/tools/delegates/: delegate_provider.h
  group eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/: reflection.h registry.h reflection_generated.h idl.h code_generators.h stl_emulation.h base.h flexbuffers.h util.h minireflect.h hash.h flatbuffers.h
  group eiq/tensorflow-lite/third_party/absl/base
    ../../../../../middleware/eiq/tensorflow-lite/third_party/absl/base/: attributes.h
  group eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint/: fixedpoint_sse.h fixedpoint_msa.h fixedpoint_neon.h fixedpoint.h
  group eiq/tensorflow-lite/third_party/gemmlowp/internal
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/internal/: pack_sse.h dispatch_gemm_shape.h pack_msa.h simd_wrappers.h common.h kernel_msa.h pack_neon.h platform.h block_params.h single_thread_gemm.h simd_wrappers_msa.h allocator.h unpack.h output_sse.h kernel_default.h simd_wrappers_common_neon_sse.h kernel_dsp.h output_msa.h kernel.h simd_wrappers_sse.h pack.h output.h compute.h simd_wrappers_neon.h kernel_sse.h multi_thread_gemm.h kernel_reference.h detect_platform.h output_neon.h kernel_neon.h
  group eiq/tensorflow-lite/third_party/gemmlowp/meta
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/meta/: quantized_mul_kernels_arm_32.h streams.h legacy_multi_thread_gemm.h legacy_multi_thread_common.h legacy_multi_thread_gemv.h transform_kernels_arm_32.h streams_arm_32.h single_thread_transform.h multi_thread_common.h streams_arm_64.h transform_kernels.h multi_thread_transform.h single_thread_gemm.h legacy_single_thread_gemm.h transform_kernels_arm_64.h base.h legacy_operations_common.h quantized_mul_kernels.h multi_thread_gemm.h quantized_mul_kernels_arm_64.h
  group eiq/tensorflow-lite/third_party/gemmlowp/profiling
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/profiling/: pthread_everywhere.h profiler.h instrumentation.h
  group eiq/tensorflow-lite/third_party/gemmlowp/public
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/public/: bit_depth.h gemmlowp.h config.h map.h output_stages.h
  group eiq/tensorflow-lite/third_party/ruy
    ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/: cpu_cache_params.h tune.h ruy.h dispatch.h mul_params.h time.h common.h size_util.h context.h trmul.h platform.h ctx.h pack_x86.h path.h prepacked_cache.h side_pair.h kernel_x86.h system_aligned_alloc.h allocator.h have_built_path_for.h mat.h ctx_impl.h blocking_counter.h pack_common.h kernel.h pack.h apply_multiplier.h opt_set.h thread_pool.h cpuinfo.h kernel_arm.h trmul_params.h matrix.h block_map.h pack_arm.h check_macros.h kernel_common.h context_get_ctx.h
  group eiq/tensorflow-lite/third_party/ruy/profiler
    ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/profiler/: profiler.h instrumentation.h treeview.h
  group device
    ../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group startup
    ../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group xip
    ../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
