# Keil uVision project tensorflow_lite_lib.uvprojx, settings and files
target tensorflow_lite_lib Debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: tensorflow-lite.lib (library)
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=4 wLevel=3
  c define: DEBUG, __STDC_CONSTANT_MACROS, __CLK_TCK=1000000, CPU_MIMXRT1176DVMAA_cm7, EIGEN_MPL2_ONLY, EIGEN_STACK_ALLOCATION_LIMIT=16384, FARMHASH_MCU, FARMHASH_LITTLE_ENDIAN, FARMHASH_NO_BUILTIN_EXPECT, FLATBUFFERS_LITTLEENDIAN, GEMMLOWP_MCU, RUY_MCU, TFLITE_MCU
  c misc: -Wno-c++98-compat-pedantic  -Wno-c++98-compat  -Wno-c99-extensions  -Wno-cast-qual  -Wno-comment  -Wno-comma  -Wno-conditional-uninitialized  -Wno-conversion  -Wno-covered-switch-default  -Wno-declaration-after-statement  -Wno-deprecated  -Wno-double-promotion  -Wno-exit-time-destructors  -Wno-extern-c-compat  -Wno-extra-semi  -Wno-extra-semi-stmt  -Wno-float-conversion  -Wno-float-equal  -Wno-format-nonliteral  -Wno-global-constructors  -Wno-gnu-zero-variadic-macro-arguments  -Wno-header-hygiene  -Wno-inconsistent-missing-destructor-override  -Wno-ignored-qualifiers  -Wno-missing-field-initializers  -Wno-missing-noreturn  -Wno-missing-prototypes  -Wno-missing-variable-declarations  -Wno-old-style-cast  -Wno-padded  -Wno-shadow  -Wno-shorten-64-to-32  -Wno-sign-compare  -Wno-sign-conversion  -Wno-switch-enum  -Wno-switch  -Wno-strict-prototypes  -Wno-tautological-unsigned-enum-zero-compare  -Wno-typedef-redefinition  -Wno-undef  -Wno-undefined-func-template  -Wno-unknown-warning-option  -Wno-unreachable-code-break  -Wno-unreachable-code-return  -Wno-unreachable-code  -Wno-unused-local-typedef  -Wno-unused-parameter  -Wno-unused-private-field  -Wno-unused-variable  -Wno-unused-template  -Wno-unused-but-set-variable  -Wno-used-but-marked-unused  -Wno-weak-vtables  -Wno-zero-as-null-pointer-constant  -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../middleware/eiq/tensorflow-lite;../../../../../middleware/eiq/tensorflow-lite/third_party/eigen;../../../../../middleware/eiq/tensorflow-lite/third_party/farmhash;../../../../../middleware/eiq/tensorflow-lite/third_party/fft2d;../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include;../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp;../../../../../middleware/eiq/tensorflow-lite/third_party
  asm define: DEBUG, DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group doc
    ../: readme.txt
  group eiq/tensorflow-lite
    ../../../../../middleware/eiq/tensorflow-lite/: AUTHORS LICENSE ChangeLogKSDK.txt readme.txt
  group eiq/tensorflow-lite/tensorflow/lite
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/: graph_info.h configuration.h stderr_reporter.h op_resolver.h interpreter.h simple_memory_arena.h allocation.h context.h string_type.h mutable_op_resolver.h string_util.h interpreter_builder.h builtin_op_data.h minimal_logging.h memory_planner.h arena_planner.h tflite_with_xnnpack_optional.h model.h optional_debug_tools.h version.h builtin_ops.h type_to_tflitetype.h error_reporter.h external_cpu_backend_context.h model_builder.h util.h context_util.h allocation.cpp mutable_op_resolver.cpp interpreter.cpp optional_debug_tools.cpp interpreter_builder.cpp graph_info.cpp string_util.cpp mmap_allocation_disabled.cpp minimal_logging_default.cpp tflite_with_xnnpack_optional.cpp minimal_logging.cpp stderr_reporter.cpp util.cpp configuration.cpp simple_memory_arena.cpp model_builder.cpp external_cpu_backend_context.cpp arena_planner.cpp
  group eiq/tensorflow-lite/tensorflow/lite/experimental/resource
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/experimental/resource/: resource_variable.h resource_base.h resource_variable.cpp
  group eiq/tensorflow-lite/tensorflow/lite/delegates
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/delegates/: utils.h interpreter_utils.h status.h interpreter_utils.cpp utils.cpp
  group eiq/tensorflow-lite/tensorflow/lite/delegates/utils
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/delegates/utils/: simple_delegate.h simple_delegate.cpp
  group eiq/tensorflow-lite/tensorflow/lite/kernels
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/: fully_connected.h lstm_shared.h custom_ops_register.h op_macros.h cpu_backend_gemm_eigen.h kernel_util.h eigen_support.h dequantize.h cpu_backend_threadpool.h register.h cpu_backend_context.h register_ref.h cpu_backend_gemm_gemmlowp.h cpu_backend_gemm_params.h cpu_backend_gemm.h padding.h cpu_backend_gemm_ruy.h builtin_op_kernels.h cpu_backend_gemm_custom_gemv.h lstm_eval.h range.cpp sub.cpp unique.cpp register.cpp neg.cpp tile.cpp concatenation.cpp gather.cpp l2norm.cpp batch_to_space_nd.cpp shape.cpp lstm_eval.cpp transpose.cpp bidirectional_sequence_lstm.cpp space_to_batch_nd.cpp audio_spectrogram.cpp detection_postprocess.cpp split.cpp round.cpp transpose_conv.cpp segment_sum.cpp gather_nd.cpp floor_mod.cpp assign_variable.cpp mfcc.cpp register_ref.cpp numeric_verify.cpp resize_bilinear.cpp add.cpp resize_nearest_neighbor.cpp mul.cpp fully_connected.cpp cpu_backend_context.cpp sparse_to_dense.cpp densify.cpp hashtable_lookup.cpp maximum_minimum.cpp elementwise.cpp matrix_diag.cpp cast.cpp depth_to_space.cpp where.cpp lsh_projection.cpp conv.cpp while.cpp reduce.cpp lstm.cpp pooling.cpp fill.cpp depthwise_conv.cpp ceil.cpp rfft2d.cpp pack.cpp cpu_backend_gemm_eigen.cpp matrix_set_diag.cpp slice.cpp zeros_like.cpp mirror_pad.cpp expand_dims.cpp activations.cpp split_v.cpp comparisons.cpp basic_rnn.cpp exp.cpp space_to_depth.cpp kernel_util.cpp scatter_nd.cpp arg_min_max.cpp logical.cpp eigen_support.cpp embedding_lookup.cpp add_n.cpp embedding_lookup_sparse.cpp pow.cpp reverse.cpp dequantize.cpp if.cpp reshape.cpp squared_difference.cpp unidirectional_sequence_lstm.cpp bidirectional_sequence_rnn.cpp fake_quant.cpp quantize.cpp local_response_norm.cpp select.cpp unidirectional_sequence_rnn.cpp reverse_sequence.cpp non_max_suppression.cpp div.cpp topk_v2.cpp unpack.cpp rank.cpp floor.cpp one_hot.cpp strided_slice.cpp squeeze.cpp batch_matmul.cpp floor_div.cpp skip_gram.cpp pad.cpp svdf.cpp
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/: common.h types.h strided_slice_logic.h min.h legacy_types.h tensor_ctypes.h spectrogram.h max.h tensor_utils.h cppmath.h quantization_util.h kernel_utils.h mfcc_mel_filterbank.h mfcc_dct.h mfcc.h transpose_utils.h tensor.h compatibility.h quantization_util.cpp mfcc_.cpp transpose_utils.cpp spectrogram.cpp mfcc_dct.cpp kernel_utils.cpp tensor_utils.cpp mfcc_mel_filterbank.cpp
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized/: optimized_ops.h neon_tensor_utils.h eigen_spatial_convolutions.h multithreaded_conv.h sse_tensor_utils.h cpu_check.h depthwiseconv_multithread.h sse_tensor_utils_impl.h depthwiseconv_uint8_3x3_filter.h depthwiseconv_uint8_transitional.h legacy_optimized_ops.h depthwiseconv_float.h neon_tensor_utils_impl.h neon_check.h im2col_utils.h sse_check.h eigen_tensor_reduced_instantiations_oss.h eigen_tensor_reduced_instantiations_google.h depthwiseconv_uint8.h depthwiseconv_3x3_filter_common.h batch_matmul.h sse_tensor_utils.cpp neon_tensor_utils.cpp cpu_check.cpp
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized/integer_ops
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized/integer_ops/: fully_connected.h pooling.h depthwise_conv.h depthwise_conv_3x3_filter.h add.h conv.h mul.h mean.h depthwise_conv_hybrid.h transpose_conv.h depthwise_conv_hybrid_3x3_filter.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized/sparse_ops
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized/sparse_ops/: fully_connected.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/: process_broadcast_shapes.h legacy_reference_ops.h fully_connected.h reference_ops.h non_max_suppression.h round.h portable_tensor_utils.h maximum_minimum.h pooling.h svdf.h arg_min_max.h sub.h dequantize.h resize_nearest_neighbor.h neg.h l2normalization.h concatenation.h add.h tanh.h conv.h mul.h densify.h depthwiseconv_float.h quantize.h strided_slice.h portable_tensor_utils_impl.h comparisons.h ceil.h reduce.h logistic.h binary_function.h prelu.h requantize.h depthwiseconv_uint8.h softmax.h floor.h batch_matmul.h pad.h portable_tensor_utils.cpp
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops/: fully_connected.h pooling.h depthwise_conv.h dequantize.h l2normalization.h add.h tanh.h log_softmax.h conv.h mul.h mean.h transpose_conv.h logistic.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/sparse_ops
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/sparse_ops/: fully_connected.h
  group eiq/tensorflow-lite/tensorflow/lite/nnapi
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/nnapi/: NeuralNetworksShim.h
  group eiq/tensorflow-lite/tensorflow/lite/profiling
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/profiling/: buffered_profiler.h time.h profile_summarizer.h platform_profiler.h memory_info.h profiler.h profile_buffer.h noop_profiler.h profile_summary_formatter.h profile_summarizer.cpp time.cpp platform_profiler.cpp memory_info.cpp profile_summary_formatter.cpp
  group eiq/tensorflow-lite/tensorflow/lite/schema
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/schema/: schema_generated.h
  group eiq/tensorflow-lite/tensorflow/lite/c
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/c/: common.h c_api_internal.h c_api.h builtin_op_data.h common.c c_api.cpp
  group eiq/tensorflow-lite/tensorflow/lite/core
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/: subgraph.h macros.h subgraph.cpp
  group eiq/tensorflow-lite/tensorflow/lite/core/api
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/api/: op_resolver.h tensor_utils.h profiler.h flatbuffer_conversions.h error_reporter.h flatbuffer_conversions.cpp error_reporter.cpp op_resolver.cpp tensor_utils_.cpp
  group eiq/tensorflow-lite/tensorflow/lite/tools
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/tools/: logging.h command_line_flags.h tool_params.h command_line_flags.cpp tool_params.cpp
  group eiq/tensorflow-lite/tensorflow/lite/tools/benchmark
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/tools/benchmark/: profiling_listener.cpp benchmark_utils.cpp benchmark_params.h benchmark_tflite_model.h benchmark_model.h benchmark_utils.h profiling_listener.h
  group eiq/tensorflow-lite/tensorflow/lite/tools/delegates
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/tools/delegates/: delegate_provider.h default_execution_provider.cpp
  group eiq/tensorflow-lite/tensorflow/lite/tools/optimize/sparsity
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/tools/optimize/sparsity/: format_converter.cpp format_converter.h
  group eiq/tensorflow-lite/tensorflow/core/util
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/core/util/: stat_summarizer_options.h stats_calculator.h stats_calculator.cpp
  group eiq/tensorflow-lite/tensorflow/core/public
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/core/public/: version.h session.h
  group eiq/tensorflow-lite/third_party/eigen
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/: COPYING.BSD COPYING.LGPL README.md COPYING.MINPACK COPYING.MPL2 COPYING.README
  group eiq/tensorflow-lite/third_party/eigen/Eigen
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/: MetisSupport SparseLU SPQRSupport StdList Sparse StdVector Eigen PardisoSupport PaStiXSupport StdDeque Jacobi Geometry SuperLUSupport LU UmfPackSupport Dense KLUSupport Householder SparseQR IterativeLinearSolvers SparseCholesky QtAlignedMalloc OrderingMethods QR Cholesky CholmodSupport Core SparseCore SVD Eigenvalues
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Cholesky
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Cholesky/: LDLT.h LLT.h LLT_LAPACKE.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/CholmodSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/CholmodSupport/: CholmodSupport.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/: DiagonalProduct.h Fuzzy.h DenseStorage.h ForceAlignedAccess.h Array.h ProductEvaluators.h Product.h Redux.h CwiseBinaryOp.h DiagonalMatrix.h Reverse.h Matrix.h Ref.h NumTraits.h StlIterators.h IndexedView.h Transpositions.h DenseBase.h Transpose.h PartialReduxEvaluator.h GlobalFunctions.h Assign.h NoAlias.h CwiseTernaryOp.h AssignEvaluator.h SelfCwiseBinaryOp.h Random.h PlainObjectBase.h Reshaped.h Swap.h CwiseNullaryOp.h GeneralProduct.h ReturnByValue.h ArrayBase.h Assign_MKL.h Diagonal.h IO.h BooleanRedux.h SolverBase.h Visitor.h MathFunctions.h ArrayWrapper.h MapBase.h CwiseUnaryView.h MatrixBase.h VectorBlock.h VectorwiseOp.h MathFunctionsImpl.h CoreEvaluators.h ConditionEstimator.h Dot.h Stride.h Block.h GenericPacketMath.h TriangularMatrix.h StableNorm.h EigenBase.h ArithmeticSequence.h BandMatrix.h Solve.h Select.h Replicate.h SolveTriangular.h SelfAdjointView.h PermutationMatrix.h DenseCoeffsBase.h CwiseUnaryOp.h Inverse.h Map.h CommaInitializer.h NestByValue.h CoreIterators.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/AltiVec
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/AltiVec/: Complex.h MathFunctions.h PacketMath.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/AVX
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/AVX/: Complex.h MathFunctions.h TypeCasting.h PacketMath.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/AVX512
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/AVX512/: Complex.h MathFunctions.h TypeCasting.h PacketMath.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/CUDA
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/CUDA/: Complex.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/Default
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/Default/: BFloat16.h GenericPacketMathFunctions.h Half.h GenericPacketMathFunctionsFwd.h TypeCasting.h ConjHelper.h Settings.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/GPU
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/GPU/: MathFunctions.h TypeCasting.h PacketMath.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/MSA
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/MSA/: Complex.h MathFunctions.h PacketMath.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/NEON
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/NEON/: Complex.h MathFunctions.h TypeCasting.h PacketMath.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/SSE
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/SSE/: Complex.h MathFunctions.h TypeCasting.h PacketMath.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/SYCL
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/SYCL/: MathFunctions.h TypeCasting.h PacketMath.h SyclMemoryModel.h InteropHeaders.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/ZVector
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/arch/ZVector/: Complex.h MathFunctions.h PacketMath.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/functors
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/functors/: UnaryFunctors.h BinaryFunctors.h AssignmentFunctors.h TernaryFunctors.h NullaryFunctors.h StlFunctors.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/products
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/products/: SelfadjointRank2Update.h TriangularMatrixMatrix.h TriangularMatrixVector.h Parallelizer.h SelfadjointMatrixMatrix.h GeneralMatrixMatrixTriangular.h SelfadjointProduct.h TriangularMatrixVector_BLAS.h GeneralBlockPanelKernel.h GeneralMatrixMatrix_BLAS.h GeneralMatrixVector.h SelfadjointMatrixVector_BLAS.h SelfadjointMatrixMatrix_BLAS.h GeneralMatrixMatrixTriangular_BLAS.h GeneralMatrixMatrix.h TriangularMatrixMatrix_BLAS.h TriangularSolverMatrix_BLAS.h SelfadjointMatrixVector.h TriangularSolverVector.h TriangularSolverMatrix.h GeneralMatrixVector_BLAS.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/util
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Core/util/: XprHelper.h ReshapedHelper.h NonMPL2.h IndexedViewHelper.h ReenableStupidWarnings.h Memory.h ConfigureVectorization.h BlasUtil.h DisableStupidWarnings.h Constants.h ForwardDeclarations.h IntegralConstant.h MKL_support.h Meta.h SymbolicIndex.h StaticAssert.h Macros.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Eigenvalues
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Eigenvalues/: GeneralizedEigenSolver.h RealSchur.h EigenSolver.h GeneralizedSelfAdjointEigenSolver.h SelfAdjointEigenSolver.h MatrixBaseEigenvalues.h RealQZ.h ComplexEigenSolver.h HessenbergDecomposition.h ComplexSchur_LAPACKE.h RealSchur_LAPACKE.h SelfAdjointEigenSolver_LAPACKE.h Tridiagonalization.h ComplexSchur.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Geometry
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Geometry/: Homogeneous.h ParametrizedLine.h Hyperplane.h Translation.h AngleAxis.h Umeyama.h Transform.h OrthoMethods.h Rotation2D.h AlignedBox.h Scaling.h RotationBase.h EulerAngles.h Quaternion.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Geometry/arch
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Geometry/arch/: Geometry_SSE.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Householder
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Householder/: BlockHouseholder.h Householder.h HouseholderSequence.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/IterativeLinearSolvers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/IterativeLinearSolvers/: LeastSquareConjugateGradient.h IncompleteCholesky.h IterativeSolverBase.h SolveWithGuess.h BiCGSTAB.h ConjugateGradient.h BasicPreconditioners.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/Jacobi
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/Jacobi/: Jacobi.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/KLUSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/KLUSupport/: KLUSupport.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/LU
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/LU/: InverseImpl.h PartialPivLU.h PartialPivLU_LAPACKE.h FullPivLU.h Determinant.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/LU/arch
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/LU/arch/: Inverse_SSE.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/MetisSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/MetisSupport/: MetisSupport.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/misc
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/misc/: lapacke_mangling.h blas.h lapack.h lapacke.h RealSvd2x2.h Kernel.h Image.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/OrderingMethods
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/OrderingMethods/: Ordering.h Amd.h Eigen_Colamd.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/PardisoSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/PardisoSupport/: PardisoSupport.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/PaStiXSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/PaStiXSupport/: PaStiXSupport.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/plugins
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/plugins/: ArrayCwiseUnaryOps.h ReshapedMethods.h BlockMethods.h IndexedViewMethods.h CommonCwiseBinaryOps.h ArrayCwiseBinaryOps.h CommonCwiseUnaryOps.h MatrixCwiseUnaryOps.h MatrixCwiseBinaryOps.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/QR
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/QR/: ColPivHouseholderQR.h FullPivHouseholderQR.h HouseholderQR.h ColPivHouseholderQR_LAPACKE.h CompleteOrthogonalDecomposition.h HouseholderQR_LAPACKE.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/SparseCholesky
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/SparseCholesky/: SimplicialCholesky_impl.h SimplicialCholesky.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/SparseCore
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/SparseCore/: SparseCwiseBinaryOp.h SparseSparseProductWithPruning.h SparseUtil.h SparseDiagonalProduct.h SparseDot.h TriangularSolver.h SparseView.h SparseFuzzy.h SparseMatrix.h SparseTriangularView.h ConservativeSparseSparseProduct.h SparseVector.h SparseRedux.h SparseSelfAdjointView.h SparseDenseProduct.h SparseCwiseUnaryOp.h SparseAssign.h CompressedStorage.h SparseMap.h SparseRef.h SparseTranspose.h MappedSparseMatrix.h SparseColEtree.h SparseMatrixBase.h SparseBlock.h AmbiVector.h SparseCompressedBase.h SparsePermutation.h SparseProduct.h SparseSolverBase.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/SparseLU
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/SparseLU/: SparseLU_Structs.h SparseLU_panel_dfs.h SparseLU_pivotL.h SparseLU_Memory.h SparseLU_panel_bmod.h SparseLU.h SparseLUImpl.h SparseLU_copy_to_ucol.h SparseLU_heap_relax_snode.h SparseLU_kernel_bmod.h SparseLU_column_dfs.h SparseLU_SupernodalMatrix.h SparseLU_relax_snode.h SparseLU_Utils.h SparseLU_column_bmod.h SparseLU_pruneL.h SparseLU_gemm_kernel.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/SparseQR
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/SparseQR/: SparseQR.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/SPQRSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/SPQRSupport/: SuiteSparseQRSupport.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/StlSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/StlSupport/: details.h StdDeque.h StdList.h StdVector.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/SuperLUSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/SuperLUSupport/: SuperLUSupport.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/SVD
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/SVD/: JacobiSVD_LAPACKE.h SVDBase.h BDCSVD.h UpperBidiagonalization.h JacobiSVD.h
  group eiq/tensorflow-lite/third_party/eigen/Eigen/src/UmfPackSupport
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/Eigen/src/UmfPackSupport/: UmfPackSupport.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/: MoreVectorization AlignedVector3 KroneckerProduct NonLinearOptimization Splines MPRealSupport ArpackSupport Polynomials OpenGLSupport MatrixFunctions AutoDiff SpecialFunctions FFT LevenbergMarquardt SparseExtra AdolcForward NumericalDiff IterativeSolvers Skyline BVH EulerAngles
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/: TensorSymmetry Tensor ThreadPool
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/Tensor
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/Tensor/: TensorTraits.h TensorUInt128.h TensorScanSycl.h TensorImagePatch.h TensorBroadcasting.h TensorGenerator.h TensorScan.h TensorBase.h TensorLayoutSwap.h TensorIntDiv.h TensorRandom.h TensorPatch.h TensorExecutor.h TensorInitializer.h TensorConvolutionSycl.h TensorDimensionList.h TensorContractionThreadPool.h TensorTrace.h TensorChipping.h TensorInflation.h TensorContractionGpu.h TensorStorage.h TensorRef.h TensorGpuHipCudaUndefines.h TensorConvolution.h TensorBlockV2.h TensorFunctors.h TensorIO.h TensorMacros.h TensorDeviceThreadPool.h TensorDeviceGpu.h TensorContractionSycl.h TensorMorphing.h TensorContraction.h TensorBlock.h TensorEvalTo.h TensorExpr.h TensorContractionCuda.h TensorDeviceSycl.h Tensor.h TensorContractionMapper.h TensorGpuHipCudaDefines.h TensorCustomOp.h TensorCostModel.h TensorStriding.h TensorDimensions.h TensorAssign.h TensorForwardDeclarations.h TensorShuffling.h TensorContractionBlocking.h TensorMeta.h TensorDeviceDefault.h TensorMap.h TensorDevice.h TensorReductionGpu.h TensorConcatenation.h TensorArgMax.h TensorFixedSize.h TensorConversion.h TensorReductionCuda.h TensorReduction.h TensorGlobalFunctions.h TensorEvaluator.h TensorReverse.h TensorVolumePatch.h TensorDeviceCuda.h TensorForcedEval.h TensorPadding.h TensorReductionSycl.h TensorFFT.h TensorIndexList.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/TensorSymmetry
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/TensorSymmetry/: DynamicSymmetry.h Symmetry.h StaticSymmetry.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/TensorSymmetry/util
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/TensorSymmetry/util/: TemplateGroupTheory.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/ThreadPool
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/ThreadPool/: ThreadEnvironment.h ThreadPoolInterface.h Barrier.h ThreadCancel.h EventCount.h ThreadYield.h ThreadLocal.h RunQueue.h NonBlockingThreadPool.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/util
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/CXX11/src/util/: CXX11Meta.h EmulateArray.h CXX11Workarounds.h MaxSizeVector.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/AutoDiff
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/AutoDiff/: AutoDiffJacobian.h AutoDiffVector.h AutoDiffScalar.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/BVH
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/BVH/: BVAlgorithms.h KdBVH.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/EulerAngles
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/EulerAngles/: EulerAngles.h EulerSystem.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/FFT
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/FFT/: ei_kissfft_impl.h ei_fftw_impl.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/IterativeSolvers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/IterativeSolvers/: IncompleteLU.h GMRES.h DGMRES.h MINRES.h Scaling.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/KroneckerProduct
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/KroneckerProduct/: KroneckerTensorProduct.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/LevenbergMarquardt
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/LevenbergMarquardt/: LMpar.h LevenbergMarquardt.h LMqrsolv.h LMcovar.h LMonestep.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/MatrixFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/MatrixFunctions/: MatrixSquareRoot.h MatrixExponential.h MatrixLogarithm.h MatrixFunction.h StemFunction.h MatrixPower.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/MoreVectorization
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/MoreVectorization/: MathFunctions.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/NonLinearOptimization
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/NonLinearOptimization/: fdjac1.h HybridNonLinearSolver.h chkder.h r1mpyq.h LevenbergMarquardt.h covar.h lmpar.h qrsolv.h r1updt.h rwupdt.h dogleg.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/NumericalDiff
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/NumericalDiff/: NumericalDiff.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/Polynomials
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/Polynomials/: PolynomialSolver.h PolynomialUtils.h Companion.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/Skyline
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/Skyline/: SkylineUtil.h SkylineInplaceLU.h SkylineMatrix.h SkylineStorage.h SkylineProduct.h SkylineMatrixBase.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/SparseExtra
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/SparseExtra/: BlockOfDynamicSparseMatrix.h MarketIO.h MatrixMarketIterator.h BlockSparseMatrix.h RandomSetter.h DynamicSparseMatrix.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/SpecialFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/SpecialFunctions/: SpecialFunctionsFunctors.h SpecialFunctionsArrayAPI.h BesselFunctionsBFloat16.h BesselFunctionsFunctors.h SpecialFunctionsBFloat16.h BesselFunctionsPacketMath.h BesselFunctionsHalf.h SpecialFunctionsHalf.h BesselFunctionsImpl.h HipVectorCompatibility.h SpecialFunctionsImpl.h BesselFunctionsArrayAPI.h SpecialFunctionsPacketMath.h
  group eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/Splines
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen/unsupported/Eigen/src/Splines/: Spline.h SplineFwd.h SplineFitting.h
  group eiq/tensorflow-lite/third_party/eigen3
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen3/: LICENSE
  group eiq/tensorflow-lite/third_party/eigen3/Eigen
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen3/Eigen/: LU SparseCholesky OrderingMethods QR Cholesky Core SparseCore SVD Eigenvalues
  group eiq/tensorflow-lite/third_party/eigen3/unsupported/Eigen
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen3/unsupported/Eigen/: MatrixFunctions SpecialFunctions
  group eiq/tensorflow-lite/third_party/eigen3/unsupported/Eigen/CXX11
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen3/unsupported/Eigen/CXX11/: FixedPoint Tensor ThreadPool
  group eiq/tensorflow-lite/third_party/eigen3/unsupported/Eigen/CXX11/src/FixedPoint
    ../../../../../middleware/eiq/tensorflow-lite/third_party/eigen3/unsupported/Eigen/CXX11/src/FixedPoint/: MatVecProduct.h PacketMathAVX2.h PacketMathAVX512.h FixedPointTypes.h MatMatProductAVX2.h TypeCastingAVX2.h MatMatProduct.h MatMatProductNEON.h TypeCastingAVX512.h
  group eiq/tensorflow-lite/third_party/farmhash
    ../../../../../middleware/eiq/tensorflow-lite/third_party/farmhash/: COPYING farmhash.cpp farmhash.h
  group eiq/tensorflow-lite/third_party/fft2d
    ../../../../../middleware/eiq/tensorflow-lite/third_party/fft2d/: fftsg.c fft2d.h fft.h readme.txt LICENSE
  group eiq/tensorflow-lite/third_party/flatbuffers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/: readme.md LICENSE.txt
  group eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/: reflection.h registry.h reflection_generated.h idl.h code_generators.h stl_emulation.h base.h flexbuffers.h util.h minireflect.h hash.h flatbuffers.h
  group eiq/tensorflow-lite/third_party/gemmlowp
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/: AUTHORS CONTRIBUTORS LICENSE README.md
  group eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint/: fixedpoint_sse.h fixedpoint_msa.h fixedpoint_neon.h fixedpoint.h
  group eiq/tensorflow-lite/third_party/gemmlowp/internal
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/internal/: pack_sse.h dispatch_gemm_shape.h pack_msa.h simd_wrappers.h common.h kernel_msa.h pack_neon.h platform.h block_params.h single_thread_gemm.h simd_wrappers_msa.h allocator.h unpack.h output_sse.h kernel_default.h simd_wrappers_common_neon_sse.h kernel_dsp.h output_msa.h kernel.h simd_wrappers_sse.h pack.h output.h compute.h simd_wrappers_neon.h kernel_sse.h multi_thread_gemm.h kernel_reference.h detect_platform.h output_neon.h kernel_neon.h
  group eiq/tensorflow-lite/third_party/gemmlowp/meta
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/meta/: quantized_mul_kernels_arm_32.h streams.h legacy_multi_thread_gemm.h legacy_multi_thread_common.h legacy_multi_thread_gemv.h transform_kernels_arm_32.h streams_arm_32.h single_thread_transform.h multi_thread_common.h streams_arm_64.h transform_kernels.h multi_thread_transform.h single_thread_gemm.h legacy_single_thread_gemm.h transform_kernels_arm_64.h base.h legacy_operations_common.h quantized_mul_kernels.h multi_thread_gemm.h quantized_mul_kernels_arm_64.h
  group eiq/tensorflow-lite/third_party/gemmlowp/profiling
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/profiling/: pthread_everywhere.h profiler.h instrumentation.h
  group eiq/tensorflow-lite/third_party/gemmlowp/public
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/public/: bit_depth.h gemmlowp.h config.h map.h output_stages.h config.cpp
  group eiq/tensorflow-lite/third_party/absl
    ../../../../../middleware/eiq/tensorflow-lite/third_party/absl/: LICENSE
  group eiq/tensorflow-lite/third_party/absl/base
    ../../../../../middleware/eiq/tensorflow-lite/third_party/absl/base/: port.h optimization.h config.h macros.h policy_checks.h attributes.h
  group eiq/tensorflow-lite/third_party/absl/memory
    ../../../../../middleware/eiq/tensorflow-lite/third_party/absl/memory/: memory.h
  group eiq/tensorflow-lite/third_party/absl/meta
    ../../../../../middleware/eiq/tensorflow-lite/third_party/absl/meta/: type_traits.h
  group eiq/tensorflow-lite/third_party/ruy
    ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/: LICENSE cpu_cache_params.h tune.h ruy.h dispatch.h mul_params.h time.h common.h size_util.h context.h trmul.h platform.h ctx.h pack_x86.h path.h prepacked_cache.h side_pair.h kernel_x86.h system_aligned_alloc.h allocator.h have_built_path_for.h mat.h ctx_impl.h blocking_counter.h pack_common.h kernel.h pack.h apply_multiplier.h opt_set.h thread_pool.h cpuinfo.h kernel_arm.h trmul_params.h matrix.h block_map.h pack_arm.h check_macros.h kernel_common.h context_get_ctx.h trmul.cpp pack_avx2.cpp cpuinfo.cpp have_built_path_for_sse42.cpp kernel_avxvnni.cpp kernel_arm64.cpp blocking_counter.cpp have_built_path_for_avxvnni.cpp allocator.cpp system_aligned_alloc.cpp pack_avx512.cpp tune.cpp context_get_ctx.cpp kernel_sse42.cpp apply_multiplier.cpp kernel_avx512.cpp kernel_avx2.cpp thread_pool.cpp prepacked_cache.cpp ctx.cpp context.cpp have_built_path_for_avx512.cpp have_built_path_for_avx2.cpp pack_sse42.cpp block_map.cpp kernel_arm32.cpp pack_avxvnni.cpp pack_arm.cpp
  group eiq/tensorflow-lite/third_party/ruy/profiler
    ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/profiler/: profiler.h instrumentation.h treeview.h profiler.cpp treeview.cpp instrumentation.cpp
target tensorflow_lite_lib Release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: tensorflow-lite.lib (library)
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=4 wLevel=3
  c define: NDEBUG, __STDC_CONSTANT_MACROS, __CLK_TCK=1000000, CPU_MIMXRT1176DVMAA_cm7, EIGEN_MPL2_ONLY, EIGEN_STACK_ALLOCATION_LIMIT=16384, FARMHASH_MCU, FARMHASH_LITTLE_ENDIAN, FARMHASH_NO_BUILTIN_EXPECT, FLATBUFFERS_LITTLEENDIAN, GEMMLOWP_MCU, RUY_MCU, TFLITE_MCU
  c misc: -fno-exceptions  -Wno-c++98-compat-pedantic  -Wno-c++98-compat  -Wno-c99-extensions  -Wno-cast-qual  -Wno-comment  -Wno-comma  -Wno-conditional-uninitialized  -Wno-conversion  -Wno-covered-switch-default  -Wno-declaration-after-statement  -Wno-deprecated  -Wno-double-promotion  -Wno-exit-time-destructors  -Wno-extern-c-compat  -Wno-extra-semi  -Wno-extra-semi-stmt  -Wno-float-conversion  -Wno-float-equal  -Wno-format-nonliteral  -Wno-global-constructors  -Wno-gnu-zero-variadic-macro-arguments  -Wno-header-hygiene  -Wno-inconsistent-missing-destructor-override  -Wno-ignored-qualifiers  -Wno-missing-field-initializers  -Wno-missing-noreturn  -Wno-missing-prototypes  -Wno-missing-variable-declarations  -Wno-old-style-cast  -Wno-padded  -Wno-shadow  -Wno-shorten-64-to-32  -Wno-sign-compare  -Wno-sign-conversion  -Wno-switch-enum  -Wno-switch  -Wno-strict-prototypes  -Wno-tautological-unsigned-enum-zero-compare  -Wno-typedef-redefinition  -Wno-undef  -Wno-undefined-func-template  -Wno-unknown-warning-option  -Wno-unreachable-code-break  -Wno-unreachable-code-return  -Wno-unreachable-code  -Wno-unused-local-typedef  -Wno-unused-parameter  -Wno-unused-private-field  -Wno-unused-variable  -Wno-unused-template  -Wno-unused-but-set-variable  -Wno-used-but-marked-unused  -Wno-weak-vtables  -Wno-zero-as-null-pointer-constant  -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: as above
  asm define: NDEBUG, NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
