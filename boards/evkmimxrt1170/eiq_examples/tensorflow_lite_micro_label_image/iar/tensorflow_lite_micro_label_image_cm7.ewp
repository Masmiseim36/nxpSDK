# IAR project tensorflow_lite_micro_label_image_cm7.ewp, settings and files
configuration flexspi_nor_sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; SDK_DEBUGCONSOLE_UART; ARM_MATH_CM7; __FPU_PRESENT=1; SDK_I2C_BASED_COMPONENT_USED=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; FLATBUFFERS_LITTLEENDIAN; GEMMLOWP_MCU; RUY_MCU; TFLITE_MCU; TF_LITE_STATIC_MEMORY
  ICCARM.CCDiagSuppress: Pa082,Pa084,Pa093,Pe111,Pe174,Pe186,Pe550,Pe611,Pe997,Pe1444
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.CCIncludePath2: ../../../../../middleware/eiq/tensorflow-lite/examples/micro/label_image; ../../../../../middleware/eiq/tensorflow-lite/examples/image/label_image; ../../../../../middleware/eiq/common/image; ../../../../../middleware/eiq/common/model; ..; ../../../../../components/video/camera; ../../../../../components/video/camera/device; ../../../../../components/video/camera/device/sccb; ../../../../../components/video/camera/device/ov5640; ../../../../../components/video/camera/receiver/csi; ../../../../../components/video/camera/receiver; ../../../../../devices/MIMXRT1176/drivers; ../../../../../components/video/display/dc; ../../../../../components/video/display/dc/elcdif; ../../../../../components/video/display/dc/lcdifv2; ../../../../../components/video/display; ../../../../../components/video/display/mipi_dsi_cmd; ../../../../../components/video/display/rm68191; ../../../../../components/video/display/rm68200; ../../../../../components/video; ../../../../../components/video/i2c; ../../../../../devices/MIMXRT1176/utilities/debug_console_lite; ../../../../../middleware/eiq/tensorflow-lite; ../../../../../middleware/eiq/common/video; ../../../../../components/lists; ../../../../../components/uart; ../../../../../devices/MIMXRT1176; ../../../../../CMSIS/Include; ../../../../../devices/MIMXRT1176/xip; ../../../xip; ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis; ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include; ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp; ../../../../../middleware/eiq/tensorflow-lite/third_party; ../../../../../middleware/eiq/common
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: tensorflow_lite_micro_label_image_cm7.out
  ILINK.IlinkConfigDefines: __stack_size__=0x10000; __heap_size__=0x800000
  ILINK.IlinkIcfFile: ../../../../../devices/MIMXRT1176/iar/MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; SDK_DEBUGCONSOLE_UART; ARM_MATH_CM7; __FPU_PRESENT=1; SDK_I2C_BASED_COMPONENT_USED=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; FLATBUFFERS_LITTLEENDIAN; GEMMLOWP_MCU; RUY_MCU; TFLITE_MCU; TF_LITE_STATIC_MEMORY
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../../../../../middleware/eiq/common/: demo_info.h timer.h timer.c eiq_common.h eiq_iui.h eiq_iworker.h
    ../../../../../middleware/eiq/tensorflow-lite/examples/micro/label_image/: demo_config.h demo_info.cpp
    ../../../../../middleware/eiq/tensorflow-lite/examples/image/label_image/: labels.h
    ../../../../../middleware/eiq/tensorflow-lite/examples/image/: main.cpp
  group source/image
    ../../../../../middleware/eiq/common/image/: image_conv_rotate.c image.h image_capture.c image_decode_raw.c image_resize_nearest.c image_draw.c image_utils.h
    ../../../../../middleware/eiq/tensorflow-lite/examples/micro/label_image/: image_data.h
  group source/model
    ../../../../../middleware/eiq/common/model/: get_top_n.cpp get_top_n.h model.h output_postproc.h
    ../../../../../middleware/eiq/tensorflow-lite/examples/common/model/: output_postproc.cpp
    ../../../../../middleware/eiq/tensorflow-lite/examples/micro/label_image/: model.cpp model_mobilenet_ops_micro.cpp
    ../../../../../middleware/eiq/tensorflow-lite/examples/image/label_image/: model_data.h
  group source/video
    ../../../../../middleware/eiq/common/video/camera/RM68191_RM68200/: eiq_camera_conf.c
    ../../../../../middleware/eiq/common/video/display/RK055AHD091_RK055IQH091/: eiq_display_conf.c
    ../../../../../middleware/eiq/common/video/: eiq_display.c eiq_video_worker.c eiq_pxp.c eiq_camera.c eiq_video_worker.h eiq_pxp.h eiq_camera_conf.h eiq_display_conf.h eiq_display.h eiq_camera.h
  group board
    ../../../../../middleware/eiq/common/: board_init.h
    ../: pin_mux.c pin_mux.h board.c board.h board_init.c clock_config.c clock_config.h dcd.c dcd.h
    ./: retarget.c
  group doc
    ../../../../../middleware/eiq/tensorflow-lite/examples/image/label_image/: labels.txt mobilenet_v1_0.25_128_quant_int8.tflite stopwatch.bmp
    ../: readme.txt
  group video
    ../../../../../components/video/camera/: fsl_camera.h
    ../../../../../components/video/camera/device/: fsl_camera_device.h
    ../../../../../components/video/camera/device/sccb/: fsl_sccb.h fsl_sccb.c
    ../../../../../components/video/camera/device/ov5640/: fsl_ov5640.h fsl_ov5640.c
    ../../../../../components/video/camera/receiver/csi/: fsl_csi_camera_adapter.h fsl_csi_camera_adapter.c
    ../../../../../components/video/camera/receiver/: fsl_camera_receiver.h
    ../../../../../components/video/display/dc/: fsl_dc_fb.h
    ../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.h fsl_dc_fb_elcdif.c
    ../../../../../components/video/display/dc/lcdifv2/: fsl_dc_fb_lcdifv2.h fsl_dc_fb_lcdifv2.c
    ../../../../../components/video/display/: fsl_display.h
    ../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
    ../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../components/video/i2c/: fsl_video_i2c.h fsl_video_i2c.c
  group drivers
    ../../../../../devices/MIMXRT1176/drivers/: fsl_csi.c fsl_csi.h fsl_common.h fsl_common.c fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_elcdif.c fsl_elcdif.h fsl_gpio.h fsl_gpio.c fsl_mipi_csi2rx.c fsl_mipi_csi2rx.h fsl_pxp.c fsl_pxp.h fsl_soc_mipi_csi2rx.h fsl_soc_mipi_csi2rx.c fsl_soc_src.h fsl_soc_src.c fsl_lpuart.h fsl_lpuart.c fsl_dcdc.h fsl_dcdc.c fsl_pmu.h fsl_pmu.c fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_anatop_ai.h fsl_anatop_ai.c fsl_lcdifv2.c fsl_lcdifv2.h
  group utilities
    ../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group eiq/tensorflow-lite/tensorflow/core/public
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/core/public/: version.h
  group eiq/tensorflow-lite/tensorflow/lite
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/: type_to_tflitetype.h version.h string_type.h string_util.h string_util.cpp
  group eiq/tensorflow-lite/tensorflow/lite/c
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/c/: common.h common.c builtin_op_data.h
  group eiq/tensorflow-lite/tensorflow/lite/core/api
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/api/: op_resolver.h tensor_utils.h profiler.h flatbuffer_conversions.h error_reporter.h flatbuffer_conversions.cpp error_reporter.cpp op_resolver.cpp tensor_utils_.cpp
  group eiq/tensorflow-lite/tensorflow/lite/kernels
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/: kernel_util.h kernel_util.cpp op_macros.h padding.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/: common.h compatibility.h cppmath.h max.h min.h quantization_util.h quantization_util.cpp strided_slice_logic.h tensor.h tensor_ctypes.h types.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized/: neon_check.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/: add.h arg_min_max.h ceil.h comparisons.h concatenation.h conv.h depthwiseconv_float.h depthwiseconv_uint8.h dequantize.h process_broadcast_shapes.h quantize.h requantize.h floor.h fully_connected.h l2normalization.h binary_function.h logistic.h maximum_minimum.h mul.h neg.h pad.h pooling.h prelu.h reduce.h resize_nearest_neighbor.h round.h softmax.h strided_slice.h sub.h tanh.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops/: add.h conv.h depthwise_conv.h fully_connected.h l2normalization.h logistic.h mul.h pooling.h tanh.h
  group eiq/tensorflow-lite/tensorflow/lite/micro
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/: micro_op_resolver.h recording_micro_allocator.h micro_utils.h micro_time.h micro_mutable_op_resolver.h micro_string.h micro_error_reporter.h micro_interpreter.h micro_profiler.h recording_micro_interpreter.h all_ops_resolver.h debug_log.h memory_helpers.h recording_simple_memory_allocator.h micro_allocator.h simple_memory_allocator.h micro_optional_debug_tools.h compatibility.h micro_error_reporter.cpp simple_memory_allocator.cpp micro_utils.cpp micro_interpreter.cpp micro_profiler.cpp micro_time.cpp micro_string.cpp micro_optional_debug_tools.cpp micro_allocator.cpp memory_helpers.cpp debug_log.cpp all_ops_resolver.cpp recording_micro_allocator.cpp recording_simple_memory_allocator.cpp
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/: micro_utils.h micro_ops.h activation_utils.h activations.cpp arg_min_max.cpp ceil.cpp circular_buffer.cpp comparisons.cpp concatenation.cpp dequantize.cpp elementwise.cpp ethosu.cpp floor.cpp l2norm.cpp logical.cpp logistic.cpp maximum_minimum.cpp neg.cpp pack.cpp pad.cpp prelu.cpp quantize.cpp reduce.cpp reshape.cpp resize_nearest_neighbor.cpp round.cpp split.cpp strided_slice.cpp sub.cpp svdf.cpp tanh.cpp unpack.cpp
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels/cmsis-nn
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/cmsis-nn/: add.cpp mul.cpp fully_connected.cpp softmax.cpp conv.cpp pooling.cpp depthwise_conv.cpp
  group eiq/tensorflow-lite/tensorflow/lite/micro/memory_planner
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.h linear_memory_planner.h memory_planner.h linear_memory_planner.cpp greedy_memory_planner.cpp
  group eiq/tensorflow-lite/tensorflow/lite/schema
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/schema/: schema_generated.h
  group eiq/tensorflow-lite/third_party/cmsis
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/: LICENSE.txt
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/Core/Include
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/Core/Include/: cmsis_compiler.h core_cm35p.h core_cm4.h core_cm0plus.h cachel1_armv7.h mpu_armv8.h core_cm1.h pmu_armv8.h core_cm7.h tz_context.h cmsis_armcc.h core_sc000.h core_armv8mml.h core_sc300.h cmsis_armclang.h cmsis_iccarm.h core_cm0.h core_armv8mbl.h core_cm33.h mpu_armv7.h core_armv81mml.h cmsis_gcc.h core_cm3.h core_cm55.h cmsis_version.h core_cm23.h cmsis_armclang_ltm.h
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/DSP/Include
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/DSP/Include/: arm_math.h arm_math_f16.h arm_mve_tables.h arm_mve_tables_f16.h arm_common_tables.h arm_const_structs.h arm_common_tables_f16.h arm_vec_math.h arm_const_structs_f16.h arm_helium_utils.h
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Include
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Include/: arm_nn_types.h arm_nnsupportfunctions.h arm_nnfunctions.h arm_nn_tables.h
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ActivationFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ActivationFunctions/: arm_relu_q15.c arm_relu_q7.c arm_relu6_s8.c arm_nn_activations_q7.c arm_nn_activations_q15.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/BasicMathFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/BasicMathFunctions/: arm_elementwise_mul_s8.c arm_elementwise_add_s8.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ConcatenationFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ConcatenationFunctions/: arm_concatenation_s8_w.c arm_concatenation_s8_z.c arm_concatenation_s8_y.c arm_concatenation_s8_x.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ConvolutionFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ConvolutionFunctions/: arm_convolve_wrapper_s8.c arm_convolve_HWC_q7_basic.c arm_convolve_1_x_n_s8.c arm_depthwise_conv_3x3_s8.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_convolve_HWC_q7_basic_nonsquare.c arm_depthwise_separable_conv_HWC_q7.c arm_convolve_s8.c arm_depthwise_conv_s8_opt.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_1x1_s8_fast.c arm_nn_mat_mult_kernel_s8_s16_reordered.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q7_RGB.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_mat_mult_s8.c arm_convolve_HWC_q15_basic.c arm_depthwise_conv_u8_basic_ver1.c arm_convolve_HWC_q7_fast.c arm_nn_mat_mult_kernel_s8_s16.c arm_nn_depthwise_conv_s8_core.c arm_depthwise_conv_s8.c arm_nn_mat_mult_kernel_q7_q15.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/FullyConnectedFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_q7.c arm_fully_connected_q15_opt.c arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_q7_opt.c arm_fully_connected_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_s8.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/NNSupportFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/NNSupportFunctions/: arm_nn_mult_q15.c arm_nntables.c arm_nn_vec_mat_mult_t_s8.c arm_nn_mat_mult_nt_t_s8.c arm_nn_mat_mul_core_4x_s8.c arm_nn_mult_q7.c arm_q7_to_q15_reordered_no_shift.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_depthwise_conv_nt_t_padded_s8.c arm_q7_to_q15_no_shift.c arm_nn_add_q7.c arm_q7_to_q15_with_offset.c arm_nn_accumulate_q7_to_q15.c arm_nn_mat_mul_core_1x_s8.c arm_q7_to_q15_reordered_with_offset.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/PoolingFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/PoolingFunctions/: arm_max_pool_s8.c arm_pool_q7_HWC.c arm_avgpool_s8.c arm_max_pool_s8_opt.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ReshapeFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ReshapeFunctions/: arm_reshape_s8.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/SoftmaxFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/SoftmaxFunctions/: arm_softmax_q7.c arm_softmax_u8.c arm_softmax_s8.c arm_softmax_q15.c arm_softmax_with_batch_q7.c
  group eiq/tensorflow-lite/third_party/flatbuffers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/: readme.md LICENSE.txt
  group eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/: reflection.h registry.h reflection_generated.h idl.h code_generators.h stl_emulation.h base.h flexbuffers.h util.h minireflect.h hash.h flatbuffers.h
  group eiq/tensorflow-lite/third_party/gemmlowp
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/: AUTHORS CONTRIBUTORS LICENSE README.md
  group eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint/: fixedpoint_sse.h fixedpoint_msa.h fixedpoint_neon.h fixedpoint.h
  group eiq/tensorflow-lite/third_party/gemmlowp/internal
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/internal/: pack_sse.h dispatch_gemm_shape.h pack_msa.h simd_wrappers.h common.h kernel_msa.h pack_neon.h platform.h block_params.h single_thread_gemm.h simd_wrappers_msa.h allocator.h unpack.h output_sse.h kernel_default.h simd_wrappers_common_neon_sse.h kernel_dsp.h output_msa.h kernel.h simd_wrappers_sse.h pack.h output.h compute.h simd_wrappers_neon.h kernel_sse.h multi_thread_gemm.h kernel_reference.h detect_platform.h output_neon.h kernel_neon.h
  group eiq/tensorflow-lite/third_party/gemmlowp/meta
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/meta/: quantized_mul_kernels_arm_32.h streams.h legacy_multi_thread_gemm.h legacy_multi_thread_common.h legacy_multi_thread_gemv.h transform_kernels_arm_32.h streams_arm_32.h single_thread_transform.h multi_thread_common.h streams_arm_64.h transform_kernels.h multi_thread_transform.h single_thread_gemm.h legacy_single_thread_gemm.h transform_kernels_arm_64.h base.h legacy_operations_common.h quantized_mul_kernels.h multi_thread_gemm.h quantized_mul_kernels_arm_64.h
  group eiq/tensorflow-lite/third_party/gemmlowp/profiling
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/profiling/: pthread_everywhere.h profiler.h instrumentation.h
  group eiq/tensorflow-lite/third_party/gemmlowp/public
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/public/: bit_depth.h gemmlowp.h config.h map.h output_stages.h config.cpp
  group eiq/tensorflow-lite/third_party/ruy
    ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/: LICENSE cpu_cache_params.h tune.h ruy.h dispatch.h mul_params.h time.h common.h size_util.h context.h trmul.h platform.h ctx.h pack_x86.h path.h prepacked_cache.h side_pair.h kernel_x86.h system_aligned_alloc.h allocator.h have_built_path_for.h mat.h ctx_impl.h blocking_counter.h pack_common.h kernel.h pack.h apply_multiplier.h opt_set.h thread_pool.h cpuinfo.h kernel_arm.h trmul_params.h matrix.h block_map.h pack_arm.h check_macros.h kernel_common.h context_get_ctx.h trmul.cpp pack_avx2.cpp cpuinfo.cpp have_built_path_for_sse42.cpp kernel_avxvnni.cpp kernel_arm64.cpp blocking_counter.cpp have_built_path_for_avxvnni.cpp allocator.cpp system_aligned_alloc.cpp pack_avx512.cpp tune.cpp context_get_ctx.cpp kernel_sse42.cpp apply_multiplier.cpp kernel_avx512.cpp kernel_avx2.cpp thread_pool.cpp prepacked_cache.cpp ctx.cpp context.cpp have_built_path_for_avx512.cpp have_built_path_for_avx2.cpp pack_sse42.cpp block_map.cpp kernel_arm32.cpp pack_avxvnni.cpp pack_arm.cpp
  group eiq/tensorflow-lite/third_party/ruy/profiler
    ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/profiler/: profiler.h instrumentation.h treeview.h profiler.cpp treeview.cpp instrumentation.cpp
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group device
    ../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group startup
    ../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group xip
    ../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
