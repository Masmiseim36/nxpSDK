# Keil uVision project tflm_modelrunner_cm7.uvprojx, settings and files
target tflm_modelrunner_cm7 flexspi_nor_sdram_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: tflm_modelrunner_cm7.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=0, XIP_BOOT_HEADER_XMCD_ENABLE=1, USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, DEBUG, __STDC_CONSTANT_MACROS, __CLK_TCK=1000000, CPU_MIMXRT1176DVMAA_cm7, MODEL_SIZE=28*1024*1024, PRINTF_ADVANCED_ENABLE=1, PRINTF_FLOAT_ENABLE=1, USE_RTOS=1, MODELRUNNER_HTTP=1, FSL_RTOS_FREE_RTOS, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SDK_OS_FREE_RTOS, FSL_RTOS_BM, SDK_DEBUGCONSOLE_UART, ARM_MATH_CM7, __FPU_PRESENT=1, SDK_I2C_BASED_COMPONENT_USED=1, TF_LITE_STATIC_MEMORY, MCUXPRESSO_SDK, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, LWIP_DISABLE_PBUF_POOL_SIZE_SANITY_CHECKS=1, CHECKSUM_GEN_ICMP6=1, CHECKSUM_CHECK_ICMP6=1
  c misc: -ffp-mode=full  -fno-exceptions  -Wno-c++17-extensions  -fno-common  -fdata-sections  -mthumb
  c include: ../source;..;../source/common;../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F;../../../../../../devices/MIMXRT1176/drivers;../../../../../../middleware/lwip/port;../../../../../../middleware/lwip/src;../../../../../../middleware/lwip/src/include;../../../../../../devices/MIMXRT1176/drivers/cm7;../../../../../../components/phy/device/phyksz8081;../../../../../../components/phy/device/phyrtl8211f;../../../../../../components/silicon_id/socs;../../../../../../components/silicon_id;../../../../../../devices/MIMXRT1176/utilities/debug_console_lite;../../../../../../middleware/eiq/tensorflow-lite;../../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include;../../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp;../../../../../../components/lists;../../../../../../components/uart;../../../../../../devices/MIMXRT1176;../../../../../../devices/MIMXRT1176/xip;../../../../xip;../../../../xmcd;../../../../../../components/phy;../../../../../../components/gpio;../../../../../../devices/MIMXRT1176/utilities/str;../../../../../../middleware/eiq/tensorflow-lite/third_party/ruy;../../../../../../CMSIS/Core/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../source;../../../../../../rtos/freertos/freertos-kernel/include
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.scf
  link misc: ../../../../../../middleware/eiq/tensorflow-lite/lib/cm7/mdk/tflm.lib --remove --predefine="-D__stack_size__=0x17000" --predefine="-D__heap_size__=0x2000000" --entry=Reset_Handler --diag_suppress 6314 --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-DXIP_BOOT_HEADER_DCD_ENABLE=0" --predefine="-DXIP_BOOT_HEADER_XMCD_ENABLE=1" --predefine="-D__stack_size__=0x2000"
  group source
    ../source/: main.cpp modelrunner.h modelrunner.cpp tf_benchmark.h tf_benchmark.cpp json_results.cpp http.h app.h http.cpp http_handler.h http_handler.cpp FreeRTOSConfig.h lwipopts.h
  group source/cJSON
    ../source/cJSON/: cJSON.h cJSON.c
  group source/base64
    ../source/base64/: base64.h base64.c
  group source/picohttpparser
    ../source/picohttpparser/: picohttpparser.h picohttpparser.c
  group scripts
    ../scripts/: cli.py main.py modelrunner.py xexpect.py requirements.txt
  group board
    ../: flash_opts.h flash_opts.c clock_config.c clock_config.h dcd.c dcd.h pin_mux.c pin_mux.h clock_config.h clock_config.c board.c board.h
    ./: retarget.c
    ../../../../xmcd/: xmcd.c xmcd.h
  group source/common
    ../source/common/: eiq_common.h eiq_iui.h eiq_iworker.h
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable/GCC/ARM_CM4F
    ../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_3.c
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_enet.h fsl_enet.c fsl_romapi.h fsl_romapi.c fsl_gpt.c fsl_gpt.h fsl_lpuart.h fsl_lpuart.c fsl_dcdc.h fsl_dcdc.c fsl_pmu.h fsl_pmu.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_gpio.h fsl_gpio.c fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_memory.h fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group lwip/port
    ../../../../../../middleware/lwip/port/: enet_ethernetif.c ethernetif.c ethernetif.h ethernetif_mmac.c ethernetif_mmac.h ethernetif_priv.h kinetis_configchecks.h enet_ethernetif_kinetis.c sys_arch.c
  group lwip/port/arch
    ../../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src/api
    ../../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/core
    ../../../../../../middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/src/core/ipv4
    ../../../../../../middleware/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/src/core/ipv6
    ../../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip/src/include/compat/posix/arpa
    ../../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/compat/posix/net
    ../../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix
    ../../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/sys
    ../../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/stdc
    ../../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/lwip
    ../../../../../../middleware/lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/priv
    ../../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../../middleware/lwip/src/include/lwip/prot/: acd.h autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip/src/include/netif
    ../../../../../../middleware/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lwip/src/include/netif/ppp
    ../../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip/src/netif
    ../../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group component/phy
    ../../../../../../components/phy/device/phyksz8081/: fsl_phyksz8081.h fsl_phyksz8081.c
    ../../../../../../components/phy/device/phyrtl8211f/: fsl_phyrtl8211f.h fsl_phyrtl8211f.c
    ../../../../../../components/phy/: fsl_phy.h
  group component/silicon_id
    ../../../../../../components/silicon_id/socs/imxrt1170/: fsl_silicon_id_soc.c
    ../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
    ../../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
  group eiq/tensorflow-lite/tensorflow/lite/micro
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/: debug_log.cpp compatibility.h debug_log.h fake_micro_context.h flatbuffer_utils.h memory_helpers.h micro_allocation_info.h micro_allocator.h micro_arena_constants.h micro_common.h micro_context.h micro_graph.h micro_interpreter.h micro_interpreter_context.h micro_interpreter_graph.h micro_log.h micro_mutable_op_resolver.h micro_op_resolver.h micro_profiler.h micro_profiler_interface.h micro_resource_variable.h micro_time.h micro_utils.h mock_micro_graph.h recording_micro_allocator.h recording_micro_interpreter.h system_setup.h test_helper_custom_ops.h test_helpers.h
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group startup
    ../../../../../../devices/MIMXRT1176/arm/: startup_MIMXRT1176_cm7.S
  group xip
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
  group component/gpio
    ../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group eiq/tensorflow-lite
    ../../../../../../middleware/eiq/tensorflow-lite/: AUTHORS LICENSE NOTICE ChangeLogKSDK.txt readme.txt
  group eiq/tensorflow-lite/signal/micro/kernels
    ../../../../../../middleware/eiq/tensorflow-lite/signal/micro/kernels/: delay_flexbuffers_generated_data.h energy_flexbuffers_generated_data.h fft_flexbuffers_generated_data.h filter_bank_flexbuffers_generated_data.h filter_bank_log_flexbuffers_generated_data.h filter_bank_spectral_subtraction_flexbuffers_generated_data.h framer_flexbuffers_generated_data.h irfft.h overlap_add_flexbuffers_generated_data.h pcan_flexbuffers_generated_data.h rfft.h stacker_flexbuffers_generated_data.h window_flexbuffers_generated_data.h
  group eiq/tensorflow-lite/signal/src
    ../../../../../../middleware/eiq/tensorflow-lite/signal/src/: circular_buffer.h complex.h energy.h fft_auto_scale.h filter_bank.h filter_bank_log.h filter_bank_spectral_subtraction.h filter_bank_square_root.h irfft.h log.h max_abs.h msb.h overlap_add.h pcan_argc_fixed.h rfft.h square_root.h window.h
  group eiq/tensorflow-lite/signal/src/kiss_fft_wrappers
    ../../../../../../middleware/eiq/tensorflow-lite/signal/src/kiss_fft_wrappers/: kiss_fft_common.h kiss_fft_float.h kiss_fft_int16.h kiss_fft_int32.h
  group eiq/tensorflow-lite/tensorflow/lite
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/: builtin_op_data.h builtin_ops.h context_util.h portable_type_to_tflitetype.h
  group eiq/tensorflow-lite/tensorflow/lite/c
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/c/: builtin_op_data.h c_api_types.h common.h
  group eiq/tensorflow-lite/tensorflow/lite/core
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/: macros.h
  group eiq/tensorflow-lite/tensorflow/lite/core/api
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/api/: error_reporter.h flatbuffer_conversions.h tensor_utils.h
  group eiq/tensorflow-lite/tensorflow/lite/core/c
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/c/: builtin_op_data.h c_api_types.h common.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/: kernel_util.h op_macros.h padding.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/: common.h compatibility.h cppmath.h max.h min.h portable_tensor.h portable_tensor_utils.h quantization_util.h runtime_shape.h strided_slice_logic.h tensor_ctypes.h types.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized/: neon_check.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/: add.h add_n.h arg_min_max.h batch_matmul.h batch_to_space_nd.h binary_function.h broadcast_args.h broadcast_to.h ceil.h comparisons.h concatenation.h conv.h cumsum.h depth_to_space.h depthwiseconv_float.h depthwiseconv_uint8.h dequantize.h div.h elu.h exp.h fill.h floor.h floor_div.h floor_mod.h fully_connected.h hard_swish.h l2normalization.h leaky_relu.h log_softmax.h logistic.h lstm_cell.h maximum_minimum.h mul.h neg.h pad.h pooling.h portable_tensor_utils.h portable_tensor_utils_impl.h prelu.h process_broadcast_shapes.h quantize.h reduce.h requantize.h resize_bilinear.h resize_nearest_neighbor.h round.h select.h slice.h softmax.h space_to_batch_nd.h space_to_depth.h strided_slice.h sub.h tanh.h transpose.h transpose_conv.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops/: add.h conv.h depthwise_conv.h fully_connected.h l2normalization.h logistic.h mean.h mul.h pooling.h tanh.h transpose_conv.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/: activation_utils.h activations.h add.h circular_buffer.h circular_buffer_flexbuffers_generated_data.h conv.h conv_test.h depthwise_conv.h dequantize.h detection_postprocess_flexbuffers_generated_data.h ethosu.h fully_connected.h hard_swish.h kernel_runner.h kernel_util.h leaky_relu.h logical.h logistic.h lstm_eval.h lstm_eval_test.h lstm_shared.h micro_ops.h micro_tensor_utils.h mul.h pad.h pooling.h prelu.h quantize.h reduce.h reshape.h softmax.h strided_slice.h sub.h svdf.h unidirectional_sequence_lstm.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/arena_allocator
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/arena_allocator/: ibuffer_allocator.h non_persistent_arena_buffer_allocator.h persistent_arena_buffer_allocator.h recording_single_arena_buffer_allocator.h single_arena_buffer_allocator.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/memory_planner
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.h linear_memory_planner.h memory_plan_struct.h micro_memory_planner.h non_persistent_buffer_planner_shim.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/tflite_bridge
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/tflite_bridge/: flatbuffer_conversions_bridge.h micro_error_reporter.h
  group eiq/tensorflow-lite/tensorflow/lite/schema
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/schema/: schema_generated.h schema_utils.h
  group eiq/tensorflow-lite/third_party/flatbuffers
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/: readme.md LICENSE.txt
  group eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/: allocator.h array.h base.h buffer.h buffer_ref.h default_allocator.h detached_buffer.h flatbuffer_builder.h flatbuffers.h flexbuffers.h stl_emulation.h strings.h struct.h table.h util.h vector.h vector_downward.h verifier.h
  group eiq/tensorflow-lite/third_party/gemmlowp
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/: LICENSE README.md
  group eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint/: fixedpoint.h fixedpoint_neon.h fixedpoint_sse.h
  group eiq/tensorflow-lite/third_party/gemmlowp/internal
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/internal/: detect_platform.h
  group eiq/tensorflow-lite/third_party/ruy
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/: LICENSE README.md
  group eiq/tensorflow-lite/third_party/ruy/ruy/profiler
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/ruy/profiler/: instrumentation.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
  group doc
    ../: readme.md
target tflm_modelrunner_cm7 flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: tflm_modelrunner_cm7.out
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=0, XIP_BOOT_HEADER_XMCD_ENABLE=1, USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, __STDC_CONSTANT_MACROS, __CLK_TCK=1000000, CPU_MIMXRT1176DVMAA_cm7, MODEL_SIZE=28*1024*1024, PRINTF_ADVANCED_ENABLE=1, PRINTF_FLOAT_ENABLE=1, USE_RTOS=1, MODELRUNNER_HTTP=1, FSL_RTOS_FREE_RTOS, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SDK_OS_FREE_RTOS, FSL_RTOS_BM, SDK_DEBUGCONSOLE_UART, ARM_MATH_CM7, __FPU_PRESENT=1, SDK_I2C_BASED_COMPONENT_USED=1, TF_LITE_STATIC_MEMORY, MCUXPRESSO_SDK, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, LWIP_DISABLE_PBUF_POOL_SIZE_SANITY_CHECKS=1, CHECKSUM_GEN_ICMP6=1, CHECKSUM_CHECK_ICMP6=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: as above
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.scf
  link misc: as above
