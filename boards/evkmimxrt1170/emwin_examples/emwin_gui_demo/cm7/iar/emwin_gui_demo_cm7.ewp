# IAR project emwin_gui_demo_cm7.ewp, settings and files
configuration flexspi_nor_sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=0; XIP_BOOT_HEADER_XMCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../common/cm7; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../components/ft5406_rt; ../../../../../../components/video; ../../../../../../components/video/display; ../../../../../../components/video/display/rm68191; ../../../../../../components/video/display/mipi_dsi_cmd; ../../../../../../components/video/display/rm68200; ../../../../../../components/video/display/dc/lcdifv2; ../../../../../../components/gt911; ../../../../../../components/video/display/dc/elcdif; ../../../../../../devices/MIMXRT1176/utilities/str; ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite; ../../../../../../components/video/display/hx8394; ../../../../../../middleware/emwin/emWin_header; ../../../../../../middleware/emwin/emWin_Config; ../../../../../../devices/MIMXRT1176; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1176/xip; ../../../../xip; ../../../../../../devices/MIMXRT1176/drivers/cm7; ../../../../xmcd; ../../../../../../components/video/display/dc; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: emwin_gui_demo_cm7.out
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../middleware/emwin/emWin_library/IAR/emWin_M7.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=0; XIP_BOOT_HEADER_XMCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../: display_support.h display_support.c pin_mux.c pin_mux.h emwin_support.c emwin_support.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
    ../../../../xmcd/: xmcd.c xmcd.h
  group source
    ../: emwin_gui_demo.c
  group doc
    ../: readme.txt
  group evkmimxrt1170
    ../: evkmimxrt1170_connect_cm4_cm7side.jlinkscript
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_elcdif.c fsl_elcdif.h fsl_pxp.c fsl_pxp.h fsl_lpi2c.c fsl_lpi2c.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_soc_src.h fsl_soc_src.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_memory.h fsl_soc_mipi_csi2rx.h fsl_soc_mipi_csi2rx.c fsl_lcdifv2.c fsl_lcdifv2.h fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group touchpanel
    ../../../../../../components/ft5406_rt/: fsl_ft5406_rt.h fsl_ft5406_rt.c
    ../../../../../../components/gt911/: fsl_gt911.h fsl_gt911.c
  group video
    ../../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../../components/video/display/: fsl_display.h
    ../../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
    ../../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../../components/video/display/dc/lcdifv2/: fsl_dc_fb_lcdifv2.h fsl_dc_fb_lcdifv2.c
    ../../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.h fsl_dc_fb_elcdif.c
    ../../../../../../components/video/display/hx8394/: fsl_hx8394.h fsl_hx8394.c
    ../../../../../../components/video/display/dc/: fsl_dc_fb.h
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group emwin/emWin_header
    ../../../../../../middleware/emwin/emWin_header/: AppWizard.h BUTTON.h BUTTON_Private.h CALENDAR.h CHECKBOX.h CHECKBOX_Private.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Type.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h GAUGE.h GAUGE_Private.h GRAPH.h GRAPH_Private.h GUI.h GUIDRV_BitPlains.h GUIDRV_DCache.h GUIDRV_DCache_Private.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_FlexColor_Private.h GUIDRV_IST3088.h GUIDRV_IST3088_Private.h GUIDRV_Lin.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_Null.h GUIDRV_S1D13748.h GUIDRV_S1D13748_Private.h GUIDRV_S1D13781.h GUIDRV_S1D13781_Private.h GUIDRV_S1D15G00.h GUIDRV_SH_MEM.h GUIDRV_SH_MEM_Private.h GUIDRV_SLin.h GUIDRV_SLin_Private.h GUIDRV_SPage.h GUIDRV_SPage_Private.h GUIDRV_SSD1926.h GUIDRV_SSD1926_Private.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h GUITDRV_ADS7846.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GCache_Private.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SPRITE_Private.h GUI_SPY_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_Type.h GUI_VNC.h GUI_Version.h GUI__BiDi2_Brackets_800.h GUI__BiDi2_Types_800.h Global.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h IMAGE.h IMAGE_Private.h IP_FS.h KEYBOARD.h KEYBOARD_Private.h KNOB.h KNOB_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MOVIE.h MOVIE_Private.h MULTIEDIT.h MULTIEDIT_Private.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h QRCODE.h QRCODE_Private.h RADIO.h RADIO_Private.h ROTARY.h ROTARY_Private.h SCROLLBAR.h SCROLLBAR_Private.h SCROLLER.h SCROLLER_Private.h SEGGER.h SLIDER.h SLIDER_Private.h SPINBOX.h SPINBOX_Private.h SWIPELIST.h SWIPELIST_Private.h SWITCH.h SWITCH_Private.h TEXT.h TEXT_Private.h TICKER.h TICKER_Private.h TREEVIEW.h TREEVIEW_Private.h WHEEL.h WHEEL_Private.h WIDGET.h WIDGET_ID.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h
  group emwin/emWin_Config
    ../../../../../../middleware/emwin/emWin_Config/: GUIConf.h LCDConf.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group xip
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
