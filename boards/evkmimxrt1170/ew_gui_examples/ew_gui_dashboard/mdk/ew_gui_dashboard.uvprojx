# Keil uVision project ew_gui_dashboard.uvprojx, settings and files
target ew_gui_dashboard flexspi_nor_sdram_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ew_gui_dashboard.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, DEBUG, CPU_MIMXRT1176DVMAA_cm7, SKIP_SYSCLK_INIT, EW_SURFACE_ROTATION=90, EW_USE_FREE_RTOS=1, EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, SDK_I2C_BASED_COMPONENT_USED=1, VG_RESOLVE_ENGINE=0, VG_PE_COLOR_KEY=0, VG_IM_INDEX_FORMAT=0, VG_AYUV_INPUT_OUTPUT=0, VG_DOUBLE_IMAGE=0, VG_RECTANGLE_STRIP_MODE=0, VG_MMU=0, VG_IM_FILTER=0, VG_IM_YUV_PACKET=1, VG_IM_YUV_PLANAR=0, VG_PE_YUV_PACKET=1, VG_TARGET_TILED=1, VG_COMMAND_CALL=1, VG_SHARE_BUFFER_IM_16K=0, VG_OFFLINE_MODE=0, VG_RESOLUTION_2880=0, VG_PE_PREMULTIPLY=0, VG_POST_CONVERTER=0, VG_PRE_CONVERTER=0, VG_RENDER_BY_MESH=0, VG_TARGET_FAST_CLEAR=0, VG_BUFFER_NUMBER_OF_TARGET=0, VG_VIDEO_CLEAR_CONTROL=0, VG_VIDEO_CONTROL=0, VGLITE_TST_FIRMWARE=0, VG_LITE_SYS_GPU_CTRL=0, SDK_OS_FREE_RTOS, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../vglite_examples/vglite_support;..;../cm7;../GeneratedCode;../../../../../devices/MIMXRT1176/drivers;../../../../../components/ft5406_rt;../../../../../components/video;../../../../../components/video/display;../../../../../components/video/display/rm68191;../../../../../components/video/display/mipi_dsi_cmd;../../../../../components/video/display/rm68200;../../../../../components/video/display/dc/lcdifv2;../../../../../components/gt911;../../../../../components/video/display/dc/elcdif;../../../../../devices/MIMXRT1176/utilities/debug_console_lite;../../../../../components/video/display/fbdev;../../../../../middleware/vglite/inc;../../../../../middleware/vglite/font;../../../../../middleware/vglite/font/mcufont/decoder;../../../../../middleware/vglite/VGLite/rtos;../../../../../middleware/vglite/VGLiteKernel;../../../../../middleware/vglite/VGLiteKernel/rtos;../../../../../middleware/EmbeddedWizard/TargetSpecific/evkmimxrt1170;../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1170/RGB565;../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1170/RTE;../../../../../devices/MIMXRT1176;../../../../../components/uart;../../../../../components/lists;../../../../../devices/MIMXRT1176/xip;../../../xip;../../../../../devices/MIMXRT1176/drivers/cm7;../../../../../CMSIS/Core/Include;../../../../../components/video/display/dc;../../../../../rtos/freertos/freertos_kernel/include;../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM4F
  asm define: DEBUG, __STARTUP_CLEAR_BSS, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../cm7
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.scf
  link misc: ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1170/RTE/libewrte-m7-keil.lib ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1170/RGB565/libewgfx-m7-r90-keil.lib --remove --entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group board
    ../: display_support.h display_support.c ewconfig.h ewdef.h pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
    ../../../vglite_examples/vglite_support/: vglite_support.h vglite_support.c
  group source
    ../: main.c ewmain.c ewmain.h DeviceDriver.c DeviceDriver.h
    ../cm7/: FreeRTOSConfig.h
  group GeneratedCode
    ../GeneratedCode/: Application.c Core.c Dashboard.c Effects.c Graphics.c Resources.c Templates.c Views.c WidgetSet.c Application.h Core.h Dashboard.h Effects.h Graphics.h Resources.h Templates.h Views.h WidgetSet.h _ApplicationApplication.h _CoreCursorEvent.h _CoreCursorGrabEvent.h _CoreCursorHit.h _CoreDialogContext.h _CoreDragEvent.h _CoreEvent.h _CoreGroup.h _CoreKeyEvent.h _CoreKeyPressHandler.h _CoreLayoutContext.h _CoreLayoutLineContext.h _CoreLayoutQuadContext.h _CoreLineView.h _CoreModalContext.h _CoreOutline.h _CoreQuadView.h _CoreRectView.h _CoreResource.h _CoreRoot.h _CoreSimpleTouchHandler.h _CoreTask.h _CoreTaskQueue.h _CoreTime.h _CoreTimer.h _CoreView.h _DashboardAnimationClass.h _DashboardArrows.h _DashboardBattery.h _DashboardBatteryEnergy.h _DashboardBatteryFrame.h _DashboardCircle0.h _DashboardCircle1.h _DashboardCircle2.h _DashboardCircle3.h _DashboardCircle4.h _DashboardCircle5.h _DashboardClock.h _DashboardColorsClass.h _DashboardDashboard.h _DashboardDashboardV1.h _DashboardDashboardV2.h _DashboardDemoMode.h _DashboardDeviceClass.h _DashboardFontL.h _DashboardFontLightL.h _DashboardFontLightM.h _DashboardFontLightXL.h _DashboardFontXL.h _DashboardFontXXL.h _DashboardGauge.h _DashboardGaugeDisplay.h _DashboardGaugeGlowSegment.h _DashboardGaugeIndicator.h _DashboardGaugeLabels.h _DashboardGaugeNeedle.h _DashboardIcons.h _DashboardLeftBottomGloomV1.h _DashboardLeftGlowV2.h _DashboardLeftWing2V2.h _DashboardLeftWingV2.h _DashboardLogo.h _DashboardMap.h _DashboardMapFading.h _DashboardNavigation.h _DashboardNavigationHints.h _DashboardOffIcon.h _DashboardPosition.h _DashboardRightBottomGloomV1.h _DashboardRightGlowV2.h _DashboardRightWing2V2.h _DashboardRightWingV2.h _DashboardStartEngine.h _DashboardStartEngineGloom.h _DashboardStartEngineStates.h _DashboardStartScreen.h _DashboardSwitchIcon.h _DashboardTopGloomV1.h _DashboardVertValueBar.h _EffectsEffect.h _EffectsEffectTimerClass.h _EffectsFadeInOutTransition.h _EffectsFader.h _EffectsFaderTask.h _EffectsFloatEffect.h _EffectsInt32Effect.h _EffectsOpacityFader.h _EffectsPointEffect.h _EffectsPositionFader.h _EffectsShowHideTransition.h _EffectsTimingList.h _EffectsTransition.h _EffectsVisibilityFader.h _GraphicsArcPath.h _GraphicsCanvas.h _GraphicsPath.h _GraphicsWarpMatrix.h _ResourcesBitmap.h _ResourcesDefaultFont.h _ResourcesFont.h _ResourcesWhiteBitmapStripe.h _TemplatesHorizontalValueBar.h _TemplatesVerticalValueBar.h _ViewsFillPath.h _ViewsFrame.h _ViewsImage.h _ViewsLine.h _ViewsRectangle.h _ViewsStrokePath.h _ViewsText.h _ViewsWallpaper.h _ViewsWarpGroup.h _ViewsWarpImage.h _ViewsWarpView.h _WidgetSetPushButton.h _WidgetSetPushButtonConfig.h _WidgetSetToggleButton.h _WidgetSetToggleButtonConfig.h _WidgetSetValueDisplay.h _WidgetSetValueDisplayConfig.h _WidgetSetWidgetConfig.h ewlocale.h
  group doc
    ../: readme.txt
  group evkmimxrt1170
    ../: evkmimxrt1170_connect_cm4_cm7side.jlinkscript
  group drivers
    ../../../../../devices/MIMXRT1176/drivers/: fsl_elcdif.c fsl_elcdif.h fsl_pxp.c fsl_pxp.h fsl_lpi2c.c fsl_lpi2c.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_soc_src.h fsl_soc_src.c fsl_snvs_hp.c fsl_snvs_hp.h fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_memory.h fsl_anatop_ai.h fsl_anatop_ai.c fsl_soc_mipi_csi2rx.h fsl_soc_mipi_csi2rx.c fsl_lcdifv2.c fsl_lcdifv2.h
    ../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group touchpanel
    ../../../../../components/ft5406_rt/: fsl_ft5406_rt.h fsl_ft5406_rt.c
    ../../../../../components/gt911/: fsl_gt911.h fsl_gt911.c
  group video
    ../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../components/video/display/: fsl_display.h
    ../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
    ../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../components/video/display/dc/lcdifv2/: fsl_dc_fb_lcdifv2.h fsl_dc_fb_lcdifv2.c
    ../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.h fsl_dc_fb_elcdif.c
    ../../../../../components/video/display/fbdev/: fsl_fbdev.h fsl_fbdev.c
    ../../../../../components/video/display/dc/: fsl_dc_fb.h
  group utilities
    ../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group vglite/inc
    ../../../../../middleware/vglite/inc/: vg_lite.h vg_lite_hal.h vg_lite_text.h
  group vglite/VGLite
    ../../../../../middleware/vglite/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c
  group vglite/VGLite/rtos
    ../../../../../middleware/vglite/VGLite/rtos/: vg_lite_os.h vg_lite_os.c
  group vglite/font
    ../../../../../middleware/vglite/font/: buf_reader.c buf_reader.h fonts.h rle_font_read.c vft_debug.c vft_debug.h vft_draw.c vft_draw.h vg_lite_text.c
  group vglite/font/mcufont/decoder
    ../../../../../middleware/vglite/font/mcufont/decoder/: mcufont.h mf_bwfont.c mf_bwfont.h mf_config.h mf_encoding.c mf_encoding.h mf_font.c mf_font.h mf_justify.c mf_justify.h mf_kerning.c mf_kerning.h mf_rlefont.c mf_rlefont.h mf_scaledfont.c mf_scaledfont.h mf_wordwrap.c mf_wordwrap.h
  group vglite/font/mcufont
    ../../../../../middleware/vglite/font/mcufont/: LICENSE
  group vglite/VGLiteKernel
    ../../../../../middleware/vglite/VGLiteKernel/: vg_lite_hw.h vg_lite_kernel.h vg_lite_kernel.c
  group vglite/VGLiteKernel/rtos
    ../../../../../middleware/vglite/VGLiteKernel/rtos/: vg_lite_hal.c vg_lite_platform.h
  group vglite
    ../../../../../middleware/vglite/: ChangeLogKSDK.txt
  group EmbeddedWizard/TargetSpecific/evkmimxrt1170
    ../../../../../middleware/EmbeddedWizard/TargetSpecific/evkmimxrt1170/: ew_bsp_clock.c ew_bsp_console.c ew_bsp_display.c ew_bsp_event.c ew_bsp_inout.c ew_bsp_system.c ew_bsp_touch.c ew_bsp_clock.h ew_bsp_console.h ew_bsp_display.h ew_bsp_event.h ew_bsp_inout.h ew_bsp_system.h ew_bsp_touch.h
  group EmbeddedWizard/PlatformPackage/evkmimxrt1170/RGB565
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1170/RGB565/: ewextbmp.h ewextfnt.h ewextgfx.h ewextpxl_RGB565.h ewgfx.h ewgfxcore.h ewgfxdefs.h ewgfxdriver.h ewgfxlinks.h ewgfxres.h ewgfxtasks.h
  group EmbeddedWizard/PlatformPackage/evkmimxrt1170/RTE
    ../../../../../middleware/EmbeddedWizard/PlatformPackage/evkmimxrt1170/RTE/: ewextrte.c ewextrte.h ewrte.h
  group device
    ../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMXRT1176/arm/: startup_MIMXRT1176_cm7.S
  group xip
    ../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group freertos/freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    ../../../../../rtos/freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos_kernel/portable/GCC/ARM_CM4F
    ../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos/freertos_kernel/portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
target ew_gui_dashboard flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ew_gui_dashboard.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, CPU_MIMXRT1176DVMAA_cm7, SKIP_SYSCLK_INIT, EW_SURFACE_ROTATION=90, EW_USE_FREE_RTOS=1, EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, SDK_I2C_BASED_COMPONENT_USED=1, VG_RESOLVE_ENGINE=0, VG_PE_COLOR_KEY=0, VG_IM_INDEX_FORMAT=0, VG_AYUV_INPUT_OUTPUT=0, VG_DOUBLE_IMAGE=0, VG_RECTANGLE_STRIP_MODE=0, VG_MMU=0, VG_IM_FILTER=0, VG_IM_YUV_PACKET=1, VG_IM_YUV_PLANAR=0, VG_PE_YUV_PACKET=1, VG_TARGET_TILED=1, VG_COMMAND_CALL=1, VG_SHARE_BUFFER_IM_16K=0, VG_OFFLINE_MODE=0, VG_RESOLUTION_2880=0, VG_PE_PREMULTIPLY=0, VG_POST_CONVERTER=0, VG_PRE_CONVERTER=0, VG_RENDER_BY_MESH=0, VG_TARGET_FAST_CLEAR=0, VG_BUFFER_NUMBER_OF_TARGET=0, VG_VIDEO_CLEAR_CONTROL=0, VG_VIDEO_CONTROL=0, VGLITE_TST_FIRMWARE=0, VG_LITE_SYS_GPU_CTRL=0, SDK_OS_FREE_RTOS, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_CLEAR_BSS, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../cm7
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.scf
  link misc: as above
