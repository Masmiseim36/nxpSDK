# Keil uVision project fmstr_example_net_cm7.uvprojx, settings and files
target fmstr_example_net_cm7 flexspi_nor_sdram_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: fmstr_example_net_cm7.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=0, XIP_BOOT_HEADER_XMCD_ENABLE=1, USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, DEBUG, CPU_MIMXRT1176DVMAA_cm7, USE_RTOS=1, SDK_DEBUGCONSOLE=1, PHY_KSZ8081=1, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, FSL_ETH_ENABLE_CACHE_CONTROL=1, LWIP_ENET_FLEXIBLE_CONFIGURATION, MCUXPRESSO_SDK, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, LWIP_DISABLE_PBUF_POOL_SIZE_SANITY_CHECKS=1, SERIAL_PORT_TYPE_UART=1, SDK_OS_FREE_RTOS
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../common/fmstr_example;../../../../../../components/phy/device/phyksz8081;../../../../../../components/phy/device/phyrtl8211f;../../../../../../devices/MIMXRT1176/drivers;../../../../../../middleware/lwip/port;../../../../../../middleware/lwip/src;../../../../../../middleware/lwip/src/include;../../../../../../devices/MIMXRT1176/drivers/cm7;../../../../../../components/silicon_id/socs;../../../../../../components/silicon_id;../../../../../../middleware/freemaster/src/common;../../../../../../devices/MIMXRT1176;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../devices/MIMXRT1176/xip;../../../../xip;../../../../../../middleware/freemaster/src/platforms/gen32le;../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can;../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial;../../../../xmcd;../../../../../../components/phy;../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F;../../../../../../devices/MIMXRT1176/utilities/str;../../../../../../devices/MIMXRT1176/utilities/debug_console;../../../../../../CMSIS/Core/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314 --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-DXIP_BOOT_HEADER_DCD_ENABLE=0" --predefine="-DXIP_BOOT_HEADER_XMCD_ENABLE=1" --predefine="-D__stack_size__=0x800" --predefine="-D__heap_size__=0x7000"
  group source
    ../: main.c freemaster_cfg.h network.c network.h FreeRTOSConfig.h FreeRTOSConfigBoard.h lwipopts.h network_enet.c
    ../../../common/fmstr_example/: freemaster_example.c freemaster_example.h
  group board
    ../: clock_config.c clock_config.h pin_mux.c pin_mux.h board.c board.h dcd.c dcd.h
    ../../../../xmcd/: xmcd.c xmcd.h
  group doc
    ../: readme.txt
  group source/example_data
    ../../../common/fmstr_example/: data_example_pmp.h data_img_logo.h data_img_file.h data_img_fmstrlogo.h data_html_index.h example_data.h
  group component/phy
    ../../../../../../components/phy/device/phyksz8081/: fsl_phyksz8081.h fsl_phyksz8081.c
    ../../../../../../components/phy/device/phyrtl8211f/: fsl_phyrtl8211f.h fsl_phyrtl8211f.c
    ../../../../../../components/phy/: fsl_phy.h
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_enet.h fsl_enet.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_memory.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group lwip/port
    ../../../../../../middleware/lwip/port/: enet_ethernetif.c ethernetif.c ethernetif.h ethernetif_mmac.c ethernetif_mmac.h ethernetif_priv.h enet_sanitychecks.h enet_ethernetif_kinetis.c sys_arch.c
  group lwip/port/arch
    ../../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src/api
    ../../../../../../middleware/lwip/src/api/: sockets.c netifapi.c netdb.c netbuf.c tcpip.c api_msg.c err.c if_api.c api_lib.c
  group lwip/src/core
    ../../../../../../middleware/lwip/src/core/: memp.c def.c ip.c pbuf.c altcp.c tcp_out.c raw.c altcp_tcp.c sys.c init.c inet_chksum.c timeouts.c tcp_in.c netif.c mem.c udp.c tcp.c stats.c dns.c altcp_alloc.c
  group lwip/src/core/ipv6
    ../../../../../../middleware/lwip/src/core/ipv6/: ethip6.c dhcp6.c ip6_addr.c nd6.c mld6.c icmp6.c ip6_frag.c ip6.c inet6.c
  group lwip/src/core/ipv4
    ../../../../../../middleware/lwip/src/core/ipv4/: dhcp.c ip4.c autoip.c icmp.c acd.c etharp.c ip4_addr.c igmp.c ip4_frag.c
  group lwip/src/include/compat/stdc
    ../../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/compat/posix
    ../../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/sys
    ../../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/posix/net
    ../../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/lwip
    ../../../../../../middleware/lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/priv
    ../../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h mem_priv.h memp_priv.h memp_std.h api_msg.h nd6_priv.h tcpip_priv.h tcp_priv.h raw_priv.h sockets_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../../middleware/lwip/src/include/lwip/prot/: ip6.h udp.h mld6.h ip4.h icmp.h igmp.h dhcp.h tcp.h autoip.h iana.h ieee.h dns.h icmp6.h ethernet.h nd6.h ip.h acd.h dhcp6.h etharp.h
  group lwip/src/include/netif
    ../../../../../../middleware/lwip/src/include/netif/: bridgeif.h zepif.h lowpan6.h ieee802154.h ethernet.h lowpan6_common.h lowpan6_opts.h bridgeif_opts.h slipif.h lowpan6_ble.h etharp.h
  group lwip/src/include/netif/ppp
    ../../../../../../middleware/lwip/src/include/netif/ppp/: ipv6cp.h pppapi.h magic.h ppp.h upap.h mppe.h pppol2tp.h pppoe.h ipcp.h pppdebug.h eap.h pppos.h ppp_opts.h pppcrypt.h vj.h chap-new.h eui64.h chap_ms.h ccp.h ecp.h lcp.h fsm.h ppp_impl.h chap-md5.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: sha1.h des.h md5.h md4.h arc4.h
  group lwip/src/netif
    ../../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: heap_3.c ReadMe.url
  group component/silicon_id
    ../../../../../../components/silicon_id/socs/imxrt1170/: fsl_silicon_id_soc.c
    ../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
    ../../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group freemaster
    ../../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_defcfg.h freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h freemaster_can.c freemaster_can.h freemaster_sha.c freemaster_pdbdm.c freemaster_serial.c freemaster_serial.h freemaster_net.c freemaster_net.h
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/: fsl_assert.c
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1176/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMXRT1176/arm/: startup_MIMXRT1176_cm7.S
  group xip
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
  group freemaster/platforms
    ../../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group freemaster/drivers
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mscan.c freemaster_mscan.h freemaster_mcan.c freemaster_mcan.h
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_usb.c freemaster_serial_usb.h
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/network/: freemaster_net_segger_rtt.c freemaster_net_segger_rtt.h freemaster_net_lwip_udp.c freemaster_net_lwip_udp.h freemaster_net_lwip_tcp.c freemaster_net_lwip_tcp.h
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable/GCC/ARM_CM4F
    ../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
target fmstr_example_net_cm7 flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: fmstr_example_net_cm7.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1176DVMAA_cm7, USE_RTOS=1, SDK_DEBUGCONSOLE=1, PHY_KSZ8081=1, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, FSL_ETH_ENABLE_CACHE_CONTROL=1, LWIP_ENET_FLEXIBLE_CONFIGURATION, MCUXPRESSO_SDK, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, LWIP_DISABLE_PBUF_POOL_SIZE_SANITY_CHECKS=1, SERIAL_PORT_TYPE_UART=1, SDK_OS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314 --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-D__stack_size__=0x800" --predefine="-D__heap_size__=0x7000"
target fmstr_example_net_cm7 flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: fmstr_example_net_cm7.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=0, XIP_BOOT_HEADER_XMCD_ENABLE=1, USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, CPU_MIMXRT1176DVMAA_cm7, USE_RTOS=1, SDK_DEBUGCONSOLE=1, PHY_KSZ8081=1, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, FSL_ETH_ENABLE_CACHE_CONTROL=1, LWIP_ENET_FLEXIBLE_CONFIGURATION, MCUXPRESSO_SDK, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, LWIP_DISABLE_PBUF_POOL_SIZE_SANITY_CHECKS=1, SERIAL_PORT_TYPE_UART=1, SDK_OS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.scf
  link misc: as above
target fmstr_example_net_cm7 flexspi_nor_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: fmstr_example_net_cm7.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1176DVMAA_cm7, USE_RTOS=1, SDK_DEBUGCONSOLE=1, PHY_KSZ8081=1, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, FSL_ETH_ENABLE_CACHE_CONTROL=1, LWIP_ENET_FLEXIBLE_CONFIGURATION, MCUXPRESSO_SDK, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, LWIP_DISABLE_PBUF_POOL_SIZE_SANITY_CHECKS=1, SERIAL_PORT_TYPE_UART=1, SDK_OS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor.scf
  link misc: as above
