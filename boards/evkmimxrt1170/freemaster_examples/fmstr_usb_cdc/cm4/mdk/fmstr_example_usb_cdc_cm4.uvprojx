# Keil uVision project fmstr_example_usb_cdc_cm4.uvprojx, settings and files
target fmstr_example_usb_cdc_cm4 debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm4 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: fmstr_example_usb_cdc_cm4.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT1176DVMAA_cm4, SDK_DEBUGCONSOLE=1, USB_STACK_BM=1, MCUXPRESSO_SDK, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, SDK_OS_BAREMETAL
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ../source;../../../../../../middleware/freemaster/src/support/mcuxsdk_usb;../source/board;../source/example_data;..;../../../../../../middleware/usb/device;../../../../../../middleware/usb/include;../../../../../../middleware/freemaster/src/common;../../../../../../devices/MIMXRT1176/utilities/debug_console_lite;../../../../../../devices/MIMXRT1176/drivers;../../../../../../devices/MIMXRT1176;../../../../../../components/uart;../../../../../../components/lists;../../../../../../devices/MIMXRT1176/xip;../../../../xip;../../../../../../devices/MIMXRT1176/drivers/cm4;../../../../../../middleware/freemaster/src/template/gen32le;../../../../../../middleware/freemaster/src/platforms/gen32le;../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can;../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial;../../../../xmcd;../../../../../../middleware/usb/phy;../../../../../../components/osa;../../../../../../devices/MIMXRT1176/utilities/str;../../../../../../CMSIS/Core/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../source/board
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm4_ram.scf
  link misc: --remove --legacyalign --entry=Reset_Handler --diag_suppress 6314
  group source
    ../source/: main.c freemaster_cfg.h freemaster_example.c freemaster_example.h freemaster_usb.c freemaster_usb.h freemaster_usb_device_descriptor.c freemaster_usb_device_descriptor.h usb_device_config.h usb_device_descriptor.h
  group board
    ../source/board/: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
    ../../../../xmcd/: xmcd.c xmcd.h
  group doc
    ../: readme.txt
  group example_data
    ../source/example_data/: data_example_pmp.h data_img_logo.h data_img_file.h data_img_fmstrlogo.h data_html_index.h example_data.h
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h usb_device_dci.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/cdc
    ../: usb_device_cdc_acm.c usb_device_cdc_acm.h
  group usb/device/source/ehci
    ../../../../../../middleware/usb/device/: usb_device_ehci.c usb_device_ehci.h
  group usb/device/include
    ../../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group freemaster
    ../../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_defcfg.h freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h freemaster_can.c freemaster_can.h freemaster_sha.c freemaster_pdbdm.c freemaster_serial.c freemaster_serial.h freemaster_net.c freemaster_net.h
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c fsl_assert.h
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_memory.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../devices/MIMXRT1176/drivers/cm4/: fsl_cache.c fsl_cache.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm4.h MIMXRT1176_cm4_features.h system_MIMXRT1176_cm4.c system_MIMXRT1176_cm4.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMXRT1176/arm/: startup_MIMXRT1176_cm4.S
  group xip
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
  group freemaster/platforms
    ../../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group freemaster/drivers
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mscan.c freemaster_mscan.h freemaster_mcan.c freemaster_mcan.h
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_usb.c freemaster_serial_usb.h
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/network/: freemaster_net_segger_rtt.c freemaster_net_segger_rtt.h freemaster_net_lwip_udp.c freemaster_net_lwip_udp.h freemaster_net_lwip_tcp.c freemaster_net_lwip_tcp.h
  group usb/phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm4.h mpu_armv7.h
target fmstr_example_usb_cdc_cm4 flexspi_nor_sdram_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm4 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: fmstr_example_usb_cdc_cm4.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=0, XIP_BOOT_HEADER_DCD_ENABLE=0, XIP_BOOT_HEADER_XMCD_ENABLE=0, USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, DEBUG, CPU_MIMXRT1176DVMAA_cm4, SDK_DEBUGCONSOLE=1, USB_STACK_BM=1, MCUXPRESSO_SDK, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, SDK_OS_BAREMETAL
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../source/board
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm4_flexspi_nor_sdram.scf
  link misc: --remove --legacyalign --entry=Reset_Handler --diag_suppress 6314 --predefine="-DXIP_BOOT_HEADER_ENABLE=0" --predefine="-DXIP_BOOT_HEADER_DCD_ENABLE=0" --predefine="-DXIP_BOOT_HEADER_XMCD_ENABLE=0"
target fmstr_example_usb_cdc_cm4 flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm4 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: fmstr_example_usb_cdc_cm4.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=0, DEBUG, CPU_MIMXRT1176DVMAA_cm4, SDK_DEBUGCONSOLE=1, USB_STACK_BM=1, MCUXPRESSO_SDK, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, SDK_OS_BAREMETAL
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../source/board
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm4_flexspi_nor.scf
  link misc: --remove --legacyalign --entry=Reset_Handler --diag_suppress 6314 --predefine="-DXIP_BOOT_HEADER_ENABLE=0"
target fmstr_example_usb_cdc_cm4 sdram_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm4 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: fmstr_example_usb_cdc_cm4.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, DEBUG, CPU_MIMXRT1176DVMAA_cm4, SDK_DEBUGCONSOLE=1, USB_STACK_BM=1, MCUXPRESSO_SDK, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, SDK_OS_BAREMETAL
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../source/board
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm4_sdram.scf
  link misc: as above
target fmstr_example_usb_cdc_cm4 release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm4 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: fmstr_example_usb_cdc_cm4.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1176DVMAA_cm4, SDK_DEBUGCONSOLE=1, USB_STACK_BM=1, MCUXPRESSO_SDK, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, SDK_OS_BAREMETAL
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../source/board
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm4_ram.scf
  link misc: as above
target fmstr_example_usb_cdc_cm4 flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm4 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: fmstr_example_usb_cdc_cm4.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=0, XIP_BOOT_HEADER_DCD_ENABLE=0, XIP_BOOT_HEADER_XMCD_ENABLE=0, USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, CPU_MIMXRT1176DVMAA_cm4, SDK_DEBUGCONSOLE=1, USB_STACK_BM=1, MCUXPRESSO_SDK, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, SDK_OS_BAREMETAL
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../source/board
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm4_flexspi_nor_sdram.scf
  link misc: as above
target fmstr_example_usb_cdc_cm4 flexspi_nor_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm4 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: fmstr_example_usb_cdc_cm4.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=0, NDEBUG, CPU_MIMXRT1176DVMAA_cm4, SDK_DEBUGCONSOLE=1, USB_STACK_BM=1, MCUXPRESSO_SDK, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, SDK_OS_BAREMETAL
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../source/board
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm4_flexspi_nor.scf
  link misc: as above
target fmstr_example_usb_cdc_cm4 sdram_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm4 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: fmstr_example_usb_cdc_cm4.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, CPU_MIMXRT1176DVMAA_cm4, SDK_DEBUGCONSOLE=1, USB_STACK_BM=1, MCUXPRESSO_SDK, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, SDK_OS_BAREMETAL
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../source/board
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm4_sdram.scf
  link misc: as above
