<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>sd_jpeg_cm7</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
      <member>
        <project>sd_jpeg_cm7</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
      <member>
        <project>sd_jpeg_cm7</project>
        <configuration>sdram_debug</configuration>
      </member>
      <member>
        <project>sd_jpeg_cm7</project>
        <configuration>sdram_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_debug</name>
      <member>
        <project>sd_jpeg_cm7</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_release</name>
      <member>
        <project>sd_jpeg_cm7</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdram_debug</name>
      <member>
        <project>sd_jpeg_cm7</project>
        <configuration>sdram_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdram_release</name>
      <member>
        <project>sd_jpeg_cm7</project>
        <configuration>sdram_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/sd_jpeg_cm7.ewp</path>
  </project>
</workspace>
