# IAR project littlefs_shell_cm4.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M4 NXP MIMXRT1176xxxA_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1176DVMAA_cm4; LFS_NO_INTRINSICS=1; SDK_DEBUGCONSOLE_UART; MCUXPRESSO_SDK; MFLASH_FILE_BASEADDR=14221312; DEBUG_CONSOLE_RX_ENABLE=0; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MIMXRT1176/drivers/cm4; ../../../../../../components/flash/mflash/mimxrt1170; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../middleware/littlefs; ../../../../../../devices/MIMXRT1176/utilities/shell; ../../../../../../devices/MIMXRT1176; ../../../../../../devices/MIMXRT1176/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1176/utilities; ../../../../../../components/flash/mflash; ../../../../../../devices/MIMXRT1176/utilities/str; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: littlefs_shell_cm4.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x1000
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm4_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; DEBUG; CPU_MIMXRT1176DVMAA_cm4; LFS_NO_INTRINSICS=1; SDK_DEBUGCONSOLE_UART; MCUXPRESSO_SDK; MFLASH_FILE_BASEADDR=14221312; DEBUG_CONSOLE_RX_ENABLE=0; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm4_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: LFS_NO_ASSERT; NDEBUG; CPU_MIMXRT1176DVMAA_cm4; LFS_NO_INTRINSICS=1; SDK_DEBUGCONSOLE_UART; MCUXPRESSO_SDK; MFLASH_FILE_BASEADDR=14221312; DEBUG_CONSOLE_RX_ENABLE=0; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: LFS_NO_ASSERT; NDEBUG; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm4; LFS_NO_INTRINSICS=1; SDK_DEBUGCONSOLE_UART; MCUXPRESSO_SDK; MFLASH_FILE_BASEADDR=14221312; DEBUG_CONSOLE_RX_ENABLE=0; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm4_sdram.icf
  group source
    ../: littlefs_shell.c lfs_mflash.c lfs_mflash.h
  group board
    ../: pin_mux.c pin_mux.h peripherals.c peripherals.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.md
  group evkmimxrt1170
    ../: evkmimxrt1170_connect_cm4_cm4side.jlinkscript evkmimxrt1170_connect_cm4_cm4side_sdram.jlinkscript
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/cm4/: fsl_cache.c fsl_cache.h
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_flexspi.c fsl_flexspi.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_anatop_ai.h fsl_anatop_ai.c
  group flash/mflash
    ../../../../../../components/flash/mflash/: mflash_common.h
  group flash/mflash/mimxrt1170
    ../../../../../../components/flash/mflash/mimxrt1170/: mflash_drv.h mflash_drv.c
  group littlefs
    ../../../../../../middleware/littlefs/: lfs.c lfs_util.c lfs.h lfs_util.h
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/shell/: fsl_shell.c fsl_shell.h
    ../../../../../../devices/MIMXRT1176/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1176/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm4.h MIMXRT1176_cm4_features.h system_MIMXRT1176_cm4.c system_MIMXRT1176_cm4.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm4.s
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
