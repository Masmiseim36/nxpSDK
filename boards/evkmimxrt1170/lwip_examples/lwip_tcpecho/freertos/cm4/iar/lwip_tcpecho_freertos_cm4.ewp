# IAR project lwip_tcpecho_freertos_cm4.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M4 NXP MIMXRT1176xxxA_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; CPU_MIMXRT1176DVMAA_cm4; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; LWIP_ENET_FLEXIBLE_CONFIGURATION; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../../components/phy/mdio/enet; ../../../../../../../components/phy/device/phyksz8081; ../../../../../../../components/phy/device/phyrtl8211f; ../../../../../../../middleware/lwip/contrib/apps/tcpecho; ../../../../../../../middleware/lwip/port; ../../../../../../../middleware/lwip/src; ../../../../../../../middleware/lwip/src/include; ../../../../../../../components/phy; ../../../../../../../devices/MIMXRT1176/drivers; ../../../../../../../devices/MIMXRT1176/utilities/str; ../../../../../../../devices/MIMXRT1176/utilities/debug_console; ../../../../../../../devices/MIMXRT1176; ../../../../../../../CMSIS/Include; ../../../../../../../components/uart; ../../../../../../../components/serial_manager; ../../../../../../../components/lists; ../../../../../../../devices/MIMXRT1176/xip; ../../../../../xip; ../../../../../../../devices/MIMXRT1176/drivers/cm4; ../../../../../../../rtos/freertos/freertos_kernel/include; ../../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../../../../..
  ILINK.IlinkOutputFile: lwip_tcpecho_freertos_cm4.out
  ILINK.IlinkConfigDefines: __stack_size__=2048; __heap_size__=25600
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm4_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=0; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; CPU_MIMXRT1176DVMAA_cm4; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; LWIP_ENET_FLEXIBLE_CONFIGURATION; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm4_flexspi_nor.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; DEBUG; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; CPU_MIMXRT1176DVMAA_cm4; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; LWIP_ENET_FLEXIBLE_CONFIGURATION; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm4_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; CPU_MIMXRT1176DVMAA_cm4; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; LWIP_ENET_FLEXIBLE_CONFIGURATION; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=0; NDEBUG; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; CPU_MIMXRT1176DVMAA_cm4; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; LWIP_ENET_FLEXIBLE_CONFIGURATION; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm4_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; CPU_MIMXRT1176DVMAA_cm4; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; LWIP_ENET_FLEXIBLE_CONFIGURATION; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm4_sdram.icf
  group source
    ../: lwip_tcpecho_freertos.c lwipopts.h FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.txt
  group evkmimxrt1170
    ../: evkmimxrt1170_connect_cm4_cm4side.jlinkscript evkmimxrt1170_connect_cm4_cm4side_sdram.jlinkscript
  group mdio
    ../../../../../../../components/phy/mdio/enet/: fsl_enet_mdio.h fsl_enet_mdio.c
    ../../../../../../../components/phy/: fsl_mdio.h
  group phy
    ../../../../../../../components/phy/device/phyksz8081/: fsl_phyksz8081.h fsl_phyksz8081.c
    ../../../../../../../components/phy/device/phyrtl8211f/: fsl_phyrtl8211f.h fsl_phyrtl8211f.c
    ../../../../../../../components/phy/: fsl_phy.h
  group lwip/contrib/apps/tcpecho
    ../../../../../../../middleware/lwip/contrib/apps/tcpecho/: tcpecho.h tcpecho.c
  group lwip/port
    ../../../../../../../middleware/lwip/port/: enet_ethernetif.c enet_ethernetif.h enet_ethernetif_priv.h enet_ethernetif_kinetis.c sys_arch.c
  group lwip/port/arch
    ../../../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src/api
    ../../../../../../../middleware/lwip/src/api/: sockets.c netifapi.c netdb.c netbuf.c tcpip.c api_msg.c err.c if_api.c api_lib.c
  group lwip/src/core
    ../../../../../../../middleware/lwip/src/core/: memp.c def.c ip.c pbuf.c altcp.c tcp_out.c raw.c altcp_tcp.c sys.c init.c inet_chksum.c timeouts.c tcp_in.c netif.c mem.c udp.c tcp.c stats.c dns.c altcp_alloc.c
  group lwip/src/core/ipv6
    ../../../../../../../middleware/lwip/src/core/ipv6/: ethip6.c dhcp6.c ip6_addr.c nd6.c mld6.c icmp6.c ip6_frag.c ip6.c inet6.c
  group lwip/src/core/ipv4
    ../../../../../../../middleware/lwip/src/core/ipv4/: dhcp.c ip4.c autoip.c icmp.c acd.c etharp.c ip4_addr.c igmp.c ip4_frag.c
  group lwip/src/include/compat/stdc
    ../../../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/compat/posix
    ../../../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/sys
    ../../../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/posix/net
    ../../../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/lwip
    ../../../../../../../middleware/lwip/src/include/lwip/: inet_chksum.h ip6.h udp.h def.h mld6.h err.h ip4.h opt.h errno.h debug.h icmp.h netif.h sio.h ip6_zone.h igmp.h netdb.h dhcp.h altcp_tls.h altcp_tcp.h ip_addr.h inet.h tcp.h api.h arch.h autoip.h ip4_addr.h altcp.h mem.h sys.h init.h dns.h tcpbase.h stats.h icmp6.h netifapi.h ethip6.h snmp.h raw.h if_api.h tcpip.h ip6_frag.h nd6.h ip.h pbuf.h acd.h ip4_frag.h timeouts.h dhcp6.h sockets.h netbuf.h etharp.h ip6_addr.h memp.h
  group lwip/src/include/lwip/priv
    ../../../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h mem_priv.h memp_priv.h memp_std.h api_msg.h nd6_priv.h tcpip_priv.h tcp_priv.h raw_priv.h sockets_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../../../middleware/lwip/src/include/lwip/prot/: ip6.h udp.h mld6.h ip4.h icmp.h igmp.h dhcp.h tcp.h autoip.h iana.h ieee.h dns.h icmp6.h ethernet.h nd6.h ip.h acd.h dhcp6.h etharp.h
  group lwip/src/include/netif
    ../../../../../../../middleware/lwip/src/include/netif/: bridgeif.h zepif.h lowpan6.h ieee802154.h ethernet.h lowpan6_common.h lowpan6_opts.h bridgeif_opts.h slipif.h lowpan6_ble.h etharp.h
  group lwip/src/include/netif/ppp
    ../../../../../../../middleware/lwip/src/include/netif/ppp/: ipv6cp.h pppapi.h magic.h ppp.h upap.h mppe.h pppol2tp.h pppoe.h ipcp.h pppdebug.h eap.h pppos.h ppp_opts.h pppcrypt.h vj.h chap-new.h eui64.h chap_ms.h ccp.h ecp.h lcp.h fsm.h ppp_impl.h chap-md5.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: sha1.h des.h md5.h md4.h arc4.h
  group lwip/src/netif
    ../../../../../../../middleware/lwip/src/netif/: lowpan6.c ethernet.c bridgeif.c bridgeif_fdb.c zepif.c lowpan6_common.c lowpan6_ble.c slipif.c
  group lwip/src/netif/ppp
    ../../../../../../../middleware/lwip/src/netif/ppp/: pppol2tp.c mppe.c vj.c pppcrypt.c ppp.c eap.c chap-md5.c lcp.c pppos.c ipcp.c fsm.c ccp.c utils.c chap-new.c demand.c pppoe.c ipv6cp.c lwip_ecp.c multilink.c eui64.c magic.c upap.c pppapi.c chap_ms.c auth.c
  group drivers
    ../../../../../../../devices/MIMXRT1176/drivers/: fsl_enet.h fsl_enet.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../../devices/MIMXRT1176/drivers/cm4/: fsl_cache.c fsl_cache.h
  group utilities
    ../../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MIMXRT1176/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/MIMXRT1176/utilities/: fsl_assert.c
  group freertos/freertos_kernel
    ../../../../../../../rtos/freertos/freertos_kernel/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_3.c ReadMe.url
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/include
    ../../../../../../../rtos/freertos/freertos_kernel/include/: croutine.h StackMacros.h atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group device
    ../../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm4.h MIMXRT1176_cm4_features.h system_MIMXRT1176_cm4.c system_MIMXRT1176_cm4.h
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm4.s
  group xip
    ../../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
