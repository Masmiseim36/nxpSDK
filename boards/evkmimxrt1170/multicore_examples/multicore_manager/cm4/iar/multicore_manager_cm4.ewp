# IAR project multicore_manager_cm4.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M4 NXP MIMXRT1176xxxA_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1176DVMAA_cm4; MCMGR_HANDLE_EXCEPTIONS=1; __SEMIHOST_HARDFAULT_DISABLE=1; MULTICORE_APP=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../middleware/multicore/mcmgr/src; ../../../../../../devices/MIMXRT1176; ../../../../../../CMSIS/Include; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1176/xip; ../../../../xip; ../../../../../../devices/MIMXRT1176/drivers/cm4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: multicore_manager_cm4.out
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm4_ram.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1176DVMAA_cm4; MCMGR_HANDLE_EXCEPTIONS=1; __SEMIHOST_HARDFAULT_DISABLE=1; MULTICORE_APP=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: mcmgr_core1.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.txt
  group evkmimxrt1170
    ../: evkmimxrt1170_connect_cm4_cm4side.jlinkscript
  group mcmgr
    ../../../../../../middleware/multicore/mcmgr/src/: mcmgr_internal_core_api_imxrt1170.c mcmgr_mu_internal.c mcmgr.h mcmgr_internal_core_api.h mcmgr.c
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_clock.h fsl_clock.c fsl_mu.h fsl_mu.c fsl_common.h fsl_common.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../devices/MIMXRT1176/drivers/cm4/: fsl_cache.c fsl_cache.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm4.h MIMXRT1176_cm4_features.h system_MIMXRT1176_cm4.c system_MIMXRT1176_cm4.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm4.s
  group xip
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
