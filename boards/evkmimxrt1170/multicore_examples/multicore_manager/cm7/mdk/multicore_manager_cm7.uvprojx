# Keil uVision project multicore_manager_cm7.uvprojx, settings and files
target multicore_manager_cm7 flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: multicore_manager_cm7.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CORE1_IMAGE_COPY_TO_RAM, CPU_MIMXRT1176DVMAA_cm7, MCMGR_HANDLE_EXCEPTIONS=1, __SEMIHOST_HARDFAULT_DISABLE=1, MULTICORE_APP=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../devices/MIMXRT1176/utilities/debug_console_lite;../../../../../../devices/MIMXRT1176/drivers;../../../../../../middleware/multicore/mcmgr/src;../../../../../../devices/MIMXRT1176;../../../../../../CMSIS/Include;../../../../../../components/uart;../../../../../../components/lists;../../../../../../devices/MIMXRT1176/xip;../../../../xip;../../../../../../devices/MIMXRT1176/drivers/cm7
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../../cm4/mdk/debug
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor.scf
  link misc: --remove --keep=*(*core1_code) --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group source
    ../: mcmgr_core0.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.txt
  group mcmgr
    ../../../../../../middleware/multicore/mcmgr/src/: mcmgr_internal_core_api_imxrt1170.c mcmgr_mu_internal.c mcmgr.h mcmgr_internal_core_api.h mcmgr.c
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
    ../../../../../../devices/MIMXRT1176/utilities/incbin/: fsl_incbin.S
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_clock.h fsl_clock.c fsl_mu.h fsl_mu.c fsl_common.h fsl_common.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMXRT1176/arm/: startup_MIMXRT1176_cm7.S
  group xip
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
target multicore_manager_cm7 flexspi_nor_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: multicore_manager_cm7.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CORE1_IMAGE_COPY_TO_RAM, CPU_MIMXRT1176DVMAA_cm7, MCMGR_HANDLE_EXCEPTIONS=1, __SEMIHOST_HARDFAULT_DISABLE=1, MULTICORE_APP=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../../cm4/mdk/release
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor.scf
  link misc: as above
