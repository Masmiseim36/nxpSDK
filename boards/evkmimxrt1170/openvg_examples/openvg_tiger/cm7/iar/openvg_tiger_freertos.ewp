# IAR project openvg_tiger_freertos.ewp, settings and files
configuration sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; DEBUG; CPU_MIMXRT1176DVMAA_cm7; SDK_DEBUGCONSOLE=1; gcdENABLE_3D=0; BOARD_DEBUG_UART_BAUDRATE=230400; DEBUG=1; DBG=1; __FREERTOS__=1; gcdENABLE_VG=1; gcdENABLE_2D=0; USE_VDK=0; STATIC_LINK=1; gcdSTATIC_LINK=1; gcdUSE_VX=0; gcdUSE_VXC_BINARY=0; GC_ENABLE_LOADTIME_OPT=0; gcdGC355_MEM_PRINT=0; gcdGC355_PROFILER=0; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK; SDK_OS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../..; ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite; ../../../../../../middleware/openvg/inc; ../../../../../../components/video/display/fbdev; ../../../../../../components/video; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../components/video/display; ../../../../../../components/video/display/rm68191; ../../../../../../components/video/display/mipi_dsi_cmd; ../../../../../../components/video/display/rm68200; ../../../../../../components/video/display/dc/lcdifv2; ../../../../../../components/video/display/hx8394; ../../../../../../devices/MIMXRT1176; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../xip; ../../../../../../devices/MIMXRT1176/drivers/cm7; ../../../../xmcd; ../../../../../../devices/MIMXRT1176/utilities/str; ../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F; ../../../../../../components/video/display/dc; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../../../../../../rtos/freertos/freertos-kernel/include
  ILINK.IlinkOutputFile: openvg_tiger_freertos.out
  ILINK.IlinkIcfFile: openvg_tiger_MIMXRT1176xxxxx_cm7_sdram_only.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../middleware/openvg/lib/libEGL.a; ../../../../../../middleware/openvg/lib/libGAL.a; ../../../../../../middleware/openvg/lib/libOpenVG.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; SDK_DEBUGCONSOLE=1; gcdENABLE_3D=0; BOARD_DEBUG_UART_BAUDRATE=230400; DEBUG=1; DBG=1; __FREERTOS__=1; gcdENABLE_VG=1; gcdENABLE_2D=0; USE_VDK=0; STATIC_LINK=1; gcdSTATIC_LINK=1; gcdUSE_VX=0; gcdUSE_VXC_BINARY=0; GC_ENABLE_LOADTIME_OPT=0; gcdGC355_MEM_PRINT=0; gcdGC355_PROFILER=0; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK; SDK_OS_FREE_RTOS
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: tiger_freertos.c FreeRTOSConfig.h tiger_path.h
  group board
    ../: pin_mux.c pin_mux.h assert_func.c dcd.c dcd.h board.c board.h clock_config.c clock_config.h display_support.h display_support.c
    ../../../../xmcd/: xmcd.c xmcd.h
  group doc
    ../: readme.md
  group evkmimxrt1170
    ../: evkmimxrt1170_connect_cm4_cm7side.jlinkscript
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c fsl_assert.h
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos-kernel/portable/IAR/ARM_CM4F
    ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group openvg/inc/EGL
    ../../../../../../middleware/openvg/inc/EGL/: egl.h eglext.h eglplatform.h eglvivante.h
  group openvg/inc/KHR
    ../../../../../../middleware/openvg/inc/KHR/: khrplatform.h
  group openvg/inc/VG
    ../../../../../../middleware/openvg/inc/VG/: openvg.h vgext.h vgplatform.h vgrename.h vgu.h
  group video
    ../../../../../../components/video/display/fbdev/: fsl_fbdev.h fsl_fbdev.c
    ../../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../../components/video/display/: fsl_display.h
    ../../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
    ../../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../../components/video/display/dc/lcdifv2/: fsl_dc_fb_lcdifv2.h fsl_dc_fb_lcdifv2.c
    ../../../../../../components/video/display/hx8394/: fsl_hx8394.h fsl_hx8394.c
    ../../../../../../components/video/display/dc/: fsl_dc_fb.h
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_clock.h fsl_clock.c fsl_soc_src.h fsl_soc_src.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_lpuart.h fsl_lpuart.c fsl_gpc.h fsl_gpc.c fsl_mu.h fsl_mu.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_anatop_ai.h fsl_anatop_ai.c fsl_soc_mipi_dsi.h fsl_soc_mipi_csi2rx.h fsl_soc_mipi_csi2rx.c fsl_lcdifv2.c fsl_lcdifv2.h fsl_memory.h
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group xip
    ../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
