# Keil uVision project se05x_iot_agent_demo.uvprojx, settings and files
target se05x_iot_agent_demo flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: se05x_iot_agent_demo.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1176DVMAA_cm7, IMX_RT, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, MBEDTLS_CONFIG_FILE='\"ksdk_mbedtls_config.h\"', MBEDTLS_USER_CONFIG_FILE='\"sss_ksdk_mbedtls_config.h\"', mqttconfigENABLE_METRICS=0, SDK_DEBUGCONSOLE_UART, FREEDOM, LPC_ENET, NXP_IOT_AGENT_USE_COREJSON, PRINTF_ADVANCED_ENABLE=1, MCUXPRESSO_SDK, CRYPTO_USE_DRIVER_CAAM, CACHE_MODE_WRITE_THROUGH=1, LWIP_DISABLE_PBUF_POOL_SIZE_SANITY_CHECKS=1, PB_FIELD_32BIT, EXTERNAL_CUSTOMER_BUILD_CONFIGURATION=1, SERIAL_PORT_TYPE_UART=1, SDK_OS_FREE_RTOS, T1oI2C, T1oI2C_UM11225, SSS_USE_FTR_FILE, NO_SECURE_CHANNEL_SUPPORT, MBEDTLS, USE_RTOS, mqttconfigENABLE_METRICS=0, SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC, LWIP_DNS=1
  c misc: -Wno-typedef-redefinition  -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../..;..;../../../../../../middleware/se_hostlib/demos/ksdk/se05x/iot_agent;../../../../../../middleware/se_hostlib/sss/plugin/mbedtls;../../../../../../middleware/se_hostlib/hostlib/hostLib/tstUtil;../../../../../../middleware/se_hostlib/nxp_iot_agent/ex/inc;../../../../../../middleware/se_hostlib/nxp_iot_agent/platform;../../../../../../middleware/se_hostlib/nxp_iot_agent/platform/mbedtls;../../../../../../middleware/se_hostlib/semslite/lib/inc;../../../../../../middleware/se_hostlib/nxp_iot_agent/ex/src/utils;../../../../../../devices/MIMXRT1176/drivers;../../../../../../devices/MIMXRT1176/drivers/cm7;../../../../../../components/phy;../../../../../../components/phy/device/phyksz8081;../../../../../../components/phy/device/phyrtl8211f;../../../../../../middleware/lwip/port;../../../../../../middleware/lwip/src;../../../../../../middleware/lwip/src/include;../../../../../../middleware/mbedtls/port/ksdk;../../../../../../middleware/se_hostlib/nxp_iot_agent/src/protobuf;../../../../../../middleware/se_hostlib/nxp_iot_agent/inc;../../../../../../middleware/aws_iot/iot-reference/Middleware/FreeRTOS/transport_mbedtls;../../../../../../middleware/aws_iot/iot-reference/examples/common/logging;../../../../../../rtos/freertos/corejson/source/include;../../../../../../devices/MIMXRT1176;../../../../../../devices/MIMXRT1176/utilities/str;../../../../../../devices/MIMXRT1176/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../devices/MIMXRT1176/xip;../../../../xip;../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F;../../../../../../middleware/mbedtls/include;../../../../../../middleware/mbedtls/library;../../../../../../middleware/se_hostlib/sss/inc;../../../../../../middleware/se_hostlib/sss/ex/inc;../../../../../../middleware/se_hostlib/sss/port/ksdk;../../../../../../middleware/se_hostlib/hostlib/hostLib/se05x_03_xx_xx;../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/infra;../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/log;../../../../../../middleware/se_hostlib/hostlib/hostLib/mbedtls/inc;../../../../../../middleware/se_hostlib/demos/ksdk/common/https_client;../../../../../../middleware/se_hostlib/hostlib/hostLib/inc;../../../../../../middleware/se_hostlib/hostlib/hostLib/se05x/src;../../../../../../middleware/se_hostlib;../../../../../../middleware/se_hostlib/platform;../../../../../../middleware/se_hostlib/sss/plugin/pkcs11;../../../../../../middleware/se_hostlib/hostlib/hostLib/platform/inc;../../../../../../middleware/se_hostlib/hostlib/hostLib/platform/ksdk;../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom;../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/T1oI2C;../../../../../../middleware/se_hostlib/sss/ex/src;../../../../../../rtos/freertos/coremqtt/source/include;../../../../../../rtos/freertos/coremqtt/source/interface;../../../../../../middleware/pkcs11;../../../../../../rtos/freertos/backoffalgorithm/source/include;../../../../../../rtos/freertos/corepkcs11/source/include;../../../../../../middleware/aws_iot/iot-reference/template;../../../../../../CMSIS/Core/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../../..
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314 --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x8000" --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group source
    ../: fsl_sss_ftr.h iot_agent_demo.c FreeRTOSConfig.h FreeRTOSConfig.c
  group board
    ../: pin_mux.c pin_mux.h se_board_config.c se_board_config.h aws_secure_sockets_config.h aws_mqtt_config.h aws_bufferpool_config.h iot_mqtt_agent_config.h app.h lwipopts.h core_mqtt_config.h core_pkcs11_config.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
    ../../../se05x_cloud_gcp/cm7/: FreeRTOSIPConfig.h
  group doc
    ../: readme.rst readme.txt
  group evkmimxrt1170
    ../: evkmimxrt1170_connect_cm4_cm7side.jlinkscript
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_caam.c fsl_caam.h fsl_pit.c fsl_pit.h fsl_flexspi.c fsl_flexspi.h fsl_enet.h fsl_enet.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_memory.h fsl_lpi2c.c fsl_lpi2c.h fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group drivers/freertos
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_lpi2c_freertos.h fsl_lpi2c_freertos.c
  group component/phy
    ../../../../../../components/phy/: fsl_phy.h
    ../../../../../../components/phy/device/phyksz8081/: fsl_phyksz8081.h fsl_phyksz8081.c
    ../../../../../../components/phy/device/phyrtl8211f/: fsl_phyrtl8211f.h fsl_phyrtl8211f.c
  group lwip/port
    ../../../../../../middleware/lwip/port/: enet_ethernetif.c ethernetif.c ethernetif.h ethernetif_mmac.c ethernetif_mmac.h ethernetif_priv.h enet_sanitychecks.h enet_ethernetif_kinetis.c sys_arch.c
  group lwip/port/arch
    ../../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src/api
    ../../../../../../middleware/lwip/src/api/: sockets.c netifapi.c netdb.c netbuf.c tcpip.c api_msg.c err.c if_api.c api_lib.c
  group lwip/src/core
    ../../../../../../middleware/lwip/src/core/: memp.c def.c ip.c pbuf.c altcp.c tcp_out.c raw.c altcp_tcp.c sys.c init.c inet_chksum.c timeouts.c tcp_in.c netif.c mem.c udp.c tcp.c stats.c dns.c altcp_alloc.c
  group lwip/src/core/ipv6
    ../../../../../../middleware/lwip/src/core/ipv6/: ethip6.c dhcp6.c ip6_addr.c nd6.c mld6.c icmp6.c ip6_frag.c ip6.c inet6.c
  group lwip/src/core/ipv4
    ../../../../../../middleware/lwip/src/core/ipv4/: dhcp.c ip4.c autoip.c icmp.c acd.c etharp.c ip4_addr.c igmp.c ip4_frag.c
  group lwip/src/include/compat/stdc
    ../../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/compat/posix
    ../../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/sys
    ../../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/posix/net
    ../../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/lwip
    ../../../../../../middleware/lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/priv
    ../../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h mem_priv.h memp_priv.h memp_std.h api_msg.h nd6_priv.h tcpip_priv.h tcp_priv.h raw_priv.h sockets_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../../middleware/lwip/src/include/lwip/prot/: ip6.h udp.h mld6.h ip4.h icmp.h igmp.h dhcp.h tcp.h autoip.h iana.h ieee.h dns.h icmp6.h ethernet.h nd6.h ip.h acd.h dhcp6.h etharp.h
  group lwip/src/include/netif
    ../../../../../../middleware/lwip/src/include/netif/: bridgeif.h zepif.h lowpan6.h ieee802154.h ethernet.h lowpan6_common.h lowpan6_opts.h bridgeif_opts.h slipif.h lowpan6_ble.h etharp.h
  group lwip/src/include/netif/ppp
    ../../../../../../middleware/lwip/src/include/netif/ppp/: ipv6cp.h pppapi.h magic.h ppp.h upap.h mppe.h pppol2tp.h pppoe.h ipcp.h pppdebug.h eap.h pppos.h ppp_opts.h pppcrypt.h vj.h chap-new.h eui64.h chap_ms.h ccp.h ecp.h lcp.h fsm.h ppp_impl.h chap-md5.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: sha1.h des.h md5.h md4.h arc4.h
  group lwip/src/netif
    ../../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group mbedtls/port/ksdk
    ../../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c ccm_alt.h ecp_alt.h ecp_alt.c ecp_curves_alt.c ecp_alt_ksdk.c threading_alt.h ksdk_mbedtls_config.h
  group se_hostlib/nxp_iot_agent/inc
    ../../../../../../middleware/se_hostlib/nxp_iot_agent/inc/: nxp_iot_agent.h nxp_iot_agent_common.h nxp_iot_agent_config.h nxp_iot_agent_config_certificates.h nxp_iot_agent_context.h nxp_iot_agent_datastore.h nxp_iot_agent_datastore_fs.h nxp_iot_agent_datastore_plain.h nxp_iot_agent_dispatcher.h nxp_iot_agent_endpoint.h nxp_iot_agent_keystore.h nxp_iot_agent_keystore_sss_se05x.h nxp_iot_agent_log.h nxp_iot_agent_macros.h nxp_iot_agent_service.h nxp_iot_agent_session.h nxp_iot_agent_status.h nxp_iot_agent_time.h nxp_iot_agent_utils.h nxp_iot_agent_utils_protobuf.h nxp_iot_agent_ver.h
  group se_hostlib/nxp_iot_agent/src
    ../../../../../../middleware/se_hostlib/nxp_iot_agent/src/: nxp_iot_agent.c nxp_iot_agent_common.c nxp_iot_agent_config.c nxp_iot_agent_datastore.c nxp_iot_agent_datastore_fs.c nxp_iot_agent_datastore_plain.c nxp_iot_agent_keystore.c nxp_iot_agent_keystore_sss_se05x.c nxp_iot_agent_service.c nxp_iot_agent_session.c nxp_iot_agent_time.c nxp_iot_agent_utils.c nxp_iot_agent_utils_protobuf_socket.c
  group se_hostlib/nxp_iot_agent/src/protobuf
    ../../../../../../middleware/se_hostlib/nxp_iot_agent/src/protobuf/: Agent.pb.h Apdu.pb.h Datastore.pb.h Dispatcher.pb.h Hostcmd.pb.h RPC.pb.h ServiceDescriptor.pb.h Types.pb.h pb.h pb_common.h pb_decode.h pb_encode.h Agent.pb.c Apdu.pb.c Datastore.pb.c Dispatcher.pb.c Hostcmd.pb.c RPC.pb.c ServiceDescriptor.pb.c Types.pb.c pb_common.c pb_decode.c pb_encode.c
  group se_hostlib/nxp_iot_agent/src/common
    ../../../../../../middleware/se_hostlib/nxp_iot_agent/src/common/: nxp_iot_agent_dispatcher.c nxp_iot_agent_utils_protobuf.c
  group se_hostlib/nxp_iot_agent/platform/mbedtls
    ../../../../../../middleware/se_hostlib/nxp_iot_agent/platform/mbedtls/: network_mbedtls.h network_mbedtls.c net_lwip.c
  group se_hostlib/nxp_iot_agent/ex/inc
    ../../../../../../middleware/se_hostlib/nxp_iot_agent/ex/inc/: iot_agent_network.h iot_agent_mqtt_freertos.h iot_agent_config.h iot_agent_claimcode_inject.h
  group se_hostlib/nxp_iot_agent/ex/src/utils
    ../../../../../../middleware/se_hostlib/nxp_iot_agent/ex/src/utils/: iot_agent_mqtt_freertos.c iot_agent_claimcode_inject.c
  group se_hostlib/nxp_iot_agent/ex/src/network
    ../../../../../../middleware/se_hostlib/nxp_iot_agent/ex/src/network/: iot_agent_network_lwip.c
  group se_hostlib/hostlib/hostLib/tstUtil
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/tstUtil/: tst_sm_time_kinetis.c tst_sm_time.h tstHostCrypto.h
  group se_hostlib/nxp_iot_agent/platform
    ../../../../../../middleware/se_hostlib/nxp_iot_agent/platform/: network.h
  group aws_iot/iot-reference/FreeRTOS/transport_mbedtls
    ../../../../../../middleware/aws_iot/iot-reference/Middleware/FreeRTOS/transport_mbedtls/: using_mbedtls.c using_mbedtls.h
  group aws_iot/iot-reference/examples/common/logging
    ../../../../../../middleware/aws_iot/iot-reference/examples/common/logging/: logging.c logging.h logging_levels.h
  group freertos/corejson/source
    ../../../../../../rtos/freertos/corejson/source/: core_json.c
  group freertos/corejson/source/include
    ../../../../../../rtos/freertos/corejson/source/include/: core_json.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1176/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1176/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMXRT1176/arm/: startup_MIMXRT1176_cm7.S
  group xip
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable/GCC/ARM_CM4F
    ../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group mbedtls/include/mbedtls
    ../../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h psa_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/include/psa
    ../../../../../../middleware/mbedtls/include/psa/: crypto.h crypto_builtin_composites.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group mbedtls/library
    ../../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cmac.c common.h constant_time.c constant_time_internal.h constant_time_invasive.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_invasive.h entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c mps_common.h mps_error.h mps_reader.c mps_reader.h mps_trace.c mps_trace.h net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c ssl_tls13_keys.h threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group se_hostlib/sss/port/ksdk
    ../../../../../../middleware/se_hostlib/sss/port/ksdk/: fsl_sss_types.h fsl_sss_types.h sss_ksdk_mbedcrypto_config.h sss_ksdk_mbedtls_config.h
  group se_hostlib/hostlib/hostLib/inc
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/inc/: Applet_SE050_Ver.h HLSEAPI.h HLSEComm.h HLSECrypto.h HLSEMisc.h HLSEObjects.h HLSETypes.h PlugAndTrust_HostLib_Ver.h PlugAndTrust_Pkg_Ver.h SE_HAL_Lib.h a71ch_api.h a71ch_util.h a71cl_api.h a71cl_util.h ax_api.h ax_common.h ax_common_a71ch.h ax_common_a71cl.h ax_common_private.h ax_scp.h ax_scp_private.h ax_sss_scp.h ax_util.h ledHandler.h modules.h nxEnsure.h nxScp03_Apis.h nxScp03_Const.h nxScp03_Types.h scp.h se05x_const.h se05x_ecc_curves.h se05x_ecc_curves_inc.h se05x_ecc_curves_values.h se05x_enums.h se05x_ftr.h se05x_tlv.h sm_const.h ledHandler.h
  group se_hostlib/hostlib/hostLib/se05x/src
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/se05x/src/: se05x_ECC_curves.c se05x_mw.c se05x_tlv.c
  group se_hostlib/sss/inc
    ../../../../../../middleware/se_hostlib/sss/inc/: fsl_sscp.h fsl_sscp_a71ch.h fsl_sscp_a71cl.h fsl_sscp_commands.h fsl_sscp_mu.h fsl_sss_api.h fsl_sss_api_ver.h fsl_sss_config.h fsl_sss_ftr_default.h fsl_sss_keyid_map.h fsl_sss_lpc55s_apis.h fsl_sss_lpc55s_types.h fsl_sss_mbedtls_apis.h fsl_sss_mbedtls_types.h fsl_sss_openssl_apis.h fsl_sss_openssl_types.h fsl_sss_policy.h fsl_sss_se05x_apis.h fsl_sss_se05x_policy.h fsl_sss_se05x_scp03.h fsl_sss_se05x_types.h fsl_sss_sscp.h fsl_sss_sscp_config.h fsl_sss_user_apis.h fsl_sss_user_types.h fsl_sss_util_asn1_der.h fsl_sss_util_rsa_sign_utils.h
  group se_hostlib/sss/src
    ../../../../../../middleware/se_hostlib/sss/src/: fsl_sss_apis.c fsl_sss_util_asn1_der.c fsl_sss_util_rsa_sign_utils.c
  group se_hostlib/sss/src/se05x
    ../../../../../../middleware/se_hostlib/sss/src/se05x/: fsl_sss_se05x_apis.c fsl_sss_se05x_eckey.c fsl_sss_se05x_mw.c fsl_sss_se05x_policy.c fsl_sss_se05x_scp03.c
  group se_hostlib/hostlib/hostLib/libCommon/infra
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/infra/: sm_demo_utils.c sm_demo_utils_rtos.c global_platf.c sm_connect.c a71_debug.h app_boot.h app_boot_nfc.h cm_commands.h global_platf.h sm_apdu.h sm_api.h sm_demo_utils.h sm_errors.h sm_types.h sm_apdu.c sm_errors.c sm_printf.c
  group se_hostlib/sss/plugin/pkcs11
    ../../../../../../middleware/se_hostlib/sss/plugin/pkcs11/: sss_pkcs11_pal_core.c sss_pkcs11_pal.h nxLog_pkcs11.h sss_pkcs11_pal_helpers.c sss_pkcs11_pal_object.c sss_pkcs11_pal_asymm.c sss_pkcs11_pal_symm.c pkcs11_mbedtls_utils.c pkcs11_mbedtls_utils.h
  group se_hostlib/sss/plugin/mbedtls
    ../../../../../../middleware/se_hostlib/sss/plugin/mbedtls/: ecdh_alt_ax.c ecdsa_verify_alt.c ecp_alt_sss.c sss_mbedtls.c sss_mbedtls_rsa.c ecdsa_verify_alt.h ecp_alt.h rsa_alt.h sss_mbedtls.h
  group se_hostlib/hostlib/hostLib/platform/inc
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/platform/inc/: ax_reset.h i2c_a7.h se05x_apis.h se_pit_config.h se_reset_config.h sm_printf.h sm_timer.h
  group se_hostlib/hostlib/hostLib/platform/ksdk
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/platform/ksdk/: ax_reset.c i2c_frdm.c i2c_imxrt.c i2c_lpc54xxx.c i2c_lpc55sxx.c se05x_reset.c timer_kinetis.c timer_kinetis_bm.c timer_kinetis_freertos.c timer_kinetis_threadx.c
  group se_hostlib/hostlib/hostLib/libCommon/smCom
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/: apduComm.h sci2c_cfg.h smCom.c smCom.h smComT1oI2C.c smComT1oI2C.h
  group se_hostlib/hostlib/hostLib/libCommon/smCom/T1oI2C
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/T1oI2C/: phEseStatus.h phEseTypes.h phNxpEsePal_i2c.h phNxpEseProto7816_3.h phNxpEse_Api.h phNxpEse_Internal.h phNxpEsePal_i2c.c phNxpEseProto7816_3.c phNxpEse_Api.c
  group se_hostlib/sss/ex/inc
    ../../../../../../middleware/se_hostlib/sss/ex/inc/: ex_a71ch_scp03.h ex_scp03_puf.h ex_sss.h ex_sss_auth.h ex_sss_boot.h ex_sss_main_cc_inc.h ex_sss_main_freeRTOS_inc.h ex_sss_main_inc.h ex_sss_main_inc_frdmk64f.h ex_sss_main_inc_imx_rt.h ex_sss_main_inc_ksdk.h ex_sss_main_inc_linux.h ex_sss_main_inc_lpcxpresso55s.h ex_sss_main_inc_nrf.h ex_sss_main_inc_qn9090.h ex_sss_objid.h ex_sss_ports.h ex_sss_scp03_keys.h ex_sss_tp_scp03_keys.h
  group se_hostlib/sss/ex/src
    ../../../../../../middleware/se_hostlib/sss/ex/src/: ex_sss_boot.c ex_sss_boot_connectstring.c ex_sss_boot_int.h ex_sss_se05x.c ex_sss_se05x_auth.c
  group se_hostlib/hostlib/hostLib/se05x_03_xx_xx
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/se05x_03_xx_xx/: se05x_APDU.c se05x_APDU.h se05x_APDU_apis.h se05x_APDU_impl.h se05x_04_xx_APDU_apis.h se05x_04_xx_APDU_impl.h
  group se_hostlib/hostlib/hostLib/libCommon/nxScp
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/nxScp/: nxScp03_Com.c
  group se_hostlib/hostlib/hostLib/libCommon/scp
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/scp/: scp.c
  group se_hostlib/hostlib/hostLib/libCommon/log
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/log/: nxLog.c nxLog.h nxLog_App.h nxLog_DefaultConfig.h nxLog_UseCases.h nxLog_VCOM.h nxLog_hostLib.h nxLog_mbedtls.h nxLog_scp.h nxLog_smCom.h nxLog_sscp.h nxLog_sss.h
  group freertos/coremqtt/source
    ../../../../../../rtos/freertos/coremqtt/source/: core_mqtt.c core_mqtt_serializer.c core_mqtt_state.c
  group freertos/coremqtt/source/include
    ../../../../../../rtos/freertos/coremqtt/source/include/: core_mqtt.h core_mqtt_config_defaults.h core_mqtt_default_logging.h core_mqtt_serializer.h core_mqtt_state.h
  group freertos/coremqtt/source/interface
    ../../../../../../rtos/freertos/coremqtt/source/interface/: transport_interface.h
  group pkcs11
    ../../../../../../middleware/pkcs11/: README.md pkcs11t.h pkcs11f.h pkcs11.h LICENSE.md CONTRIBUTING.md
  group freertos/backoffalgorithm/source
    ../../../../../../rtos/freertos/backoffalgorithm/source/: backoff_algorithm.c
  group freertos/backoffalgorithm/source/include
    ../../../../../../rtos/freertos/backoffalgorithm/source/include/: backoff_algorithm.h
  group se_hostlib/hostlib/hostLib/mbedtls/inc
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/mbedtls/inc/: ax_mbedtls.h
  group se_hostlib/hostlib/hostLib/mbedtls/src
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/mbedtls/src/: ecdh_alt.c rsa_alt.c
  group se_hostlib/sss/src/mbedtls
    ../../../../../../middleware/se_hostlib/sss/src/mbedtls/: fsl_sss_mbedtls_apis.c
  group freertos/corepkcs11/source
    ../../../../../../rtos/freertos/corepkcs11/source/: core_pkcs11.c core_pki_utils.c
  group freertos/corepkcs11/source/include
    ../../../../../../rtos/freertos/corepkcs11/source/include/: core_pkcs11.h core_pkcs11_config_defaults.h core_pkcs11_pal.h core_pki_utils.h
  group aws_iot/iot-reference/template
    ../../../../../../middleware/aws_iot/iot-reference/template/: demo_config.h kvstore_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
target se05x_iot_agent_demo flexspi_nor_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: se05x_iot_agent_demo.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1176DVMAA_cm7, IMX_RT, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, MBEDTLS_CONFIG_FILE='\"ksdk_mbedtls_config.h\"', MBEDTLS_USER_CONFIG_FILE='\"sss_ksdk_mbedtls_config.h\"', mqttconfigENABLE_METRICS=0, SDK_DEBUGCONSOLE_UART, FREEDOM, LPC_ENET, NXP_IOT_AGENT_USE_COREJSON, PRINTF_ADVANCED_ENABLE=1, MCUXPRESSO_SDK, CRYPTO_USE_DRIVER_CAAM, CACHE_MODE_WRITE_THROUGH=1, LWIP_DISABLE_PBUF_POOL_SIZE_SANITY_CHECKS=1, PB_FIELD_32BIT, EXTERNAL_CUSTOMER_BUILD_CONFIGURATION=1, SERIAL_PORT_TYPE_UART=1, SDK_OS_FREE_RTOS, T1oI2C, T1oI2C_UM11225, SSS_USE_FTR_FILE, NO_SECURE_CHANNEL_SUPPORT, MBEDTLS, USE_RTOS, mqttconfigENABLE_METRICS=0, SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC, LWIP_DNS=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../../..
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor.scf
  link misc: as above
