# IAR project dev_composite_hid_audio_unified_freertos_cm7.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DATA_SECTION_IS_CACHEABLE=0; DEBUG; _DEBUG=1; CPU_MIMXRT1176DVMAA_cm7; HAL_AUDIO_ISR_PRIORITY=0; USB_STACK_FREERTOS; USB_STACK_FREERTOS_HEAP_SIZE=32768; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../../middleware/usb/example/boards/evkmimxrt1170/usb_device_composite_hid_audio_unified/freertos/cm7; ../../../../..; ../../../../../../../components/audio; ../../../../../../../components/i2c; ../../../../../../../components/codec/i2c; ../../../../../../../components/codec/port/wm8960; ../../../../../../../components/codec/port; ../../../../../../../components/codec; ../../../../../../../devices/MIMXRT1176/drivers; ../../../../../../../components/codec/wm8960; ../../../../../../../middleware/usb/device; ../../../../../../../middleware/usb/include; ../../../../../../../middleware/usb/phy; ../../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F; ../../../../../../../components/lists; ../../../../../../../components/uart; ../../../../../../../components/serial_manager; ../../../../../../../devices/MIMXRT1176; ../../../../../../../devices/MIMXRT1176/drivers/cm7; ../../../../../xip; ../../../../../../../devices/MIMXRT1176/xip; ../../../../../../../devices/MIMXRT1176/utilities; ../../../../../../../devices/MIMXRT1176/utilities/debug_console; ../../../../../../../components/osa; ../../../../../../../CMSIS/Core/Include; ../../../../../../../devices/MIMXRT1176/utilities/str
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../../../../..; ../../../../../../../rtos/freertos/freertos-kernel/include
  ILINK.IlinkOutputFile: dev_composite_hid_audio_unified_freertos_cm7.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DATA_SECTION_IS_CACHEABLE=1; USE_SDRAM; DEBUG; CPU_MIMXRT1176DVMAA_cm7; HAL_AUDIO_ISR_PRIORITY=0; USB_STACK_FREERTOS; USB_STACK_FREERTOS_HEAP_SIZE=32768; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DATA_SECTION_IS_CACHEABLE=0; DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1176DVMAA_cm7; HAL_AUDIO_ISR_PRIORITY=0; USB_STACK_FREERTOS; USB_STACK_FREERTOS_HEAP_SIZE=32768; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DATA_SECTION_IS_CACHEABLE=0; NDEBUG; _DEBUG=0; CPU_MIMXRT1176DVMAA_cm7; HAL_AUDIO_ISR_PRIORITY=0; USB_STACK_FREERTOS; USB_STACK_FREERTOS_HEAP_SIZE=32768; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DATA_SECTION_IS_CACHEABLE=1; NDEBUG; USE_SDRAM; CPU_MIMXRT1176DVMAA_cm7; HAL_AUDIO_ISR_PRIORITY=0; USB_STACK_FREERTOS; USB_STACK_FREERTOS_HEAP_SIZE=32768; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DATA_SECTION_IS_CACHEABLE=0; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; HAL_AUDIO_ISR_PRIORITY=0; USB_STACK_FREERTOS; USB_STACK_FREERTOS_HEAP_SIZE=32768; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group source
    ../: usb_audio_config.h audio_unified.c audio_unified.h composite.c composite.h hid_keyboard.c hid_keyboard.h usb_device_descriptor.c usb_device_descriptor.h usb_device_config.h FreeRTOSConfig.h
  group doc
    ../: readme.txt
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/audio
    ../: usb_device_audio.c usb_device_audio.h
  group usb/device/class/hid
    ../: usb_device_hid.c usb_device_hid.h
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h usb_device_dci.h
  group usb/device/source/ehci
    ../../../../../../../middleware/usb/device/: usb_device_ehci.c usb_device_ehci.h
  group usb/device/include
    ../../../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group usb/phy
    ../../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group usb/include
    ../../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group component/audio
    ../../../../../../../components/audio/: fsl_adapter_audio.h fsl_adapter_sai.c
  group component/i2c
    ../../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/osa
    ../../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c
  group codec
    ../../../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
    ../../../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../../../components/codec/wm8960/: fsl_wm8960.h fsl_wm8960.c
  group codec/port
    ../../../../../../../components/codec/port/: fsl_codec_adapter.h
  group codec/port/wm8960
    ../../../../../../../components/codec/port/wm8960/: fsl_codec_wm8960_adapter.c fsl_codec_wm8960_adapter.h
  group drivers
    ../../../../../../../devices/MIMXRT1176/drivers/: fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_lpi2c.c fsl_lpi2c.h fsl_sai.h fsl_sai.c fsl_sai_edma.h fsl_sai_edma.c fsl_lpuart.h fsl_lpuart.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_dcdc.h fsl_dcdc.c fsl_gpio.h fsl_gpio.c fsl_iomuxc.h fsl_pmu.h fsl_pmu.c fsl_memory.h fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group freertos/freertos-kernel
    ../../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable
    ../../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/IAR/ARM_CM4F
    ../../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group device
    ../../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group startup
    ../../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group xip
    ../../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
    ../../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
  group utilities
    ../../../../../../../devices/MIMXRT1176/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../../../devices/MIMXRT1176/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
