# IAR project host_cdc_freertos_cm7.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: _DEBUG=1; DEBUG; CPU_MIMXRT1176DVMAA_cm7; DEBUG_CONSOLE_RX_ENABLE=0; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; DEBUG_CONSOLE_RECEIVE_BUFFER_LEN=16; DEBUG_CONSOLE_TRANSMIT_BUFFER_LEN=128; USB_STACK_FREERTOS; USB_STACK_FREERTOS_HEAP_SIZE=32768; configAPPLICATION_ALLOCATED_HEAP=1; FSL_RTOS_FREE_RTOS; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SERIAL_PORT_TYPE_UART=1; SDK_DEBUGCONSOLE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../..; ../../../../../../../middleware/usb/host; ../../../../../../../middleware/usb/include; ../../../../../../../middleware/usb/phy; ../../../../../../../rtos/freertos/freertos_kernel/include; ../../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F; ../../../../../../../middleware/usb/host/class; ../../../../../../../devices/MIMXRT1176/drivers; ../../../../../../../devices/MIMXRT1176; ../../../../../../../CMSIS/Include; ../../../../../../../devices/MIMXRT1176/utilities/str; ../../../../../../../devices/MIMXRT1176/utilities/debug_console; ../../../../../../../components/uart; ../../../../../../../components/serial_manager; ../../../../../../../components/lists; ../../../../../../../devices/MIMXRT1176/xip; ../../../../../xip; ../../../../../../../components/osa; ../../../../../../../devices/MIMXRT1176/drivers/cm7
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../../../../..
  ILINK.IlinkOutputFile: host_cdc_freertos_cm7.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1176DVMAA_cm7; DEBUG_CONSOLE_RX_ENABLE=0; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; DEBUG_CONSOLE_RECEIVE_BUFFER_LEN=16; DEBUG_CONSOLE_TRANSMIT_BUFFER_LEN=128; USB_STACK_FREERTOS; USB_STACK_FREERTOS_HEAP_SIZE=32768; configAPPLICATION_ALLOCATED_HEAP=1; FSL_RTOS_FREE_RTOS; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SERIAL_PORT_TYPE_UART=1; SDK_DEBUGCONSOLE=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DATA_SECTION_IS_CACHEABLE=1; USE_SDRAM; DEBUG; CPU_MIMXRT1176DVMAA_cm7; DEBUG_CONSOLE_RX_ENABLE=0; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; DEBUG_CONSOLE_RECEIVE_BUFFER_LEN=16; DEBUG_CONSOLE_TRANSMIT_BUFFER_LEN=128; USB_STACK_FREERTOS; USB_STACK_FREERTOS_HEAP_SIZE=32768; configAPPLICATION_ALLOCATED_HEAP=1; FSL_RTOS_FREE_RTOS; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SERIAL_PORT_TYPE_UART=1; SDK_DEBUGCONSOLE=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; DEBUG_CONSOLE_RX_ENABLE=0; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; DEBUG_CONSOLE_RECEIVE_BUFFER_LEN=16; DEBUG_CONSOLE_TRANSMIT_BUFFER_LEN=128; USB_STACK_FREERTOS; USB_STACK_FREERTOS_HEAP_SIZE=32768; configAPPLICATION_ALLOCATED_HEAP=1; FSL_RTOS_FREE_RTOS; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SERIAL_PORT_TYPE_UART=1; SDK_DEBUGCONSOLE=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; DEBUG_CONSOLE_RX_ENABLE=0; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; DEBUG_CONSOLE_RECEIVE_BUFFER_LEN=16; DEBUG_CONSOLE_TRANSMIT_BUFFER_LEN=128; USB_STACK_FREERTOS; USB_STACK_FREERTOS_HEAP_SIZE=32768; configAPPLICATION_ALLOCATED_HEAP=1; FSL_RTOS_FREE_RTOS; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SERIAL_PORT_TYPE_UART=1; SDK_DEBUGCONSOLE=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DATA_SECTION_IS_CACHEABLE=1; NDEBUG; USE_SDRAM; CPU_MIMXRT1176DVMAA_cm7; DEBUG_CONSOLE_RX_ENABLE=0; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; DEBUG_CONSOLE_RECEIVE_BUFFER_LEN=16; DEBUG_CONSOLE_TRANSMIT_BUFFER_LEN=128; USB_STACK_FREERTOS; USB_STACK_FREERTOS_HEAP_SIZE=32768; configAPPLICATION_ALLOCATED_HEAP=1; FSL_RTOS_FREE_RTOS; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SERIAL_PORT_TYPE_UART=1; SDK_DEBUGCONSOLE=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
  group doc
    ../: readme.txt
  group source
    ../: app.h app.c host_cdc.c host_cdc.h usb_host_config.h FreeRTOSConfig.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h dcd.c dcd.h
  group usb/host
    ../../../../../../../middleware/usb/host/: usb_host_ehci.c usb_host_ehci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c usb_host.h usb_host_hci.h usb_host_devices.h usb_host_framework.h
  group usb/host/class
    ../../../../../../../middleware/usb/host/class/: usb_host_cdc.c usb_host_cdc.h usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h
  group usb/phy
    ../../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group usb/include
    ../../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group freertos/freertos_kernel
    ../../../../../../../rtos/freertos/freertos_kernel/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/include
    ../../../../../../../rtos/freertos/freertos_kernel/include/: croutine.h StackMacros.h atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group drivers
    ../../../../../../../devices/MIMXRT1176/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group device
    ../../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group utilities
    ../../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MIMXRT1176/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/MIMXRT1176/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/osa
    ../../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c
  group startup
    ../../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group xip
    ../../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
