# Keil uVision project host_msd_fatfs_bm_cm7.uvprojx, settings and files
target host_msd_fatfs_bm_cm7 debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: host_msd_fatfs_bm_cm7.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _DEBUG=1, DEBUG, CPU_MIMXRT1176DVMAA_cm7, USB_STACK_BM, PRINTF_ADVANCED_ENABLE=1, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SDK_DEBUGCONSOLE=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../../middleware/usb/host;../../../../../../../middleware/usb/include;../../../../../../../middleware/usb/phy;../../../../../../../devices/MIMXRT1176/utilities/debug_console_lite;../../../../../../../middleware/usb/host/class;../../../../../../../middleware/fatfs/source;../../../../../../../middleware/fatfs/source/fsl_usb_disk;../../../../../../../devices/MIMXRT1176/drivers;../../../../../../../devices/MIMXRT1176;../../../../../../../CMSIS/Include;../../../../../../../components/uart;../../../../../../../components/lists;../../../../../../../devices/MIMXRT1176/xip;../../../../../xip;../../../../../../../components/osa;../../../../../../../devices/MIMXRT1176/drivers/cm7
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_ram.scf
  link misc: --remove --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x2000"
  group doc
    ../: readme.txt
  group source
    ../: app.h app.c host_msd_fatfs.c ffconf.h host_msd_fatfs.h usb_host_config.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h dcd.c dcd.h
  group usb/host
    ../../../../../../../middleware/usb/host/: usb_host_ehci.c usb_host_ehci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c usb_host.h usb_host_hci.h usb_host_devices.h usb_host_framework.h
  group usb/phy
    ../../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group utilities
    ../../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group usb/host/class
    ../../../../../../../middleware/usb/host/class/: usb_host_msd.c usb_host_msd.h usb_host_msd_ufi.c usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h
  group fatfs/source
    ../../../../../../../middleware/fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c diskio.h ff.h
  group fatfs/source/fsl_usb_disk
    ../../../../../../../middleware/fatfs/source/fsl_usb_disk/: fsl_usb_disk.h fsl_usb_disk_bm.c
  group drivers
    ../../../../../../../devices/MIMXRT1176/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group device
    ../../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../../devices/MIMXRT1176/arm/: startup_MIMXRT1176_cm7.S
  group xip
    ../../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
  group component/osa
    ../../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c
  group usb/include
    ../../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
target host_msd_fatfs_bm_cm7 flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: host_msd_fatfs_bm_cm7.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DATA_SECTION_IS_CACHEABLE=1, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1176DVMAA_cm7, USB_STACK_BM, PRINTF_ADVANCED_ENABLE=1, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SDK_DEBUGCONSOLE=1
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor.scf
  link misc: --remove --legacyalign --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x2000"
target host_msd_fatfs_bm_cm7 sdram_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: host_msd_fatfs_bm_cm7.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DATA_SECTION_IS_CACHEABLE=1, USE_SDRAM, DEBUG, CPU_MIMXRT1176DVMAA_cm7, USB_STACK_BM, PRINTF_ADVANCED_ENABLE=1, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SDK_DEBUGCONSOLE=1
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_sdram.scf
  link misc: --remove --predefine="-D__heap_noncacheable__=1" --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x2000"
target host_msd_fatfs_bm_cm7 release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: host_msd_fatfs_bm_cm7.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _DEBUG=0, NDEBUG, CPU_MIMXRT1176DVMAA_cm7, USB_STACK_BM, PRINTF_ADVANCED_ENABLE=1, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SDK_DEBUGCONSOLE=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_ram.scf
  link misc: as above
target host_msd_fatfs_bm_cm7 flexspi_nor_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: host_msd_fatfs_bm_cm7.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DATA_SECTION_IS_CACHEABLE=1, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1176DVMAA_cm7, USB_STACK_BM, PRINTF_ADVANCED_ENABLE=1, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SDK_DEBUGCONSOLE=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor.scf
  link misc: as above
target host_msd_fatfs_bm_cm7 sdram_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: host_msd_fatfs_bm_cm7.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DATA_SECTION_IS_CACHEABLE=1, USE_SDRAM, NDEBUG, CPU_MIMXRT1176DVMAA_cm7, USB_STACK_BM, PRINTF_ADVANCED_ENABLE=1, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SDK_DEBUGCONSOLE=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_sdram.scf
  link misc: as above
