# IAR project wifi_webconfig_cm7.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0; CPU_MIMXRT1176DVMAA_cm7; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; LWIP_NETIF_API=1; HTTPSRV_CFG_WEBSOCKET_ENABLED=1; HTTPSRV_CFG_DEFAULT_SES_CNT=8; SDK_DEBUGCONSOLE_UART; MFLASH_FILE_BASEADDR=14221312; SDK_OS_FREE_RTOS; SDIO_ENABLED; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.PreInclude: ../app_config.h
  ICCARM.CCIncludePath2: ..; ../../../common/cm7; ../../../..; ../../../../../../components/flash/mflash; ../../../../../../components/flash/mflash/mimxrt1170; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../devices/MIMXRT1176/drivers/cm7; ../../../../../../middleware/wifi_nxp/incl; ../../../../../../middleware/wifi_nxp/incl/port/os; ../../../../../../middleware/wifi_nxp/incl/wifidriver; ../../../../../../middleware/wifi_nxp/incl/wlcmgr; ../../../../../../middleware/wifi_nxp/wifi_bt_firmware; ../../../../../../middleware/wifi_nxp/wifidriver; ../../../../../../middleware/wifi_nxp/wifidriver/incl; ../../../../../../rtos/freertos/freertos_kernel/include; ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F; ../../../../../../devices/MIMXRT1176/utilities/str; ../../../../../../devices/MIMXRT1176/utilities/debug_console; ../../../../../../middleware/sdmmc/sdio; ../../../../../../middleware/sdmmc/common; ../../../../../../middleware/sdmmc/host/usdhc; ../../../../../../components/gpio; ../../../../../../middleware/lwip/src/apps/httpsrv; ../../../../../../middleware/lwip/port; ../../../../../../middleware/lwip/src; ../../../../../../middleware/lwip/src/include; ../../../../../../middleware/wifi_nxp/dhcpd; ../../../../../../middleware/wifi_nxp/incl/port/lwip; ../../../../../../middleware/wifi_nxp/port/lwip; ../../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits; ../../../../../../components/wifi_bt_module/Murata/tx_pwr_limits; ../../../../../../devices/MIMXRT1176; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1176/xip; ../../../../xip; ../../../../../../components/silicon_id; ../../../../../../CMSIS/Core/Include; ../../../../../../middleware/sdmmc/osa; ../../../../../../components/osa; ../../../../../../middleware/edgefast_wifi/include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: wifi_webconfig_cm7.out
  ILINK.IlinkConfigDefines: __stack_size__=2048; __heap_size__=90000
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0; CPU_MIMXRT1176DVMAA_cm7; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; LWIP_NETIF_API=1; HTTPSRV_CFG_WEBSOCKET_ENABLED=1; HTTPSRV_CFG_DEFAULT_SES_CNT=8; SDK_DEBUGCONSOLE_UART; MFLASH_FILE_BASEADDR=14221312; SDK_OS_FREE_RTOS; SDIO_ENABLED; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: lwipopts.h lwippools.h app_config.h webconfig.c webconfig.h cred_flash_storage.c cred_flash_storage.h http_server.c http_server.h FreeRTOSConfig.h wifi_config.h
  group board
    ../: pin_mux.c pin_mux.h sdmmc_config.c sdmmc_config.h wifi_bt_config.c wifi_bt_config.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group lwip/src/apps/httpsrv
    ../: httpsrv_fs_data.c
    ../../../../../../middleware/lwip/src/apps/httpsrv/: httpsrv.c httpsrv.h httpsrv_base64.c httpsrv_base64.h httpsrv_config.h httpsrv_fs.c httpsrv_fs.h httpsrv_port.h httpsrv_prv.h httpsrv_script.c httpsrv_script.h httpsrv_sha1.c httpsrv_sha1.h httpsrv_supp.c httpsrv_supp.h httpsrv_task.c httpsrv_tls.c httpsrv_tls.h httpsrv_utf8.c httpsrv_utf8.h httpsrv_ws.c httpsrv_ws.h httpsrv_ws_api.c httpsrv_ws_prv.h
  group lwip/src/api
    ../../../../../../middleware/lwip/src/api/: sockets.c netifapi.c netdb.c netbuf.c tcpip.c api_msg.c err.c if_api.c api_lib.c
  group lwip/src/core
    ../../../../../../middleware/lwip/src/core/: memp.c def.c ip.c pbuf.c altcp.c tcp_out.c raw.c altcp_tcp.c sys.c init.c inet_chksum.c timeouts.c tcp_in.c netif.c mem.c udp.c tcp.c stats.c dns.c altcp_alloc.c
  group lwip/src/core/ipv6
    ../../../../../../middleware/lwip/src/core/ipv6/: ethip6.c dhcp6.c ip6_addr.c nd6.c mld6.c icmp6.c ip6_frag.c ip6.c inet6.c
  group lwip/src/core/ipv4
    ../../../../../../middleware/lwip/src/core/ipv4/: dhcp.c ip4.c autoip.c icmp.c acd.c etharp.c ip4_addr.c igmp.c ip4_frag.c
  group lwip/src/include/compat/stdc
    ../../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/compat/posix
    ../../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/sys
    ../../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/posix/net
    ../../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/lwip
    ../../../../../../middleware/lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/priv
    ../../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h mem_priv.h memp_priv.h memp_std.h api_msg.h nd6_priv.h tcpip_priv.h tcp_priv.h raw_priv.h sockets_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../../middleware/lwip/src/include/lwip/prot/: ip6.h udp.h mld6.h ip4.h icmp.h igmp.h dhcp.h tcp.h autoip.h iana.h ieee.h dns.h icmp6.h ethernet.h nd6.h ip.h acd.h dhcp6.h etharp.h
  group lwip/src/include/netif
    ../../../../../../middleware/lwip/src/include/netif/: bridgeif.h zepif.h lowpan6.h ieee802154.h ethernet.h lowpan6_common.h lowpan6_opts.h bridgeif_opts.h slipif.h lowpan6_ble.h etharp.h
  group lwip/src/include/netif/ppp
    ../../../../../../middleware/lwip/src/include/netif/ppp/: ipv6cp.h pppapi.h magic.h ppp.h upap.h mppe.h pppol2tp.h pppoe.h ipcp.h pppdebug.h eap.h pppos.h ppp_opts.h pppcrypt.h vj.h chap-new.h eui64.h chap_ms.h ccp.h ecp.h lcp.h fsm.h ppp_impl.h chap-md5.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: sha1.h des.h md5.h md4.h arc4.h
  group lwip/src/netif
    ../../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lwip/port
    ../../../../../../middleware/lwip/port/: sys_arch.c
  group lwip/port/arch
    ../../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group doc
    ../: readme.txt
  group evkmimxrt1170
    ../: evkmimxrt1170_connect_cm4_cm7side.jlinkscript
  group flash/mflash
    ../../../../../../components/flash/mflash/: mflash_file.h mflash_file.c mflash_common.h
  group flash/mflash/mimxrt1170
    ../../../../../../components/flash/mflash/mimxrt1170/: mflash_drv.h mflash_drv.c
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_flexspi.c fsl_flexspi.h fsl_clock.h fsl_clock.c fsl_usdhc.c fsl_usdhc.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_anatop_ai.h fsl_anatop_ai.c fsl_memory.h
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group wifi/incl
    ../../../../../../middleware/wifi_nxp/incl/: dhcp-server.h WIFI_IW416_BOARD_AW_AM457_CAL_DATA_EXT.h wm_utils.h wmerrno.h wmlog.h wmtypes.h wmstats.h
  group wifi/incl/wlcmgr
    ../../../../../../middleware/wifi_nxp/incl/wlcmgr/: wlan.h wlan_11d.h
  group wifi/incl/port/os
    ../../../../../../middleware/wifi_nxp/incl/port/os/: wm_os.h
  group wifi/incl/port/lwip
    ../../../../../../middleware/wifi_nxp/incl/port/lwip/: wm_net.h
  group wifi/incl/wifidriver
    ../../../../../../middleware/wifi_nxp/incl/wifidriver/: wifi-decl.h wifi.h wifi_events.h mlan_sdio_api.h
  group wifi/wifidriver
    ../../../../../../middleware/wifi_nxp/wifidriver/: mlan_11ac.c mlan_11ax.c mlan_11d.c mlan_11h.c mlan_11n.c mlan_11n_aggr.c mlan_11n_rxreorder.c mlan_api.c mlan_cfp.c mlan_cmdevt.c mlan_glue.c mlan_init.c mlan_join.c mlan_misc.c mlan_scan.c mlan_shim.c mlan_sta_cmd.c mlan_sta_cmdresp.c mlan_sta_event.c mlan_sta_ioctl.c mlan_sta_rx.c mlan_txrx.c mlan_uap_cmdevent.c mlan_uap_ioctl.c mlan_wmm.c wifi-debug.c wifi-debug.h wifi-internal.h wifi-mem.c wifi-uap.c wifi.c wifi_common.h wifi_pwrmgr.c wifi-sdio.c sdio.c sdio.h firmware_dnld.c firmware_dnld.h mlan_sdio.c wifi-sdio.h
  group wifi/wifidriver/incl
    ../../../../../../middleware/wifi_nxp/wifidriver/incl/: mlan.h mlan_11ac.h mlan_11ax.h mlan_11h.h mlan_11n.h mlan_11n_aggr.h mlan_11n_rxreorder.h mlan_api.h mlan_fw.h mlan_ieee.h mlan_init.h mlan_join.h mlan_main.h mlan_meas.h mlan_remap_mem_operations.h mlan_uap.h mlan_util.h mlan_wmm.h mlan_main_defs.h mlan_ioctl.h mlan_decl.h type_decls.h mlan_sdio_defs.h mlan_sdio.h
  group wifi/port/os
    ../../../../../../middleware/wifi_nxp/port/os/: os.c
  group wifi/port/lwip
    ../../../../../../middleware/wifi_nxp/port/lwip/: net.c netif_decl.h wifi_netif.c
  group wifi/wifi_bt_firmware
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/: sd8801_wlan.h sduart8977_wlan_bt.h sduartIW416_wlan_bt.h sduart8987_wlan_bt.h wlan_bt_fw.h
  group wifi/dhcpd
    ../../../../../../middleware/wifi_nxp/dhcpd/: dhcp-bootp.h dhcp-priv.h dhcp-server-main.c dhcp-server.c dns-server.c dns.h
  group wifi/wlcmgr
    ../../../../../../middleware/wifi_nxp/wlcmgr/: wlan.c wlan_txpwrlimit_cfg.c
  group freertos/freertos_kernel
    ../../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    ../../../../../../rtos/freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos_kernel/portable
    ../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: ReadMe.url heap_3.c
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1176/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1176/utilities/: fsl_assert.c
  group sdmmc/src
    ../../../../../../middleware/sdmmc/sdio/: fsl_sdio.c
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../../middleware/sdmmc/sdio/: fsl_sdio.h
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sdio
    ../../../../../../middleware/sdmmc/sdio/: ChangeLogKSDK.txt
  group sdmmc/host
    ../../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt
    ../../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group sdmmc/osa
    ../../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group component/gpio
    ../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group component/wifi_bt_module/AzureWave/tx_pwr_limits
    ../../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits/: wlan_txpwrlimit_cfg_WW.h
  group component/wifi_bt_module/Murata/tx_pwr_limits
    ../../../../../../components/wifi_bt_module/Murata/tx_pwr_limits/: wlan_txpwrlimit_cfg_murata_1XK_CA.h wlan_txpwrlimit_cfg_murata_1XK_EU.h wlan_txpwrlimit_cfg_murata_1XK_JP.h wlan_txpwrlimit_cfg_murata_1XK_US.h wlan_txpwrlimit_cfg_murata_1XK_WW.h wlan_txpwrlimit_cfg_murata_1ZM_CA.h wlan_txpwrlimit_cfg_murata_1ZM_EU.h wlan_txpwrlimit_cfg_murata_1ZM_JP.h wlan_txpwrlimit_cfg_murata_1ZM_US.h wlan_txpwrlimit_cfg_murata_1ZM_WW.h wlan_txpwrlimit_cfg_murata_2DS_CA.h wlan_txpwrlimit_cfg_murata_2DS_EU.h wlan_txpwrlimit_cfg_murata_2DS_JP.h wlan_txpwrlimit_cfg_murata_2DS_US.h wlan_txpwrlimit_cfg_murata_2DS_WW.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/silicon_id
    ../../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c
  group edgefast_wifi/source
    ../../../../../../middleware/edgefast_wifi/source/: wpl_nxp.c
  group edgefast_wifi/include
    ../../../../../../middleware/edgefast_wifi/include/: wpl.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group startup
    ../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group xip
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
