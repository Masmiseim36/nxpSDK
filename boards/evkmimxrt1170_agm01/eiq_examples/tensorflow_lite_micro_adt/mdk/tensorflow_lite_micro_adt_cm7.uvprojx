# Keil uVision project tensorflow_lite_micro_adt_cm7.uvprojx, settings and files
target tensorflow_lite_micro_adt_cm7 flexspi_nor_sdram_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: tensorflow_lite_micro_adt_cm7.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, DEBUG, __STDC_CONSTANT_MACROS, __CLK_TCK=1000000, CPU_MIMXRT1176DVMAA_cm7, SDK_DEBUGCONSOLE_UART, ARM_MATH_CM7, __FPU_PRESENT=1, SDK_I2C_BASED_COMPONENT_USED=1, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, TF_LITE_STATIC_MEMORY, CMSIS_NN, MCUXPRESSO_SDK
  c misc: -Wno-missing-field-initializers  -Wno-self-assign  -Wno-unreachable-code  -fno-exceptions  -Wno-c++17-extensions  -fno-common  -fdata-sections  -mthumb
  c include: ..;../../../../../middleware/eiq/tensorflow-lite/examples/adt;../../../../../middleware/eiq/common/model;../../../../../middleware/eiq/common;../../../../../middleware/issdk/drivers/gpio/i.mx;../../../../../middleware/issdk/drivers/gpio;../../../../../middleware/issdk/sensors;../../../../../devices/MIMXRT1176/drivers;../../../../../devices/MIMXRT1176/cmsis_drivers;../../../../../CMSIS/Driver/Include;../../../../../devices/MIMXRT1176/utilities/debug_console_lite;../../../../../middleware/eiq/common/sensor;../../../../../middleware/eiq/tensorflow-lite;../../../../../components/lists;../../../../../components/uart;../../../../../devices/MIMXRT1176;../../../../../devices/MIMXRT1176/xip;../../../../evkmimxrt1170/xip;../../../../../CMSIS/Core/Include;../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include;../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp;../../../../../middleware/eiq/tensorflow-lite/third_party/ruy;../../../../../middleware/eiq/tensorflow-lite/third_party;../../../../../CMSIS/DSP/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: ../../../../../devices/MIMXRT1176/arm/MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.scf
  link misc: ../../../../../CMSIS/DSP/Lib/ARM/arm_cortexM7lfdp_math.lib --remove --predefine="-D__stack_size__=0x10000" --predefine="-D__heap_size__=0x80000" --entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group board
    ../: frdm_stbc_agm01_shield.h issdk_hal.h RTE_Device.h evkmimxrt1170.c evkmimxrt1170.h systick_utils.c systick_utils.h pin_mux.c pin_mux.h board.c board.h board_init.c board_init.h clock_config.c clock_config.h dcd.c dcd.h
    ../../../../../middleware/issdk/drivers/systick/: systick_utils.h
    ./: retarget.c
  group source
    ../../../../../middleware/eiq/tensorflow-lite/examples/adt/: main.cpp model_data.h sensor_data.h demo_config.h
    ../../../../../middleware/eiq/common/: demo_info.h timer.h timer.c
    ../../../../../middleware/eiq/tensorflow-lite/examples/common/: demo_info.cpp
  group source/model
    ../../../../../middleware/eiq/tensorflow-lite/examples/adt/: output_postproc.cpp output_postproc.h model_adt_ops_micro.cpp
    ../../../../../middleware/eiq/common/model/: model.h
    ../../../../../middleware/eiq/tensorflow-lite/examples/: model.cpp
  group doc
    ../../../../../middleware/eiq/tensorflow-lite/examples/adt/adt_train/: adt_model.tflite adt_train.py input_data.txt keras_model.h5 requirements.txt validation_data.txt
    ../: readme.txt
  group gpio_driver
    ../../../../../middleware/issdk/drivers/gpio/i.mx/: gpio_driver.c gpio_driver.h
    ../../../../../middleware/issdk/drivers/gpio/: Driver_GPIO.h
  group interfaces
    ../../../../../middleware/issdk/sensors/: register_io_i2c.c register_io_spi.c sensor_io_spi.c sensor_io_i2c.c register_io_i2c.h register_io_spi.h sensor_io_spi.h sensor_io_i2c.h sensor_drv.h
  group sensors
    ../../../../../middleware/issdk/sensors/: fxas21002.h fxas21002_drv.h fxas21002_drv.c fxos8700.h fxos8700_drv.h fxos8700_drv.c
  group drivers
    ../../../../../devices/MIMXRT1176/drivers/: fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.h fsl_lpspi_edma.c fsl_lpuart.h fsl_lpuart.c fsl_lpuart_edma.h fsl_lpuart_edma.c fsl_gpc.h fsl_gpc.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_dcdc.h fsl_dcdc.c fsl_pmu.h fsl_pmu.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_anatop_ai.h fsl_anatop_ai.c
    ../../../../../devices/MIMXRT1176/cmsis_drivers/: fsl_lpi2c_cmsis.h fsl_lpi2c_cmsis.c fsl_lpspi_cmsis.h fsl_lpspi_cmsis.c fsl_lpuart_cmsis.h fsl_lpuart_cmsis.c
  group CMSIS_driver
    ../../../../../CMSIS/Driver/Include/: Driver_Common.h Driver_SPI.h Driver_USART.h Driver_I2C.h
  group utilities
    ../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group source/sensor
    ../../../../../middleware/eiq/common/sensor/: sensor_capture.c sensor_raw.c sensor.h sensor_raw.h
  group eiq/tensorflow-lite/tensorflow/core/public
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/core/public/: version.h
  group eiq/tensorflow-lite/tensorflow/lite
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/: portable_type_to_tflitetype.h version.h
  group eiq/tensorflow-lite/tensorflow/lite/c
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/c/: common.h common.c builtin_op_data.h
  group eiq/tensorflow-lite/tensorflow/lite/core/api
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/api/: error_reporter.h flatbuffer_conversions.h op_resolver.h profiler.h tensor_utils.h error_reporter.cpp flatbuffer_conversions.cpp op_resolver.cpp tensor_utils.cpp
  group eiq/tensorflow-lite/tensorflow/lite/kernels
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/: kernel_util.h kernel_utils.cpp op_macros.h padding.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/: common.h compatibility.h cppmath.h max.h min.h portable_tensor.h quantization_util.h quantization_util.cpp strided_slice_logic.h tensor_ctypes.h types.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized/: neon_check.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/: add.h arg_min_max.h binary_function.h ceil.h comparisons.h concatenation.h conv.h depthwiseconv_float.h depthwiseconv_uint8.h dequantize.h floor.h fully_connected.h hard_swish.h l2normalization.h logistic.h maximum_minimum.h mul.h neg.h pad.h pooling.h prelu.h process_broadcast_shapes.h quantize.h reduce.h requantize.h resize_nearest_neighbor.h round.h softmax.h strided_slice.h sub.h tanh.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops/: add.h conv.h depthwise_conv.h fully_connected.h l2normalization.h logistic.h mean.h mul.h pooling.h tanh.h
  group eiq/tensorflow-lite/tensorflow/lite/micro
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/: all_ops_resolver.cpp all_ops_resolver.h compatibility.h debug_log.cpp debug_log.h memory_helpers.cpp memory_helpers.h micro_allocator.cpp micro_allocator.h micro_error_reporter.cpp micro_error_reporter.h micro_interpreter.cpp micro_interpreter.h micro_mutable_op_resolver.h micro_op_resolver.h micro_profiler.cpp micro_profiler.h micro_string.cpp micro_string.h micro_time.cpp micro_time.h micro_utils.cpp micro_utils.h recording_micro_allocator.cpp recording_micro_allocator.h recording_micro_interpreter.h recording_simple_memory_allocator.cpp recording_simple_memory_allocator.h simple_memory_allocator.cpp simple_memory_allocator.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/: activation_utils.h fully_connected.h kernel_runner.h kernel_util.h micro_ops.h micro_utils.h arg_min_max.cpp ceil.cpp circular_buffer.cpp comparisons.cpp concatenation.cpp dequantize.cpp elementwise.cpp ethosu.cpp hard_swish.cpp kernel_runner.cpp kernel_util.cpp l2norm.cpp logical.cpp maximum_minimum.cpp neg.cpp pack.cpp pad.cpp prelu.cpp quantize.cpp reduce.cpp reshape.cpp resize_nearest_neighbor.cpp round.cpp shape.cpp split.cpp split_v.cpp strided_slice.cpp sub.cpp tanh.cpp unpack.cpp activations.cpp floor.cpp logistic.cpp
  group eiq/tensorflow-lite/tensorflow/lite/micro/memory_planner
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.h linear_memory_planner.h memory_planner.h greedy_memory_planner.cpp linear_memory_planner.cpp
  group eiq/tensorflow-lite/tensorflow/lite/schema
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/schema/: schema_utils.cpp schema_generated.h schema_utils.h
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group device
    ../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group startup
    ../../../../../devices/MIMXRT1176/arm/: startup_MIMXRT1176_cm7.S
  group xip
    ../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../evkmimxrt1170/xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels/cmsis-nn
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/cmsis-nn/: add.cpp conv.cpp depthwise_conv.cpp fully_connected.cpp mul.cpp pooling.cpp softmax.cpp svdf.cpp
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group eiq/tensorflow-lite/third_party/flatbuffers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/: readme.md LICENSE.txt
  group eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/: base.h flatbuffers.h stl_emulation.h
  group eiq/tensorflow-lite/third_party/gemmlowp
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/: LICENSE README.md
  group eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint/: fixedpoint.h
  group eiq/tensorflow-lite/third_party/gemmlowp/internal
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/internal/: detect_platform.h
  group eiq/tensorflow-lite/third_party/ruy
    ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/: LICENSE README.md
  group eiq/tensorflow-lite/third_party/ruy/ruy/profiler
    ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/ruy/profiler/: instrumentation.h
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/Core/Include
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/DSP/Include
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/DSP/Include/: arm_common_tables.h arm_math.h arm_math_memory.h arm_math_types.h
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/DSP/Include/dsp
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/DSP/Include/dsp/: basic_math_functions.h bayes_functions.h complex_math_functions.h controller_functions.h distance_functions.h fast_math_functions.h filtering_functions.h interpolation_functions.h matrix_functions.h none.h statistics_functions.h support_functions.h svm_defines.h svm_functions.h transform_functions.h utils.h
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Include
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Include/: arm_nn_tables.h arm_nn_types.h arm_nnfunctions.h arm_nnsupportfunctions.h
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ActivationFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ActivationFunctions/: arm_nn_activations_q15.c arm_nn_activations_q7.c arm_relu6_s8.c arm_relu_q15.c arm_relu_q7.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/BasicMathFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/BasicMathFunctions/: arm_elementwise_add_s8.c arm_elementwise_mul_s8.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ConcatenationFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ConcatenationFunctions/: arm_concatenation_s8_w.c arm_concatenation_s8_x.c arm_concatenation_s8_y.c arm_concatenation_s8_z.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ConvolutionFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ConvolutionFunctions/: arm_convolve_1_x_n_s8.c arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_1x1_s8_fast.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_s8.c arm_convolve_wrapper_s8.c arm_depthwise_conv_3x3_s8.c arm_depthwise_conv_s8.c arm_depthwise_conv_s8_opt.c arm_depthwise_conv_u8_basic_ver1.c arm_depthwise_conv_wrapper_s8.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_depthwise_conv_s8_core.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_nn_mat_mult_kernel_s8_s16.c arm_nn_mat_mult_kernel_s8_s16_reordered.c arm_nn_mat_mult_s8.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/FullyConnectedFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_s8.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/NNSupportFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/NNSupportFunctions/: arm_nn_accumulate_q7_to_q15.c arm_nn_add_q7.c arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_mat_mul_core_1x_s8.c arm_nn_mat_mul_core_4x_s8.c arm_nn_mat_mult_nt_t_s8.c arm_nn_mult_q15.c arm_nn_mult_q7.c arm_nn_vec_mat_mult_t_s8.c arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c arm_q7_to_q15_reordered_with_offset.c arm_q7_to_q15_with_offset.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/PoolingFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/PoolingFunctions/: arm_avgpool_s8.c arm_max_pool_s8.c arm_pool_q7_HWC.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ReshapeFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ReshapeFunctions/: arm_reshape_s8.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/SVDFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/SVDFunctions/: arm_svdf_s8.c
  group eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/SoftmaxFunctions
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/SoftmaxFunctions/: arm_softmax_q15.c arm_softmax_q7.c arm_softmax_s8.c arm_softmax_u8.c arm_softmax_with_batch_q7.c
  group eiq/tensorflow-lite/third_party/cmsis
    ../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis/: LICENSE.txt
  group CMSIS/DSP/Include
    ../../../../../CMSIS/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h
target tensorflow_lite_micro_adt_cm7 flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: tensorflow_lite_micro_adt_cm7.out
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, __STDC_CONSTANT_MACROS, __CLK_TCK=1000000, CPU_MIMXRT1176DVMAA_cm7, SDK_DEBUGCONSOLE_UART, ARM_MATH_CM7, __FPU_PRESENT=1, SDK_I2C_BASED_COMPONENT_USED=1, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, TF_LITE_STATIC_MEMORY, CMSIS_NN, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: as above
  link misc: as above
