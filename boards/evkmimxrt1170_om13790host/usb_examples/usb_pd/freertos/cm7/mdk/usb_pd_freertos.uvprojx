# Keil uVision project usb_pd_freertos.uvprojx, settings and files
target usb_pd_freertos debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: usb_pd_freertos.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _DEBUG=1, DEBUG, CPU_MIMXRT1176DVMAA_cm7, DEBUG_CONSOLE_TRANSMIT_BUFFER_LEN=600, SDK_OS_FREE_RTOS, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, USB_STACK_FREERTOS_HEAP_SIZE=8192, I2C_RETRY_TIMES=40000, DEBUG_CONSOLE_ASSERT_DISABLE=1, SERIAL_PORT_TYPE_UART=1, SDK_DEBUGCONSOLE=1, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../../evkmimxrt1170;..;../../../../../../../middleware/usb/pd;../../../../../../../components/osa;../../../../../../../devices/MIMXRT1176/drivers;../../../../../../../devices/MIMXRT1176;../../../../../../../devices/MIMXRT1176/xip;../../../../../../evkmimxrt1170/xip;../../../../../../../devices/MIMXRT1176/utilities/str;../../../../../../../devices/MIMXRT1176/utilities/debug_console;../../../../../../../components/lists;../../../../../../../components/gpio;../../../../../../../components/timer;../../../../../../../components/uart;../../../../../../../components/serial_manager;../../../../../../../components/i2c;../../../../../../../middleware/usb/pd/ptn5110;../../../../../../../middleware/usb/pd/phy_interface;../../../../../../../CMSIS/Core/Include;../../../../../../../middleware/usb/include;../../../../../../../rtos/freertos/freertos_kernel/include;../../../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM4F
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../../../../../evkmimxrt1170
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_ram.scf
  link misc: --remove --entry=Reset_Handler --predefine="-D__stack_size__=0x800" --predefine="-D__heap_size__=0x1000"
  group doc
    ../: readme.txt
  group source
    ../: FreeRTOSConfig.h pd_board_config.h pd_app_demo.c pd_app.c pd_app.h pd_command_app.c pd_command_interface.c pd_command_interface.h pd_power_app.c pd_power_interface.c pd_power_interface.h usb_pd_config.h pd_power_nx20p3483.c pd_power_nx20p3483.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h dcd.c dcd.h
  group usb/pd
    ../../../../../../../middleware/usb/pd/: usb_pd.h usb_pd_connect.c usb_pd_interface.h usb_pd_interface.c usb_pd_msg.c usb_pd_phy.h usb_pd_policy.c usb_pd_spec.h usb_pd_timer.c usb_pd_timer.h usb_pd_auto_policy.h usb_pd.h usb_pd_interface.h usb_pd_phy.h usb_pd_spec.h usb_pd_timer.c usb_pd_timer.h
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group component/osa
    ../../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c
  group drivers
    ../../../../../../../devices/MIMXRT1176/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_gpio.h fsl_gpio.c fsl_anatop_ai.h fsl_anatop_ai.c fsl_lpi2c.c fsl_lpi2c.h fsl_gpt.c fsl_gpt.h
  group device
    ../../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group startup
    ../../../../../../../devices/MIMXRT1176/arm/: startup_MIMXRT1176_cm7.S
  group xip
    ../../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../../../evkmimxrt1170/xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
  group utilities
    ../../../../../../../devices/MIMXRT1176/utilities/: fsl_assert.c
    ../../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MIMXRT1176/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/gpio
    ../../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group component/timer
    ../../../../../../../components/timer/: fsl_adapter_timer.h fsl_adapter_gpt.c
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/i2c
    ../../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group usb/ptn5110
    ../../../../../../../middleware/usb/pd/ptn5110/: usb_pd_ptn5110.h usb_pd_ptn5110_connect.c usb_pd_ptn5110_hal.c usb_pd_ptn5110_interface.c usb_pd_ptn5110_msg.c usb_pd_ptn5110_register.h
  group usb/phy_interface
    ../../../../../../../middleware/usb/pd/phy_interface/: usb_pd_i2c.h usb_pd_i2c.c
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
  group usb/include
    ../../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group freertos/freertos_kernel
    ../../../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    ../../../../../../../rtos/freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos_kernel/portable/GCC/ARM_CM4F
    ../../../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos/freertos_kernel/portable
    ../../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
target usb_pd_freertos flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: usb_pd_freertos.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1176DVMAA_cm7, DEBUG_CONSOLE_TRANSMIT_BUFFER_LEN=600, SDK_OS_FREE_RTOS, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, USB_STACK_FREERTOS_HEAP_SIZE=8192, I2C_RETRY_TIMES=40000, DEBUG_CONSOLE_ASSERT_DISABLE=1, SERIAL_PORT_TYPE_UART=1, SDK_DEBUGCONSOLE=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../../../../../evkmimxrt1170
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor.scf
  link misc: --remove --entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-D__stack_size__=0x800" --predefine="-D__heap_size__=0x1000"
target usb_pd_freertos sdram_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: usb_pd_freertos.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, DEBUG, CPU_MIMXRT1176DVMAA_cm7, DEBUG_CONSOLE_TRANSMIT_BUFFER_LEN=600, SDK_OS_FREE_RTOS, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, USB_STACK_FREERTOS_HEAP_SIZE=8192, I2C_RETRY_TIMES=40000, DEBUG_CONSOLE_ASSERT_DISABLE=1, SERIAL_PORT_TYPE_UART=1, SDK_DEBUGCONSOLE=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../../../../../evkmimxrt1170
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_sdram.scf
  link misc: as above
target usb_pd_freertos release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: usb_pd_freertos.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _DEBUG=0, NDEBUG, CPU_MIMXRT1176DVMAA_cm7, DEBUG_CONSOLE_TRANSMIT_BUFFER_LEN=600, SDK_OS_FREE_RTOS, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, USB_STACK_FREERTOS_HEAP_SIZE=8192, I2C_RETRY_TIMES=40000, DEBUG_CONSOLE_ASSERT_DISABLE=1, SERIAL_PORT_TYPE_UART=1, SDK_DEBUGCONSOLE=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../../../../../evkmimxrt1170
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_ram.scf
  link misc: as above
target usb_pd_freertos flexspi_nor_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: usb_pd_freertos.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1176DVMAA_cm7, DEBUG_CONSOLE_TRANSMIT_BUFFER_LEN=600, SDK_OS_FREE_RTOS, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, USB_STACK_FREERTOS_HEAP_SIZE=8192, I2C_RETRY_TIMES=40000, DEBUG_CONSOLE_ASSERT_DISABLE=1, SERIAL_PORT_TYPE_UART=1, SDK_DEBUGCONSOLE=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../../../../../evkmimxrt1170
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_flexspi_nor.scf
  link misc: as above
target usb_pd_freertos sdram_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: usb_pd_freertos.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, CPU_MIMXRT1176DVMAA_cm7, DEBUG_CONSOLE_TRANSMIT_BUFFER_LEN=600, SDK_OS_FREE_RTOS, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, USB_STACK_FREERTOS_HEAP_SIZE=8192, I2C_RETRY_TIMES=40000, DEBUG_CONSOLE_ASSERT_DISABLE=1, SERIAL_PORT_TYPE_UART=1, SDK_DEBUGCONSOLE=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../../../../../evkmimxrt1170
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176xxxxx_cm7_sdram.scf
  link misc: as above
