# IAR project usb_pd_alt_mode_dp_host_freertos.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: _DEBUG=1; DEBUG; CPU_MIMXRT1176DVMAA_cm7; USB_STACK_FREERTOS_HEAP_SIZE=10240; SDK_OS_FREE_RTOS; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; I2C_RETRY_TIMES=40000; DEBUG_CONSOLE_ASSERT_DISABLE=1; SERIAL_PORT_TYPE_UART=1; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../evkmimxrt1170; ../../../../../../../middleware/usb/pd; ../../../../../../../middleware/usb/pd/alt_mode; ../../../../../../../components/osa; ../../../../../../../devices/MIMXRT1176/drivers; ../../../../../../../devices/MIMXRT1176; ../../../../../../../devices/MIMXRT1176/xip; ../../../../../../evkmimxrt1170/xip; ../../../../../../../devices/MIMXRT1176/utilities/str; ../../../../../../../devices/MIMXRT1176/utilities/debug_console; ../../../../../../../components/lists; ../../../../../../../components/gpio; ../../../../../../../components/timer; ../../../../../../../components/uart; ../../../../../../../components/serial_manager; ../../../../../../../components/i2c; ../../../../../../../middleware/usb/pd/ptn5110; ../../../../../../../middleware/usb/pd/phy_interface; ../../../../../../../CMSIS/Core/Include; ../../../../../../../middleware/usb/include; ../../../../../../../rtos/freertos/freertos_kernel/include; ../../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../../../../../../evkmimxrt1170
  ILINK.IlinkOutputFile: usb_pd_alt_mode_dp_host_freertos.out
  ILINK.IlinkConfigDefines: __stack_size__=0x800; __heap_size__=0x1000
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1176DVMAA_cm7; USB_STACK_FREERTOS_HEAP_SIZE=10240; SDK_OS_FREE_RTOS; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; I2C_RETRY_TIMES=40000; DEBUG_CONSOLE_ASSERT_DISABLE=1; SERIAL_PORT_TYPE_UART=1; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; DEBUG; CPU_MIMXRT1176DVMAA_cm7; USB_STACK_FREERTOS_HEAP_SIZE=10240; SDK_OS_FREE_RTOS; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; I2C_RETRY_TIMES=40000; DEBUG_CONSOLE_ASSERT_DISABLE=1; SERIAL_PORT_TYPE_UART=1; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; USB_STACK_FREERTOS_HEAP_SIZE=10240; SDK_OS_FREE_RTOS; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; I2C_RETRY_TIMES=40000; DEBUG_CONSOLE_ASSERT_DISABLE=1; SERIAL_PORT_TYPE_UART=1; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; USB_STACK_FREERTOS_HEAP_SIZE=10240; SDK_OS_FREE_RTOS; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; I2C_RETRY_TIMES=40000; DEBUG_CONSOLE_ASSERT_DISABLE=1; SERIAL_PORT_TYPE_UART=1; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; USB_STACK_FREERTOS_HEAP_SIZE=10240; SDK_OS_FREE_RTOS; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; I2C_RETRY_TIMES=40000; DEBUG_CONSOLE_ASSERT_DISABLE=1; SERIAL_PORT_TYPE_UART=1; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
  group doc
    ../: readme.txt
  group source
    ../: pd_board_config.h pd_app.c pd_app.h pd_app_demo.c pd_command_app.c pd_command_interface.c pd_command_interface.h pd_power_app.c pd_power_interface.c pd_power_interface.h usb_pd_config.h pd_app_misc.h pd_dp_board_chip.c pd_dp_board_chip.h pd_crossbar_cbtl.h pd_crossbar_cbtl.c pd_ptn36502.h pd_ptn36502.c pd_dp_hpd_driver.h pd_dp_hpd_driver.c pd_power_nx20p3483.h pd_power_nx20p3483.c FreeRTOSConfig.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h dcd.c dcd.h
  group usb/pd
    ../../../../../../../middleware/usb/pd/: usb_pd.h usb_pd_connect.c usb_pd_interface.h usb_pd_interface.c usb_pd_msg.c usb_pd_phy.h usb_pd_policy.c usb_pd_spec.h usb_pd_timer.c usb_pd_timer.h usb_pd_auto_policy.h usb_pd.h usb_pd_interface.h usb_pd_phy.h usb_pd_spec.h usb_pd_timer.c usb_pd_timer.h
  group usb/pd/altmode
    ../../../../../../../middleware/usb/pd/alt_mode/: usb_pd_alt_mode.c usb_pd_alt_mode.h usb_pd_alt_mode_dp.c usb_pd_alt_mode_dp.h
  group usb/ptn5110
    ../../../../../../../middleware/usb/pd/ptn5110/: usb_pd_ptn5110.h usb_pd_ptn5110_connect.c usb_pd_ptn5110_hal.c usb_pd_ptn5110_interface.c usb_pd_ptn5110_msg.c usb_pd_ptn5110_register.h
  group usb/phy_interface
    ../../../../../../../middleware/usb/pd/phy_interface/: usb_pd_i2c.h usb_pd_i2c.c
  group usb/include
    ../../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group freertos/freertos_kernel
    ../../../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/include
    ../../../../../../../rtos/freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group component/osa
    ../../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/gpio
    ../../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group component/timer
    ../../../../../../../components/timer/: fsl_adapter_timer.h fsl_adapter_gpt.c
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/i2c
    ../../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group drivers
    ../../../../../../../devices/MIMXRT1176/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_gpio.h fsl_gpio.c fsl_anatop_ai.h fsl_anatop_ai.c fsl_lpi2c.c fsl_lpi2c.h fsl_gpt.c fsl_gpt.h
  group device
    ../../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group startup
    ../../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group xip
    ../../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../../../evkmimxrt1170/xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
  group utilities
    ../../../../../../../devices/MIMXRT1176/utilities/: fsl_assert.c
    ../../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MIMXRT1176/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
