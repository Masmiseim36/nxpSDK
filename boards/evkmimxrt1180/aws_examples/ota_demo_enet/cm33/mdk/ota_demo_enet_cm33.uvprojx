# Keil uVision project ota_demo_enet_cm33.uvprojx, settings and files
target ota_demo_enet_cm33 flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1189CVM8B:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU)  DSP
  output: ota_demo_enet_cm33.out
  AfterMake: fromelf.exe --output "$Lota_demo.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=0, DEBUG, CPU_MIMXRT1189CVM8B_cm33, MBEDTLS_CONFIG_FILE='\"ele_s400_mbedtls_config.h\"', MBEDTLS_USER_CONFIG_FILE='\"mbedtls_user_config.h\"', FSL_ETH_ENABLE_CACHE_CONTROL, ETH_RX_TASK_PRIO=6, USE_RTOS=1, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, CBOR_NO_FLOATING_POINT, DISABLE_LOGGING, MCUXPRESSO_SDK, LWIP_DISABLE_PBUF_POOL_SIZE_SANITY_CHECKS=1, CHECKSUM_GEN_IP=1, CHECKSUM_GEN_UDP=1, CHECKSUM_GEN_TCP=1, CHECKSUM_GEN_ICMP=1, CHECKSUM_GEN_ICMP6=1, CHECKSUM_CHECK_ICMP=1, CHECKSUM_CHECK_ICMP6=1, MBEDTLS_MCUX_ELE_S400_API, SDK_OS_FREE_RTOS, SERIAL_PORT_TYPE_UART=1, CACHE_MODE_WRITE_THROUGH=1, LWIP_DNS=1, MFLASH_FILE_BASEADDR=14221312, MQTT_AGENT_DO_NOT_USE_CUSTOM_CONFIG, MBEDTLS_THREADING_ALT, MBEDTLS_THREADING_C
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../config_files;../bootutil_port;../bootutil_port/mcuboot_config;../bootutil_port/sysflash;../bootutil_port/board_specific;../ota;../../../..;../../../../../../devices/MIMXRT1189/drivers;../../../../../../components/phy/device/phyrtl8211f;../../../../../../components/phy/device/phyrtl8201;../../../../../../middleware/lwip/port;../../../../../../middleware/lwip/src;../../../../../../middleware/lwip/src/include;../../../../../../middleware/mbedtls/include;../../../../../../middleware/mbedtls/library;../../../../../../middleware/mbedtls/port/ele_s400;../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure;../../../../../../middleware/aws_iot/iot-reference/examples/common/kvstore;../../../../../../middleware/aws_iot/iot-reference/examples/common/logging;../../../../../../middleware/aws_iot/iot-reference/examples/common/mqtt_agent;../../../../../../middleware/aws_iot/iot-reference/Middleware/FreeRTOS/transport_mbedtls;../../../../../../middleware/aws_iot/ota/source/include;../../../../../../middleware/aws_iot/ota/source/portable/os;../../../../../../rtos/freertos/corepkcs11/source/dependency/3rdparty/mbedtls_utils;../../../../../../middleware/pkcs11;../../../../../../rtos/freertos/corepkcs11/source/include;../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../devices/MIMXRT1189;../../../../../../devices/MIMXRT1189/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../devices/MIMXRT1189/utilities;../../../../../../devices/MIMXRT1189/drivers/cm33;../../../../../../components/silicon_id/socs;../../../../../../components/silicon_id;../../../../../../platform/drivers/netc/socs/imxrt1180;../../../../../../components/phy;../../../../../../components/gpio;../../../../../../components/ele_crypto;../../../../../../components/flash/mflash;../../../../../../components/flash/mflash/mimxrt1180;../../../../../../rtos/freertos/backoffalgorithm/source/include;../../../../../../rtos/freertos/coremqtt-agent/source/include;../../../../../../middleware/aws_iot/iot-reference/Middleware/FreeRTOS/mqtt-agent-interface/include;../../../../../../rtos/freertos/coremqtt/source/include;../../../../../../rtos/freertos/coremqtt/source/interface;../../../../../../rtos/freertos/corejson/source/include;../../../../../../middleware/tinycbor/src;../../../../../../CMSIS/Core/Include;../../../../../../devices/MIMXRT1189/utilities/str
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../config_files;../../../..;../../../../../../rtos/freertos/freertos-kernel/include
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: linker/MIMXRT1189xxxxx_cm33_flexspi_nor_mcuboot.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314 --predefine="-DXIP_BOOT_HEADER_ENABLE=0" --predefine="-D__stack_size__=0x200" --predefine="-D__heap_size__=0x200"
  group source
    ../: mbedtls_user_config.h main_enet.c lwipopts.h aws_clientcredential.h aws_clientcredential_keys.h freertos_tasks_c_additions.h aws_dev_mode_key_provisioning.h aws_dev_mode_key_provisioning.c mcuboot_app_support.c mcuboot_app_support.h iot_pkcs11_pal.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group config_files
    ../config_files/: ota_config.h core_mqtt_config.h core_pkcs11_config.h demo_config.h kvstore_config.h shadow_config.h FreeRTOSConfig.h
  group bootutil_port/board_specific
    ../bootutil_port/board_specific/: flash_partitioning.h flash_partitioning.c sblconfig.h
  group bootutil_port/mcuboot_config
    ../bootutil_port/mcuboot_config/: mcuboot_config.h mcuboot_logging.h
  group bootutil_port
    ../bootutil_port/: flash_map.h
  group bootutil_port/sysflash
    ../bootutil_port/sysflash/: sysflash.h
  group source/ota
    ../ota/: ota_pal.c ota_pal.h ota_signature_validation.c ota_update.c ota_update.h
  group doc
    ../: readme.md
  group drivers/netc
    ../../../../../../devices/MIMXRT1189/drivers/: fsl_netc.h fsl_netc_ierb.h fsl_netc_ierb.c fsl_netc_timer.h fsl_netc_timer.c fsl_netc_mdio.h fsl_netc_mdio.c fsl_netc_endpoint.h fsl_netc_endpoint.c fsl_netc_switch.h fsl_netc_switch.c
    ../../../../../../platform/drivers/netc/socs/imxrt1180/: fsl_netc_soc.c fsl_netc_soc.h
  group drivers/netc/netc_hw
    ../../../../../../devices/MIMXRT1189/drivers/netc_hw/: fsl_netc_hw.h fsl_netc_hw.c fsl_netc_hw_port.c fsl_netc_hw_port.h fsl_netc_hw_si.c fsl_netc_hw_si.h fsl_netc_hw_enetc.c fsl_netc_hw_enetc.h
  group drivers
    ../../../../../../devices/MIMXRT1189/drivers/: fsl_msgintr.h fsl_msgintr.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_misc.h fsl_rgpio.h fsl_rgpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_memory.h fsl_s3mu.c fsl_s3mu.h fsl_flexspi.c fsl_flexspi.h fsl_ele_base_api.h fsl_ele_base_api.c
    ../../../../../../devices/MIMXRT1189/drivers/cm33/: fsl_cache.c fsl_cache.h
  group component/phy
    ../../../../../../components/phy/device/phyrtl8211f/: fsl_phyrtl8211f.h fsl_phyrtl8211f.c
    ../../../../../../components/phy/device/phyrtl8201/: fsl_phyrtl8201.h fsl_phyrtl8201.c
    ../../../../../../components/phy/: fsl_phy.h
  group lwip/port
    ../../../../../../middleware/lwip/port/: ethernetif.c ethernetif.h ethernetif_mmac.h ethernetif_mmac.c ethernetif_priv.h netc_configchecks.h netc_ethernetif.c sys_arch.c
  group lwip/port/arch
    ../../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src/api
    ../../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/core
    ../../../../../../middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/src/core/ipv4
    ../../../../../../middleware/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/src/core/ipv6
    ../../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip/src/include/compat/posix/arpa
    ../../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/compat/posix/net
    ../../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix
    ../../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/sys
    ../../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/stdc
    ../../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/lwip
    ../../../../../../middleware/lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/priv
    ../../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../../middleware/lwip/src/include/lwip/prot/: acd.h autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip/src/include/netif
    ../../../../../../middleware/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lwip/src/include/netif/ppp
    ../../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip/src/netif
    ../../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group mbedtls/include/mbedtls
    ../../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h psa_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/include/psa
    ../../../../../../middleware/mbedtls/include/psa/: crypto.h crypto_builtin_composites.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group mbedtls/library
    ../../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum_internal.h bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cmac.c common.h constant_time.c constant_time_internal.h constant_time_invasive.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_invasive.h entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c mps_common.h mps_error.h mps_reader.c mps_reader.h mps_trace.c mps_trace.h net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c ssl_tls13_keys.h threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/port/ele_s400
    ../../../../../../middleware/mbedtls/port/ele_s400/: ele_mbedtls.c ele_mbedtls.h ele_s400_mbedtls_config.h ele_fw.h ele_entropy.c aes_alt.h aes_alt.c ccm_alt.h ccm_alt.c gcm_alt.h gcm_alt.c rsa_alt.h rsa_alt.c threading_alt.h sha256_alt.c sha256_alt.h sha512_alt.c sha512_alt.h hmac_alt.c
  group freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure
    ../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.c port.c portasm.c portasm.h portmacro.h portmacrocommon.h
  group aws_iot/iot-reference/examples/common/kvstore
    ../../../../../../middleware/aws_iot/iot-reference/examples/common/kvstore/: kvstore.c kvstore.h
  group aws_iot/iot-reference/examples/common/logging
    ../../../../../../middleware/aws_iot/iot-reference/examples/common/logging/: logging.c logging.h logging_levels.h
  group aws_iot/iot-reference/examples/common/mqtt_agent
    ../../../../../../middleware/aws_iot/iot-reference/examples/common/mqtt_agent/: mqtt_agent_task.c mqtt_agent_task.h
  group aws_iot/iot-reference/FreeRTOS/transport_mbedtls
    ../../../../../../middleware/aws_iot/iot-reference/Middleware/FreeRTOS/transport_mbedtls/: using_mbedtls.c using_mbedtls.h
  group aws_iot/ota/source
    ../../../../../../middleware/aws_iot/ota/source/: ota.c ota_base64.c ota_cbor.c ota_http.c ota_interface.c ota_mqtt.c
  group aws_iot/ota/source/include
    ../../../../../../middleware/aws_iot/ota/source/include/: ota.h ota_appversion32.h ota_base64_private.h ota_cbor_private.h ota_config_defaults.h ota_http_interface.h ota_http_private.h ota_interface_private.h ota_mqtt_interface.h ota_mqtt_private.h ota_os_interface.h ota_platform_interface.h ota_private.h stdbool.readme stdint.readme
  group aws_iot/ota/source/portable/os
    ../../../../../../middleware/aws_iot/ota/source/portable/os/: ota_os_freertos.c ota_os_freertos.h
  group freertos/corepkcs11/source/dependency/3rdparty/mbedtls_utils
    ../../../../../../rtos/freertos/corepkcs11/source/dependency/3rdparty/mbedtls_utils/: mbedtls_utils.c mbedtls_utils.h
  group pkcs11
    ../../../../../../middleware/pkcs11/: README.md pkcs11t.h pkcs11f.h pkcs11.h LICENSE.md CONTRIBUTING.md
  group freertos/corepkcs11/source
    ../../../../../../rtos/freertos/corepkcs11/source/: core_pkcs11.c core_pki_utils.c
  group freertos/corepkcs11/source/include
    ../../../../../../rtos/freertos/corepkcs11/source/include/: core_pkcs11.h core_pkcs11_config_defaults.h core_pkcs11_pal.h core_pki_utils.h
  group freertos/corepkcs11/source/portable/mbedtls
    ../../../../../../rtos/freertos/corepkcs11/source/portable/mbedtls/: core_pkcs11_mbedtls.c
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group device
    ../../../../../../devices/MIMXRT1189/: fsl_device_registers.h MIMXRT1189_cm33.h MIMXRT1189_cm33_features.h system_MIMXRT1189_cm33.c system_MIMXRT1189_cm33.h
  group utilities
    ../../../../../../devices/MIMXRT1189/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1189/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../../devices/MIMXRT1189/utilities/str/: fsl_str.c fsl_str.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMXRT1189/arm/: startup_MIMXRT1189_cm33.S
  group component/silicon_id
    ../../../../../../components/silicon_id/socs/imxrt1180/: fsl_silicon_id_soc.c
    ../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
    ../../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group component/gpio
    ../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_rgpio.c
  group component/ele_crypto
    ../../../../../../components/ele_crypto/: ele_crypto.c ele_crypto.h ele_crypto_internal.h
  group flash/mflash
    ../../../../../../components/flash/mflash/: mflash_file.h mflash_file.c mflash_common.h
  group flash/mflash/mimxrt1180
    ../../../../../../components/flash/mflash/mimxrt1180/: mflash_drv.h mflash_drv.c
  group freertos/backoffalgorithm/source
    ../../../../../../rtos/freertos/backoffalgorithm/source/: backoff_algorithm.c
  group freertos/backoffalgorithm/source/include
    ../../../../../../rtos/freertos/backoffalgorithm/source/include/: backoff_algorithm.h
  group freertos/coremqtt-agent/source/include
    ../../../../../../rtos/freertos/coremqtt-agent/source/include/: core_mqtt_agent.h core_mqtt_agent_command_functions.h core_mqtt_agent_config_defaults.h core_mqtt_agent_default_logging.h core_mqtt_agent_message_interface.h
  group freertos/coremqtt-agent/source
    ../../../../../../rtos/freertos/coremqtt-agent/source/: core_mqtt_agent_command_functions.c core_mqtt_agent.c
  group aws_iot/iot-reference/mqtt-agent-interface
    ../../../../../../middleware/aws_iot/iot-reference/Middleware/FreeRTOS/mqtt-agent-interface/: freertos_agent_message.c freertos_command_pool.c
  group aws_iot/iot-reference/mqtt-agent-interface/include
    ../../../../../../middleware/aws_iot/iot-reference/Middleware/FreeRTOS/mqtt-agent-interface/include/: freertos_agent_message.h freertos_command_pool.h
  group freertos/coremqtt/source
    ../../../../../../rtos/freertos/coremqtt/source/: core_mqtt.c core_mqtt_serializer.c core_mqtt_state.c
  group freertos/coremqtt/source/include
    ../../../../../../rtos/freertos/coremqtt/source/include/: core_mqtt.h core_mqtt_config_defaults.h core_mqtt_default_logging.h core_mqtt_serializer.h core_mqtt_state.h
  group freertos/coremqtt/source/interface
    ../../../../../../rtos/freertos/coremqtt/source/interface/: transport_interface.h
  group freertos/corejson/source
    ../../../../../../rtos/freertos/corejson/source/: core_json.c
  group freertos/corejson/source/include
    ../../../../../../rtos/freertos/corejson/source/include/: core_json.h
  group tinycbor/src
    ../../../../../../middleware/tinycbor/src/: cbor.h cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborinternal_p.h cborparser.c compilersupport_p.h tinycbor-version.h utf8_p.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target ota_demo_enet_cm33 flexspi_nor_release (ARM-ADS)
  device: MIMXRT1189CVM8B:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU)  DSP
  output: ota_demo_enet_cm33.out
  AfterMake: fromelf.exe --output "$Lota_demo.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=0, NDEBUG, CPU_MIMXRT1189CVM8B_cm33, MBEDTLS_CONFIG_FILE='\"ele_s400_mbedtls_config.h\"', MBEDTLS_USER_CONFIG_FILE='\"mbedtls_user_config.h\"', FSL_ETH_ENABLE_CACHE_CONTROL, ETH_RX_TASK_PRIO=6, USE_RTOS=1, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, CBOR_NO_FLOATING_POINT, DISABLE_LOGGING, MCUXPRESSO_SDK, LWIP_DISABLE_PBUF_POOL_SIZE_SANITY_CHECKS=1, CHECKSUM_GEN_IP=1, CHECKSUM_GEN_UDP=1, CHECKSUM_GEN_TCP=1, CHECKSUM_GEN_ICMP=1, CHECKSUM_GEN_ICMP6=1, CHECKSUM_CHECK_ICMP=1, CHECKSUM_CHECK_ICMP6=1, MBEDTLS_MCUX_ELE_S400_API, SDK_OS_FREE_RTOS, SERIAL_PORT_TYPE_UART=1, CACHE_MODE_WRITE_THROUGH=1, LWIP_DNS=1, MFLASH_FILE_BASEADDR=14221312, MQTT_AGENT_DO_NOT_USE_CUSTOM_CONFIG, MBEDTLS_THREADING_ALT, MBEDTLS_THREADING_C
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: linker/MIMXRT1189xxxxx_cm33_flexspi_nor_mcuboot.scf
  link misc: as above
