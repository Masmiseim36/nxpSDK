# IAR project power_mode_switch_bm_dcdc_core0.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1189xxx8_M33 NXP MIMXRT1189xxx8_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CORE1_IMAGE_COPY_TO_RAM; CPU_MIMXRT1189CVM8B_cm33; MCMGR_HANDLE_EXCEPTIONS=1; __SEMIHOST_HARDFAULT_DISABLE=1; MCUXPRESSO_SDK; MULTICORE_APP=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../common; ..; ../../../../../../../devices/MIMXRT1189/utilities/debug_console_lite; ../../../../../../../devices/MIMXRT1189/drivers; ../../../../../../../devices/MIMXRT1189; ../../../../../../../components/uart; ../../../../../../../components/lists; ../../../../../../../devices/MIMXRT1189/xip; ../../../../../xip; ../../../../../../../devices/MIMXRT1189/drivers/cm33; ../../../../../../../components/silicon_id/socs; ../../../../../../../components/silicon_id; ../../../../../../../middleware/multicore/mcmgr/src; ../../../../../../../devices/MIMXRT1189/utilities/str; ../../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.bin
  ILINK.IlinkOutputFile: power_mode_switch_bm_dcdc_core0.out
  ILINK.IlinkKeepSymbols: _power_mode_switch_bm_core1_image
  ILINK.IlinkConfigDefines: __multicore__=1
  ILINK.IlinkIcfFile: MIMXRT1189xxxxx_cm33_ram.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=0; CORE1_IMAGE_COPY_TO_RAM; CPU_MIMXRT1189CVM8B_cm33; MCMGR_HANDLE_EXCEPTIONS=1; __SEMIHOST_HARDFAULT_DISABLE=1; MCUXPRESSO_SDK; MULTICORE_APP=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1189xxxxx_cm33_flexspi_nor.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CORE1_IMAGE_COPY_TO_RAM; CPU_MIMXRT1189CVM8B_cm33; MCMGR_HANDLE_EXCEPTIONS=1; __SEMIHOST_HARDFAULT_DISABLE=1; MCUXPRESSO_SDK; MULTICORE_APP=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=0; NDEBUG; CORE1_IMAGE_COPY_TO_RAM; CPU_MIMXRT1189CVM8B_cm33; MCMGR_HANDLE_EXCEPTIONS=1; __SEMIHOST_HARDFAULT_DISABLE=1; MCUXPRESSO_SDK; MULTICORE_APP=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1189xxxxx_cm33_flexspi_nor.icf
  group source
    ../: power_mode_switch_core0.c
    ../../common/: lpm.c lpm.h chip_init_def.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.md
  group mcmgr
    ../../../../../../../middleware/multicore/mcmgr/src/: mcmgr_internal_core_api_imxrt1180.c mcmgr_mu_internal.c mcmgr.h mcmgr_internal_core_api.h mcmgr.c
  group utilities
    ../../../../../../../devices/MIMXRT1189/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c fsl_assert.h
    ../../../../../../../devices/MIMXRT1189/utilities/str/: fsl_str.c fsl_str.h
  group drivers
    ../../../../../../../devices/MIMXRT1189/drivers/: fsl_rgpio.h fsl_rgpio.c fsl_dcdc.h fsl_dcdc.c fsl_mu.h fsl_mu.c fsl_gpc.h fsl_gpc.c fsl_soc_src.h fsl_soc_src.c fsl_pmu.h fsl_pmu.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_misc.h fsl_ele_base_api.h fsl_ele_base_api.c fsl_s3mu.c fsl_s3mu.h
    ../../../../../../../devices/MIMXRT1189/drivers/cm33/: fsl_cache.c fsl_cache.h
  group device
    ../../../../../../../devices/MIMXRT1189/: fsl_device_registers.h MIMXRT1189_cm33.h MIMXRT1189_cm33_features.h system_MIMXRT1189_cm33.c system_MIMXRT1189_cm33.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/silicon_id
    ../../../../../../../components/silicon_id/socs/imxrt1180/: fsl_silicon_id_soc.c
    ../../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
    ../../../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group startup
    ../../../../../../../devices/MIMXRT1189/iar/: startup_MIMXRT1189_cm33.s
  group xip
    ../../../../../../../devices/MIMXRT1189/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../../xip/: evkmimxrt1180_flexspi_nor_config.c evkmimxrt1180_flexspi_nor_config.h
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
