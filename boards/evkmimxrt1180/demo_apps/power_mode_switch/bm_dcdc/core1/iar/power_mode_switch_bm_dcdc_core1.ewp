# IAR project power_mode_switch_bm_dcdc_core1.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1189xxx8_M7 NXP MIMXRT1189xxx8_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1189CVM8B_cm7; BOARD_DEBUG_UART_CLK_ROOT=kCLOCK_Root_Lpuart1112; BOARD_DEBUG_UART_BASEADDR=LPUART12; BOARD_DEBUG_UART_INSTANCE=12; BOARD_UART_IRQ=LPUART12_IRQn; BOARD_UART_IRQ_HANDLER=LPUART12_IRQHandler; MCMGR_HANDLE_EXCEPTIONS=1; __SEMIHOST_HARDFAULT_DISABLE=1; FLEXSPI_IN_USE; MCUXPRESSO_SDK; MULTICORE_APP=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../common; ..; ../../../../../../../devices/MIMXRT1189/utilities/str; ../../../../../../../devices/MIMXRT1189/utilities/debug_console_lite; ../../../../../../../devices/MIMXRT1189/drivers; ../../../../../../../devices/MIMXRT1189; ../../../../../../../components/uart; ../../../../../../../components/lists; ../../../../../../../devices/MIMXRT1189/xip; ../../../../../xip; ../../../../../../../devices/MIMXRT1189/drivers/cm7; ../../../../../../../components/silicon_id/socs; ../../../../../../../components/silicon_id; ../../../../../../../middleware/multicore/mcmgr/src; ../../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: power_mode_switch_bm_core1.bin
  ILINK.IlinkOutputFile: power_mode_switch_bm_dcdc_core1.out
  ILINK.IlinkConfigDefines: __multicore__=1
  ILINK.IlinkIcfFile: MIMXRT1189xxxxx_cm7_ram.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1189CVM8B_cm7; BOARD_DEBUG_UART_CLK_ROOT=kCLOCK_Root_Lpuart1112; BOARD_DEBUG_UART_BASEADDR=LPUART12; BOARD_DEBUG_UART_INSTANCE=12; BOARD_UART_IRQ=LPUART12_IRQn; BOARD_UART_IRQ_HANDLER=LPUART12_IRQHandler; MCMGR_HANDLE_EXCEPTIONS=1; __SEMIHOST_HARDFAULT_DISABLE=1; FLEXSPI_IN_USE; MCUXPRESSO_SDK; MULTICORE_APP=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: power_mode_switch_core1.c
    ../../common/: lpm.c lpm.h chip_init_def.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.md
  group mcmgr
    ../../../../../../../middleware/multicore/mcmgr/src/: mcmgr_internal_core_api_imxrt1180.c mcmgr_mu_internal.c mcmgr.h mcmgr_internal_core_api.h mcmgr.c
  group utilities
    ../../../../../../../devices/MIMXRT1189/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MIMXRT1189/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../../devices/MIMXRT1189/drivers/: fsl_rgpio.h fsl_rgpio.c fsl_dcdc.h fsl_dcdc.c fsl_mu.h fsl_mu.c fsl_gpc.h fsl_gpc.c fsl_soc_src.h fsl_soc_src.c fsl_pmu.h fsl_pmu.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_misc.h
    ../../../../../../../devices/MIMXRT1189/drivers/cm7/: fsl_cache.c fsl_cache.h
  group device
    ../../../../../../../devices/MIMXRT1189/: fsl_device_registers.h MIMXRT1189_cm7.h MIMXRT1189_cm7_features.h system_MIMXRT1189_cm7.c system_MIMXRT1189_cm7.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/silicon_id
    ../../../../../../../components/silicon_id/socs/imxrt1180/: fsl_silicon_id_soc.c
    ../../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
    ../../../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group startup
    ../../../../../../../devices/MIMXRT1189/iar/: startup_MIMXRT1189_cm7.s
  group xip
    ../../../../../../../devices/MIMXRT1189/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../../xip/: evkmimxrt1180_flexspi_nor_config.c evkmimxrt1180_flexspi_nor_config.h
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
