<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>fsl_romapi_cm33</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>fsl_romapi_cm33</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
      <member>
        <project>fsl_romapi_cm33</project>
        <configuration>hyperram_debug</configuration>
      </member>
      <member>
        <project>fsl_romapi_cm33</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>fsl_romapi_cm33</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
      <member>
        <project>fsl_romapi_cm33</project>
        <configuration>hyperram_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>fsl_romapi_cm33</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_debug</name>
      <member>
        <project>fsl_romapi_cm33</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>hyperram_debug</name>
      <member>
        <project>fsl_romapi_cm33</project>
        <configuration>hyperram_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>fsl_romapi_cm33</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_release</name>
      <member>
        <project>fsl_romapi_cm33</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>hyperram_release</name>
      <member>
        <project>fsl_romapi_cm33</project>
        <configuration>hyperram_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/fsl_romapi_cm33.ewp</path>
  </project>
</workspace>
