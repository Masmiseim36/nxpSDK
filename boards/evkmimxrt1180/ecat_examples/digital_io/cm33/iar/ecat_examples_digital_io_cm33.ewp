# IAR project ecat_examples_digital_io_cm33.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1189xxx8_M33 NXP MIMXRT1189xxx8_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1189CVM8B_cm33; SDK_DEBUGCONSOLE_UART; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pa039,Pe111
  ICCARM.CCIncludePath2: ..; ../SSC/Src; ../../../../../../devices/MIMXRT1189/drivers; ../../../../../../devices/MIMXRT1189; ../../../../../../devices/MIMXRT1189/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1189/utilities; ../../../../../../devices/MIMXRT1189/xip; ../../../../xip; ../../../../../../devices/MIMXRT1189/drivers/cm33; ../../../../../../components/silicon_id/socs; ../../../../../../components/silicon_id; ../../../../../../CMSIS/Core/Include; ../../../../../../devices/MIMXRT1189/utilities/str
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.bin
  ILINK.IlinkOutputFile: ecat_examples_digital_io_cm33.out
  ILINK.IlinkIcfFile: MIMXRT1189xxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=0; CPU_MIMXRT1189CVM8B_cm33; SDK_DEBUGCONSOLE_UART; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 2
  OBJCOPY.OOCOutputFile: ecat_examples_digital_io.bin
  ILINK.IlinkIcfFile: MIMXRT1189xxxxx_cm33_flexspi_nor.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1189CVM8B_cm33; SDK_DEBUGCONSOLE_UART; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=0; NDEBUG; CPU_MIMXRT1189CVM8B_cm33; SDK_DEBUGCONSOLE_UART; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: ecat_examples_digital_io.bin
  ILINK.IlinkIcfFile: MIMXRT1189xxxxx_cm33_flexspi_nor.icf
  group board
    ../: pin_mux.c pin_mux.h ecat_hw.c ecat_hw.h board.c board.h clock_config.c clock_config.h
  group source
    ../: digital_io.c
  group source/SSC
    ../SSC/: digital_io.xlsx digital_io.xml
  group source/SSC/Src
    ../SSC/Src/: applInterface.h coeappl.c coeappl.h digital_io.h digital_ioObjects.h ecatappl.c ecatappl.h ecatcoe.c ecatcoe.h ecat_def.h ecatslv.c ecatslv.h esc.h mailbox.c mailbox.h objdef.c objdef.h sdoserv.c sdoserv.h
  group doc
    ../: readme.md
  group drivers
    ../../../../../../devices/MIMXRT1189/drivers/: fsl_ecat.h fsl_ecat.c fsl_lpi2c.c fsl_lpi2c.h fsl_xbar.h fsl_xbar.c fsl_gpt.c fsl_gpt.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_misc.h fsl_rgpio.h fsl_rgpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_ele_base_api.h fsl_ele_base_api.c fsl_s3mu.c fsl_s3mu.h
    ../../../../../../devices/MIMXRT1189/drivers/cm33/: fsl_cache.c fsl_cache.h
  group device
    ../../../../../../devices/MIMXRT1189/: fsl_device_registers.h MIMXRT1189_cm33.h MIMXRT1189_cm33_features.h system_MIMXRT1189_cm33.c system_MIMXRT1189_cm33.h
  group utilities
    ../../../../../../devices/MIMXRT1189/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1189/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../../devices/MIMXRT1189/utilities/str/: fsl_str.c fsl_str.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/silicon_id
    ../../../../../../components/silicon_id/socs/imxrt1180/: fsl_silicon_id_soc.c
    ../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
    ../../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group startup
    ../../../../../../devices/MIMXRT1189/iar/: startup_MIMXRT1189_cm33.s
  group xip
    ../../../../../../devices/MIMXRT1189/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1180_flexspi_nor_config.c evkmimxrt1180_flexspi_nor_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
