# IAR project ecat_examples_eoe_cm33.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1189xxx8_M33 NXP MIMXRT1189xxx8_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=0; LWIP_TIMEVAL_PRIVATE=1; CPU_MIMXRT1189CVM8B_cm33; SDK_DEBUGCONSOLE_UART; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK; USE_RTOS=1; CHECKSUM_GEN_IP=1; CHECKSUM_GEN_UDP=1; CHECKSUM_GEN_TCP=1; CHECKSUM_GEN_ICMP=1; CHECKSUM_CHECK_ICMP=1; SDK_OS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pa039,Pe111
  ICCARM.CCIncludePath2: ..; ../SSC/Src; ../../../../../../devices/MIMXRT1189/drivers; ../../../../../../middleware/lwip/src/apps/httpsrv; ../../../../../../middleware/lwip/src/include/lwip/apps; ../../../../../../middleware/lwip/port; ../../../../../../middleware/lwip/src; ../../../../../../middleware/lwip/src/include; ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../devices/MIMXRT1189; ../../../../../../devices/MIMXRT1189/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1189/utilities; ../../../../../../devices/MIMXRT1189/xip; ../../../../xip; ../../../../../../devices/MIMXRT1189/drivers/cm33; ../../../../../../components/silicon_id/socs; ../../../../../../components/silicon_id; ../../../../../../CMSIS/Core/Include; ../../../../../../devices/MIMXRT1189/utilities/str
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../../../../../../rtos/freertos/freertos-kernel/include
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.bin
  ILINK.IlinkOutputFile: ecat_examples_eoe_cm33.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2048; __heap_size__=0x30000
  ILINK.IlinkIcfFile: MIMXRT1189xxxxx_cm33_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=0; NDEBUG; LWIP_TIMEVAL_PRIVATE=1; CPU_MIMXRT1189CVM8B_cm33; SDK_DEBUGCONSOLE_UART; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK; USE_RTOS=1; CHECKSUM_GEN_IP=1; CHECKSUM_GEN_UDP=1; CHECKSUM_GEN_TCP=1; CHECKSUM_GEN_ICMP=1; CHECKSUM_CHECK_ICMP=1; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 0
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../: pin_mux.c pin_mux.h ecat_hw.c ecat_hw.h board.c board.h clock_config.c clock_config.h
  group source
    ../: eoe_freertos.c FreeRTOSConfig.h eoe_lwip_interface.c eoe_lwip_interface.h httpsrv_freertos.c httpsrv_freertos.h httpsrv_fs_data.c lwipopts.h
  group source/webpage
    ../webpage/: auth.html cgi.html favicon.ico httpsrv.css index.html NXP_logo.png poll.html request.js ssi.shtml websocket.html welcome.html
  group source/SSC
    ../SSC/: eoe_freertos.xlsx eoe.xml
  group source/SSC/Src
    ../SSC/Src/: applInterface.h coeappl.c coeappl.h eoe_freertos.h eoe_freertosObjects.h ecatappl.c ecatappl.h ecatcoe.c ecatcoe.h ecat_def.h ecateoe.c ecateoe.h ecatslv.c ecatslv.h eoeappl.c eoeappl.h esc.h mailbox.c mailbox.h objdef.c objdef.h sdoserv.c sdoserv.h
  group doc
    ../: readme.md
  group drivers
    ../../../../../../devices/MIMXRT1189/drivers/: fsl_ecat.h fsl_ecat.c fsl_lpi2c.c fsl_lpi2c.h fsl_xbar.h fsl_xbar.c fsl_gpt.c fsl_gpt.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_misc.h fsl_rgpio.h fsl_rgpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_ele_base_api.h fsl_ele_base_api.c fsl_s3mu.c fsl_s3mu.h
    ../../../../../../devices/MIMXRT1189/drivers/cm33/: fsl_cache.c fsl_cache.h
  group lwip/src/apps/httpsrv
    ../../../../../../middleware/lwip/src/apps/httpsrv/: httpsrv.c httpsrv.h httpsrv_base64.c httpsrv_base64.h httpsrv_config.h httpsrv_fs.c httpsrv_fs.h httpsrv_port.h httpsrv_prv.h httpsrv_script.c httpsrv_script.h httpsrv_sha1.c httpsrv_sha1.h httpsrv_supp.c httpsrv_supp.h httpsrv_task.c httpsrv_tls.c httpsrv_tls.h httpsrv_utf8.c httpsrv_utf8.h httpsrv_ws.c httpsrv_ws.h httpsrv_ws_api.c httpsrv_ws_prv.h
  group lwip/src/apps/mdns
    ../../../../../../middleware/lwip/src/apps/mdns/: mdns.c mdns_domain.c mdns_out.c
  group lwip/src/include/lwip
    ../../../../../../middleware/lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/apps
    ../../../../../../middleware/lwip/src/include/lwip/apps/: mdns.h mdns_domain.h mdns_priv.h mdns_opts.h mdns_out.h
  group lwip/src/include/lwip/priv
    ../../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../../middleware/lwip/src/include/lwip/prot/: acd.h autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip/src/include/compat/posix
    ../../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/compat/posix/net
    ../../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/sys
    ../../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/stdc
    ../../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/netif
    ../../../../../../middleware/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lwip/src/include/netif/ppp
    ../../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip/src/api
    ../../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/core
    ../../../../../../middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/src/core/ipv4
    ../../../../../../middleware/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/src/core/ipv6
    ../../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip/src/netif
    ../../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lwip/port
    ../../../../../../middleware/lwip/port/: eoe_ethernetif.c eoe_ethernetif.h sys_arch.c
  group lwip/port/arch
    ../../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: heap_3.c ReadMe.url
  group freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group device
    ../../../../../../devices/MIMXRT1189/: fsl_device_registers.h MIMXRT1189_cm33.h MIMXRT1189_cm33_features.h system_MIMXRT1189_cm33.c system_MIMXRT1189_cm33.h
  group utilities
    ../../../../../../devices/MIMXRT1189/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1189/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../../devices/MIMXRT1189/utilities/str/: fsl_str.c fsl_str.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/silicon_id
    ../../../../../../components/silicon_id/socs/imxrt1180/: fsl_silicon_id_soc.c
    ../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
    ../../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group startup
    ../../../../../../devices/MIMXRT1189/iar/: startup_MIMXRT1189_cm33.s
  group xip
    ../../../../../../devices/MIMXRT1189/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1180_flexspi_nor_config.c evkmimxrt1180_flexspi_nor_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
