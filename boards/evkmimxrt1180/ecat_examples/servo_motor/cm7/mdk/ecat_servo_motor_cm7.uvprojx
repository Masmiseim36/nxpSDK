# Keil uVision project ecat_servo_motor_cm7.uvprojx, settings and files
target ecat_servo_motor_cm7 debug (ARM-ADS)
  device: MIMXRT1189CVM8B:cm7 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ecat_servo_motor_cm7.out
  AfterMake: fromelf.exe --output "$Lecat_servo_motor.bin" --bincombined "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, SDK_DEBUGCONSOLE_UART, SERIAL_PORT_TYPE_UART=1, PRINTF_ADVANCED_ENABLE=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8B_cm7, PMSM_SNSLESS, PMSM_SNSLESS_ENC, MID_EN
  c misc: -include ../mcux_config.h -O1  -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../SSC;../SSC/Src;../../../../../../devices/MIMXRT1189/drivers;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MIMXRT1189;../../../../../../devices/MIMXRT1189/periph;../../../../../../devices/MIMXRT1189/drivers/cm7;../../../../../../devices/MIMXRT1189/utilities/debug_console_lite;../../../../../../components/lists;../../../../../../devices/MIMXRT1189/utilities/str;../../../../../../components/serial_manager;../../../../../../components/uart;../../../../../../components/silicon_id;../../../../../../components/silicon_id/socs;../../../../../../middleware/freemaster/src/common;../../../../../../middleware/freemaster/src/platforms/gen32le;../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can;../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial;../../../../../../middleware/rtcesl/CM7F_RTCESL_4.8_KEIL/AMCLIB/Include;../../../../../../middleware/rtcesl/CM7F_RTCESL_4.8_KEIL/GDFLIB/Include;../../../../../../middleware/rtcesl/CM7F_RTCESL_4.8_KEIL/GFLIB/Include;../../../../../../middleware/rtcesl/CM7F_RTCESL_4.8_KEIL/GMCLIB/Include;../../../../../../middleware/rtcesl/CM7F_RTCESL_4.8_KEIL/MLIB/Include;../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_algorithms;../../../../../../middleware/motor_control/pmsm/pmsm_float/state_machine;../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_state_machine;../../../../../../middleware/motor_control/pmsm/pmsm_float;../../../../../../middleware/motor_control/freemaster;../../../../../../middleware/motor_control/docs;../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_identification;../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_drivers;../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_algorithms/mcaa_lib/cm7f_mdk/Include
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8B_cm7
  asm include: ..;../../../../../../devices/MIMXRT1189/drivers;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MIMXRT1189;../../../../../../devices/MIMXRT1189/periph;../../../../../../devices/MIMXRT1189/drivers/cm7;../../../../../../devices/MIMXRT1189/utilities/debug_console_lite;../../../../../../components/lists;../../../../../../devices/MIMXRT1189/utilities/str;../../../../../../components/serial_manager;../../../../../../components/uart;../../../../../../components/silicon_id;../../../../../../components/silicon_id/socs;../../../../../../middleware/freemaster/src/common;../../../../../../middleware/freemaster/src/platforms/gen32le;../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can;../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial;../../../../../../middleware/rtcesl/CM7F_RTCESL_4.8_KEIL/AMCLIB/Include;../../../../../../middleware/rtcesl/CM7F_RTCESL_4.8_KEIL/GDFLIB/Include;../../../../../../middleware/rtcesl/CM7F_RTCESL_4.8_KEIL/GFLIB/Include;../../../../../../middleware/rtcesl/CM7F_RTCESL_4.8_KEIL/GMCLIB/Include;../../../../../../middleware/rtcesl/CM7F_RTCESL_4.8_KEIL/MLIB/Include;../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_algorithms;../../../../../../middleware/motor_control/pmsm/pmsm_float/state_machine;../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_state_machine;../../../../../../middleware/motor_control/pmsm/pmsm_float;../../../../../../middleware/motor_control/freemaster;../../../../../../middleware/motor_control/docs;../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_identification;../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_drivers;../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_algorithms/mcaa_lib/cm7f_mdk/Include
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1189xxxxx_cm7_ram.scf
  link misc: ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.8_KEIL/AMCLIB/AMCLIB.lib ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.8_KEIL/GFLIB/GFLIB.lib ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.8_KEIL/GDFLIB/GDFLIB.lib ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.8_KEIL/GMCLIB/GMCLIB.lib ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.8_KEIL/MLIB/MLIB.lib ../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_algorithms/mcaa_lib/cm7f_mdk/mcaa_lib.lib --remove --predefine=\"-D__stack_size__=0x2000\" --predefine=\"-D__heap_size__=0x10000\" --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: servo_motor.c servo_motor.h ecat_hw.c ecat_hw.h freemaster_cfg.h m1_pmsm_appconfig.h m2_pmsm_appconfig.h mc_periph_init.c mc_periph_init.h peripherals.c peripherals.h mcux_config.h
  group source/SSC
    ../SSC/: CiA402-combine-the-SSC-slave-with-ec_pmsm-support.patch servo_motor.xml
  group source/SSC/Src
    ../SSC/Src/: applInterface.h cia402appl.c cia402appl.h coeappl.c coeappl.h ecat_def.h ecatappl.c ecatappl.h ecatcoe.c ecatcoe.h ecatslv.c ecatslv.h esc.h mailbox.c mailbox.h objdef.c objdef.h sdoserv.c sdoserv.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group drivers
    ../../../../../../devices/MIMXRT1189/drivers/: fsl_pmu.h fsl_pmu.c fsl_clock.h fsl_clock.c fsl_dcdc.c fsl_dcdc.h fsl_ecat.c fsl_ecat.h fsl_ele_base_api.c fsl_ele_base_api.h fsl_gpc.c fsl_gpc.h fsl_iomuxc.h fsl_memory.h fsl_misc.h fsl_soc_src.c fsl_soc_src.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_gpt.c fsl_gpt.h fsl_lpadc.c fsl_lpadc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.h fsl_lpuart.c fsl_rgpio.h fsl_rgpio.c fsl_s3mu.c fsl_s3mu.h fsl_xbar.h fsl_xbar.c
    ../../../../../../devices/MIMXRT1189/drivers/cm7/: fsl_cache.c fsl_cache.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv7m_cachel1.h armv7m_mpu.h
  group device
    ../../../../../../devices/MIMXRT1189/: fsl_device_registers.h MIMXRT1189_cm7.h MIMXRT1189_cm7_COMMON.h MIMXRT1189_cm7_features.h system_MIMXRT1189_cm7.c system_MIMXRT1189_cm7.h
  group device/periph
    ../../../../../../devices/MIMXRT1189/periph/: PERI_ADC.h PERI_ANADIG.h PERI_ANADIG_LDO_BBSM.h PERI_ANADIG_MISC.h PERI_ANADIG_OSC.h PERI_ANADIG_PLL.h PERI_ANADIG_PMU.h PERI_ANADIG_TEMPSENSOR.h PERI_AOI.h PERI_ASRC.h PERI_AXBS.h PERI_BBNSM.h PERI_BLK_CTRL_BBSMMIX.h PERI_BLK_CTRL_NS_AONMIX.h PERI_BLK_CTRL_S_AONMIX.h PERI_BLK_CTRL_WAKEUPMIX.h PERI_CACHE_ECC_MCM.h PERI_CAN.h PERI_CCM.h PERI_CMP.h PERI_DAC.h PERI_DCDC.h PERI_DMA.h PERI_DMA4.h PERI_ECAT.h PERI_EIM.h PERI_ENETC_GLOBAL.h PERI_ENETC_PCI_TYPE0.h PERI_ENETC_PF_EMDIO.h PERI_ENETC_PF_TMR.h PERI_ENETC_SI.h PERI_ENETC_VF_PCI_TYPE0.h PERI_EQDC.h PERI_ERM.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXSPI.h PERI_FLEXSPI_SLV.h PERI_GPC_CPU_CTRL.h PERI_GPC_GLOBAL.h PERI_GPC_SYS_SLEEP_CTRL.h PERI_GPT.h PERI_I2S.h PERI_I3C.h PERI_IEE.h PERI_IEE_APC.h PERI_IERC_IERB.h PERI_IERC_PCI.h PERI_IOMUXC.h PERI_IOMUXC_AON.h PERI_KPP.h PERI_LPI2C.h PERI_LPIT.h PERI_LPSPI.h PERI_LPTMR.h PERI_LPUART.h PERI_M7_MCM.h PERI_MECC.h PERI_MSGINTR.h PERI_MU.h PERI_NETC_ENETC.h PERI_NETC_ETH_LINK.h PERI_NETC_IERB.h PERI_NETC_PORT.h PERI_NETC_PRIV.h PERI_NETC_PSEUDO_LINK.h PERI_NETC_SW.h PERI_NETC_SW_ENETC.h PERI_OCOTP_FSB.h PERI_OSC_RC_400M.h PERI_OTFAD.h PERI_PDM.h PERI_PHY_LDO.h PERI_PLL.h PERI_PWM.h PERI_RGPIO.h PERI_RTWDOG.h PERI_S3MU.h PERI_SEMA42.h PERI_SEMC.h PERI_SINC.h PERI_SPDIF.h PERI_SRC_GENERAL.h PERI_SRC_MIF_LN28FDSOI_SPLLRAM.h PERI_SRC_MIF_S28SPREGH.h PERI_SRC_MIF_S28SPREGH_PSWA.h PERI_SRC_MIX_SLICE.h PERI_SYSPM.h PERI_SYS_CTR_COMPARE.h PERI_SYS_CTR_CONTROL.h PERI_SYS_CTR_READ.h PERI_TCM_ECC_MCM.h PERI_TMPSNS.h PERI_TMR.h PERI_TPM.h PERI_TRDC.h PERI_TSTMR.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_VMBANDGAP.h PERI_VREF.h PERI_XBAR_NUM_OUT221.h PERI_XBAR_NUM_OUT32.h PERI_XCACHE.h
  group startup/arm
    ../../../../../../devices/MIMXRT1189/arm/: startup_MIMXRT1189_cm7.S
  group utilities
    ../../../../../../devices/MIMXRT1189/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
    ../../../../../../devices/MIMXRT1189/utilities/: fsl_memcpy.S
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group utilities/str
    ../../../../../../devices/MIMXRT1189/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MIMXRT1189/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/silicon_id
    ../../../../../../components/silicon_id/: fsl_silicon_id.h fsl_silicon_id.c
    ../../../../../../components/silicon_id/socs/imxrt1180/: fsl_silicon_id_soc.c
  group component
    ../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
  group freemaster/src/common
    ../../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_defcfg.h freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h freemaster_can.c freemaster_can.h freemaster_sha.c freemaster_pdbdm.c freemaster_serial.c freemaster_serial.h freemaster_net.c freemaster_net.h
  group freemaster/src/platforms/gen32le
    ../../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group freemaster/src/drivers/mcuxsdk/can
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mscan.c freemaster_mscan.h freemaster_mcan.c freemaster_mcan.h
  group freemaster/src/drivers/mcuxsdk/serial
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_usb.c freemaster_serial_usb.h
  group freemaster/src/drivers/mcuxsdk/network
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/network/: freemaster_net_segger_rtt.c freemaster_net_segger_rtt.h freemaster_net_lwip_udp.c freemaster_net_lwip_udp.h freemaster_net_lwip_tcp.c freemaster_net_lwip_tcp.h
  group rtcesl/CM7F_RTCESL_4.8_KEIL/AMCLIB/Include
    ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.8_KEIL/AMCLIB/Include/: amclib.h AMCLIB_ACIMCtrlMTPA_FLT.h AMCLIB_ACIMRotFluxObsrv_FLT.h AMCLIB_ACIMSpeedMRAS_FLT.h AMCLIB_AngleTrackObsrv_F32.h AMCLIB_AngleTrackObsrv_FLT.h AMCLIB_CtrlFluxWkng_A32.h AMCLIB_CtrlFluxWkng_FLT.h amclib_FP.h AMCLIB_PMSMBemfObsrvAB_A32.h AMCLIB_PMSMBemfObsrvAB_FLT.h AMCLIB_PMSMBemfObsrvDQ_A32.h AMCLIB_PMSMBemfObsrvDQ_FLT.h AMCLIB_TrackObsrv_F32.h AMCLIB_TrackObsrv_FLT.h amclib_types.h
  group rtcesl/CM7F_RTCESL_4.8_KEIL/GDFLIB/Include
    ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.8_KEIL/GDFLIB/Include/: gdflib.h GDFLIB_FilterExp_F32.h GDFLIB_FilterExp_FLT.h GDFLIB_FilterIIR1_F32.h GDFLIB_FilterIIR1_F32_Asmi.h GDFLIB_FilterIIR1_FLT.h GDFLIB_FilterIIR2_F32.h GDFLIB_FilterIIR2_FLT.h GDFLIB_FilterIIR3_F32.h GDFLIB_FilterIIR3_FLT.h GDFLIB_FilterIIR4_F32.h GDFLIB_FilterIIR4_FLT.h GDFLIB_FilterMA_A32.h GDFLIB_FilterMA_FLT.h gdflib_FP.h gdflib_types.h
  group rtcesl/CM7F_RTCESL_4.8_KEIL/GFLIB/Include
    ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.8_KEIL/GFLIB/Include/: gflib.h GFLIB_Acos_F16.h GFLIB_Acos_FLT.h GFLIB_Asin_F16.h GFLIB_Asin_FLT.h GFLIB_Atan_F32.h GFLIB_Atan_FLT.h GFLIB_AtanYX_F16.h GFLIB_AtanYX_FLT.h GFLIB_CtrlBetaIPDp_A32.h GFLIB_CtrlBetaIPDp_FLT.h GFLIB_CtrlBetaIPp_A32.h GFLIB_CtrlBetaIPp_FLT.h GFLIB_CtrlPIDp_A32.h GFLIB_CtrlPIDp_FLT.h GFLIB_CtrlPIp_A32.h GFLIB_CtrlPIp_FLT.h GFLIB_DFlexRamp_A32.h GFLIB_DFlexRamp_FLT.h GFLIB_DRamp_F16.h GFLIB_DRamp_F32.h GFLIB_DRamp_FLT.h GFLIB_FlexRamp_A32.h GFLIB_FlexRamp_FLT.h GFLIB_FlexSRamp_A32.h GFLIB_FlexSRamp_FLT.h gflib_FP.h GFLIB_Hyst_F16_Asmi.h GFLIB_Hyst_FLT.h GFLIB_Integrator_A32.h GFLIB_Integrator_FLT.h GFLIB_Limit_F16.h GFLIB_Limit_F32.h GFLIB_Limit_FLT.h GFLIB_LowerLimit_F16.h GFLIB_LowerLimit_F32.h GFLIB_LowerLimit_FLT.h GFLIB_Lut_F16_Asmi.h GFLIB_Lut_F32.h GFLIB_Lut_FLT.h GFLIB_LutPer_F16_Asmi.h GFLIB_LutPer_F32.h GFLIB_LutPer_FLT.h GFLIB_Ramp_F16.h GFLIB_Ramp_F32.h GFLIB_Ramp_FLT.h GFLIB_SinCos_F32.h GFLIB_SinCos_FLT.h GFLIB_Sqrt_F16.h GFLIB_Sqrt_F32.h GFLIB_Sqrt_FLT_Asmi.h GFLIB_Tan_F32.h GFLIB_Tan_FLT.h gflib_types.h GFLIB_UpperLimit_F16.h GFLIB_UpperLimit_F32.h GFLIB_UpperLimit_FLT.h GFLIB_VectorLimit_F16.h GFLIB_VectorLimit_FLT.h
  group rtcesl/CM7F_RTCESL_4.8_KEIL/GMCLIB/Include
    ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.8_KEIL/GMCLIB/Include/: gmclib.h GMCLIB_Clark_F16_Asmi.h GMCLIB_Clark_FLT.h GMCLIB_Decoupling_A32.h GMCLIB_DTCompLut1D_F16.h GMCLIB_Decoupling_FLT.h GMCLIB_ElimDcBusRip_A32_Asmi.h GMCLIB_ElimDcBusRip_F16_Asmi.h GMCLIB_ElimDcBusRip_FLT.h gmclib_FP.h GMCLIB_Park_F16_Asmi.h GMCLIB_Park_FLT.h GMCLIB_Svm_F16.h gmclib_types.h
  group rtcesl/CM7F_RTCESL_4.8_KEIL/MLIB/Include
    ../../../../../../middleware/rtcesl/CM7F_RTCESL_4.8_KEIL/MLIB/Include/: asm_mac.h mlib.h MLIB_Abs_F16.h MLIB_Abs_F16_Asmi.h MLIB_Abs_F32.h MLIB_Abs_F32_Asmi.h MLIB_Abs_FLT.h MLIB_Abs_FLT_Asmi.h MLIB_Add_A32.h MLIB_Add_F16.h MLIB_Add_F16_Asmi.h MLIB_Add_F32.h MLIB_Add_F32_Asmi.h MLIB_Add_FLT.h MLIB_Add4_F16_Asmi.h MLIB_Add4_F32_Asmi.h MLIB_Add4_FLT.h MLIB_BiShift_F16.h MLIB_BiShift_F32.h MLIB_Clb_F16.h MLIB_Clb_F32.h MLIB_Conv_F32.h MLIB_Conv_FLT_Asmi.h MLIB_ConvSc_FLT_Asmi.h MLIB_Div_A32.h MLIB_Div_F16.h MLIB_Div_F32.h MLIB_Div_FLT.h MLIB_Div1Q_A32.h MLIB_Div1Q_F16.h MLIB_Div1Q_F32.h mlib_FP.h MLIB_Log2_U16.h MLIB_Mac_A32.h MLIB_Mac_F16_Asmi.h MLIB_Mac_F32.h MLIB_Mac_F32_Asmi.h MLIB_Mac_FLT.h MLIB_Mac4_F32.h MLIB_Mac4_F32_Asmi.h MLIB_Mac4_FLT.h MLIB_Mac4Rnd_F16_Asmi.h MLIB_Mac4Rnd_F32.h MLIB_Mac4Rnd_F32_Asmi.h MLIB_MacRnd_A32.h MLIB_MacRnd_F16_Asmi.h MLIB_MacRnd_F32.h MLIB_MacRnd_F32_Asmi.h MLIB_Mnac_A32.h MLIB_Mnac_F16_Asmi.h MLIB_Mnac_F32.h MLIB_Mnac_F32_Asmi.h MLIB_Mnac_FLT.h MLIB_MnacRnd_A32.h MLIB_MnacRnd_F16_Asmi.h MLIB_MnacRnd_F32.h MLIB_MnacRnd_F32_Asmi.h MLIB_Msu_A32.h MLIB_Msu_F16_Asmi.h MLIB_Msu_F32_Asmi.h MLIB_Msu_FLT.h MLIB_Msu4_F32.h MLIB_Msu4_F32_Asmi.h MLIB_Msu4_FLT.h MLIB_Msu4Rnd_F16.h MLIB_Msu4Rnd_F16_Asmi.h MLIB_Msu4Rnd_F32.h MLIB_Msu4Rnd_F32_Asmi.h MLIB_MsuRnd_A32.h MLIB_MsuRnd_F16_Asmi.h MLIB_MsuRnd_F32.h MLIB_MsuRnd_F32_Asmi.h MLIB_Mul_A32.h MLIB_Mul_A32_Asmi.h MLIB_Mul_F16.h MLIB_Mul_F16_Asmi.h MLIB_Mul_F32.h MLIB_Mul_F32_Asmi.h MLIB_Mul_FLT.h MLIB_MulRnd_A32.h MLIB_MulRnd_A32_Asmi.h MLIB_MulRnd_F16.h MLIB_MulRnd_F16_Asmi.h MLIB_MulRnd_F32.h MLIB_MulRnd_F32_Asmi.h MLIB_Neg_F16.h MLIB_Neg_F16_Asmi.h MLIB_Neg_F32.h MLIB_Neg_F32_Asmi.h MLIB_Neg_FLT.h MLIB_Rcp_A32.h MLIB_Rcp1Q_A32.h MLIB_Rnd_F32.h MLIB_Rnd_F32_Asmi.h MLIB_Sat_A32_Asmi.h MLIB_Shift_F16.h MLIB_Shift_F16_Asmi.h MLIB_Shift_F32.h MLIB_Shift_F32_Asmi.h MLIB_Sign_F16_Asmi.h MLIB_Sign_F32_Asmi.h MLIB_Sign_FLT_Asmi.h MLIB_Sub_A32.h MLIB_Sub_F16.h MLIB_Sub_F16_Asmi.h MLIB_Sub_F32.h MLIB_Sub_F32_Asmi.h MLIB_Sub_F64.h MLIB_Sub_FLT.h MLIB_Sub4_F16_Asmi.h MLIB_Sub4_F32_Asmi.h MLIB_Sub4_FLT.h mlib_types.h RTCESL_cfg.h
  group motor_control/docs
    ../../../../../../middleware/motor_control/docs/: readme_pmsm.txt
  group motor_control/pmsm/pmsm_float/mc_algorithms
    ../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_algorithms/: pmsm_control.c pmsm_control.h pmsm_control.c pmsm_control.h
  group motor_control/pmsm/pmsm_float/state_machine
    ../../../../../../middleware/motor_control/pmsm/pmsm_float/state_machine/: state_machine.c state_machine.h
  group motor_control/pmsm/pmsm_float/mc_state_machine
    ../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_state_machine/: m1_sm_snsless_enc.c m1_sm_snsless_enc.h sm_common.h
  group motor_control/freemaster
    ../../../../../../middleware/motor_control/freemaster/: pmsm_float_enc.pmpx pmsm_float_enc.pmpx
  group motor_control/pmsm/pmsm_float/mc_identification
    ../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_identification/: hall_calib.c hall_calib.h ke_measure.c ke_measure.h mech_measure.c mech_measure.h mid_auxiliary.c mid_auxiliary.h mid_def.h mid_mc_api_connector.c mid_mc_api_connector.h mid_sm_states.c mid_sm_states.h pp_measure.c pp_measure.h
  group motor_control/pmsm/pmsm_float
    ../../../../../../middleware/motor_control/pmsm/pmsm_float/: fm_tsa_pmsm.c
  group motor_control/pmsm/pmsm_float/mc_drivers
    ../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_drivers/: mcdrv_adc_imxrt118x.h mcdrv_adc_imxrt118x.c mcdrv_pwm3ph_pwma.c mcdrv_pwm3ph_pwma.h mcdrv_enc_eqd2.c mcdrv_enc_eqd2.h
  group motor_control/freemaster/pmsm_float/mcat/assets
    ../../../../../../middleware/motor_control/freemaster/pmsm_float/mcat/assets/: speedfocwolswbemf.gif
  group motor_control/freemaster/pmsm_float/mcat/css
    ../../../../../../middleware/motor_control/freemaster/pmsm_float/mcat/css/: app.css
  group motor_control/freemaster/pmsm_float/mcat/js
    ../../../../../../middleware/motor_control/freemaster/pmsm_float/mcat/js/: chunk.js chunk.js.map mcat.js mcat.js.map
  group motor_control/freemaster/pmsm_float/mcat
    ../../../../../../middleware/motor_control/freemaster/pmsm_float/mcat/: freemaster-client.js index.html init.js simple-jsonrpc-js.js
  group motor_control/pmsm/pmsm_float/mc_algorithms/mcaa_lib/cm7f_mdk/Include
    ../../../../../../middleware/motor_control/pmsm/pmsm_float/mc_algorithms/mcaa_lib/cm7f_mdk/Include/: MCAA_EstimRL_FLT.h mcaa_lib_fp.h
  group doc
    ../: readme.md example_board_readme.md
target ecat_servo_motor_cm7 flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1189CVM8B:cm7 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ecat_servo_motor_cm7.out
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, XIP_EXTERNAL_FLASH=1, SDK_DEBUGCONSOLE_UART, SERIAL_PORT_TYPE_UART=1, PRINTF_ADVANCED_ENABLE=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8B_cm7, PMSM_SNSLESS, PMSM_SNSLESS_ENC, MID_EN
  c misc: as above
  c include: as above
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8B_cm7
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1189xxxxx_cm7_flexspi_nor.scf
  link misc: as above
target ecat_servo_motor_cm7 release (ARM-ADS)
  device: MIMXRT1189CVM8B:cm7 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ecat_servo_motor_cm7.out
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, SDK_DEBUGCONSOLE_UART, SERIAL_PORT_TYPE_UART=1, PRINTF_ADVANCED_ENABLE=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8B_cm7, PMSM_SNSLESS, PMSM_SNSLESS_ENC, MID_EN
  c misc: -include ../mcux_config.h -Oz  -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8B_cm7
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1189xxxxx_cm7_ram.scf
  link misc: as above
target ecat_servo_motor_cm7 flexspi_nor_release (ARM-ADS)
  device: MIMXRT1189CVM8B:cm7 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ecat_servo_motor_cm7.out
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, XIP_EXTERNAL_FLASH=1, SDK_DEBUGCONSOLE_UART, SERIAL_PORT_TYPE_UART=1, PRINTF_ADVANCED_ENABLE=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8B_cm7, PMSM_SNSLESS, PMSM_SNSLESS_ENC, MID_EN
  c misc: as above
  c include: as above
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8B_cm7
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1189xxxxx_cm7_flexspi_nor.scf
  link misc: as above
