# Keil uVision project handsfree.uvprojx, settings and files
target handsfree flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1189CVM8B:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU)  DSP
  output: handsfree.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=0, DEBUG, CPU_MIMXRT1189CVM8B_cm33, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, APPL_USE_STANDARD_IO, GATT_CLIENT, GATT_DB, FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0, FSL_OSA_MAIN_FUNC_ENABLE=0, HAL_UART_ADAPTER_FIFO=1, FSL_FEATURE_FLASH_PAGE_SIZE_BYTES=4096, HAL_AUDIO_DMA_INIT_ENABLE=0, HAL_UART_DMA_INIT_ENABLE=0, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, SDK_OS_FREE_RTOS, FSL_OSA_TASK_ENABLE=1, SDIO_ENABLED=1, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING=1, SDK_DEBUGCONSOLE_UART=1, CONFIG_BT_BREDR=1, CONFIG_BT_PERIPHERAL=1, CONFIG_BT_CENTRAL=1, CONFIG_BT_SMP=1, CONFIG_BT_DEVICE_NAME='\"edgefast_hfp\"', OSA_USED=1, SHELL_USE_COMMON_TASK=0, SHELL_TASK_STACK_SIZE=2048, SHELL_TASK_PRIORITY=configMAX_PRIORITIES-2, LPUART_RING_BUFFER_SIZE=1024U, HAL_UART_DMA_ENABLE=1, LFS_NO_INTRINSICS=1, LFS_NO_ERROR=1, CONFIG_ARM=1, EDGEFAST_BT_LITTLEFS_MFLASH, MBEDTLS_CONFIG_FILE='\"ele_s400_mbedtls_config.h\"', MBEDTLS_MCUX_ELE_S400_API, MCUXPRESSO_SDK, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8962_ENABLE, DEBUG_CONSOLE_RX_ENABLE=0, LOG_ENABLE_ASYNC_MODE=1, LOG_MAX_ARGUMENT_COUNT=10, LOG_ENABLE_OVERWRITE=0, CACHE_MODE_WRITE_THROUGH=1, MFLASH_FILE_BASEADDR=14221312, SERIAL_PORT_TYPE_UART=1, LWIP_DNS=1, LWIP_NETIF_HOSTNAME=1, LWIP_IGMP=1, _XOPEN_SOURCE=500
  c misc: -include ../app_bluetooth_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../controller/configs/mbedtls;../controller/configs/lwip;../controller/configs/wifi;../platform/configs;../../../../../../components/audio;../../../../../../components/i2c;../../../../../../components/codec/i2c;../../../../../../components/codec/port/wm8962;../../../../../../components/codec/port;../../../../../../components/codec;../../../../../../devices/MIMXRT1189/drivers;../../../../../../components/codec/wm8962;../../../../../../components/osa;../../../../../../devices/MIMXRT1189/utilities/shell;../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../middleware/wireless/ethermind/bluetooth/export/eOSAL;../../../../../../middleware/wireless/ethermind/bluetooth/export/include;../../../../../../middleware/wireless/ethermind/bluetooth/export/vendor;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/att;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avctp;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avdtp;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/bnep;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/dbase;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/hci_1.2;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/mcap;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/obex;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/rfcomm;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sdp;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sm;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/smp;../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/aes_cmac;../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/at_parser;../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/object_parser;../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/racp;../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/storage;../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/xml_parser;../../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth;../../../../../../middleware/wireless/ethermind/port/pal/mcux/ethal;../../../../../../middleware/wireless/ethermind/port/pal/mcux/sbc;../../../../../../middleware/wireless/ethermind/port/osal/src/freertos;../../../../../../middleware/wireless/ethermind/port/pal/mcux;../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/sbc;../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/config;../../../../../../middleware/wireless/ethermind/bluetooth/export/extension;../../../../../../middleware/wifi_nxp/incl;../../../../../../middleware/wifi_nxp/wifi_bt_firmware;../../../../../../middleware/wifi_nxp/wifi_bt_firmware/8801;../../../../../../middleware/wifi_nxp/wifi_bt_firmware/IW416;../../../../../../middleware/wifi_nxp/wifi_bt_firmware/8987;../../../../../../middleware/wifi_nxp/wifi_bt_firmware/nw61x;../../../../../../middleware/wifi_nxp/wifidriver;../../../../../../middleware/wifi_nxp/wifidriver/incl;../../../../../../middleware/wifi_nxp/firmware_dnld;../../../../../../middleware/wifi_nxp/sdio_nxp_abs;../../../../../../middleware/wifi_nxp/sdio_nxp_abs/incl;../../../../../../middleware/wifi_nxp/fwdnld_intf_abs;../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/host;../../../../../../middleware/edgefast_bluetooth/include;../../../../../../middleware/edgefast_bluetooth/source/porting;../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind;../../../../../../components/common_task;../../../../../../components/ele_crypto;../../../../../../components/lists;../../../../../../components/uart;../../../../../../devices/MIMXRT1189/drivers/cm33;../../../../../../components/flash/mflash/mimxrt1180;../../../../../../components/flash/mflash;../../../../../../components/gpio;../../../../../../components/serial_manager;../../../../../../devices/MIMXRT1189;../../../../xip;../../../../../../devices/MIMXRT1189/xip;../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/platform;../../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth/controller;../../../../../../middleware/fatfs/source/fsl_usb_disk;../../../../../../middleware/fatfs/source;../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure;../../../../../../middleware/littlefs;../../../../../../middleware/mbedtls/include;../../../../../../middleware/mbedtls/library;../../../../../../middleware/mbedtls/port/ele_s400;../../../../../../middleware/sdmmc/host/usdhc;../../../../../../middleware/sdmmc/sdio;../../../../../../middleware/usb/host;../../../../../../middleware/usb/include;../../../../../../middleware/usb/host/class;../../../../../../middleware/usb/phy;../../../../../../devices/MIMXRT1189/utilities;../../../../../../devices/MIMXRT1189/utilities/debug_console;../../../../../../devices/MIMXRT1189/utilities/str;../../../../../../middleware/wifi_nxp/incl/port/osa;../../../../../../middleware/wifi_nxp/incl/wifidriver;../../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits;../../../../../../components/wifi_bt_module/Murata/tx_pwr_limits;../../../../../../components/wifi_bt_module/u-blox/tx_pwr_limits;../../../../../../components/wifi_bt_module/incl;../../../../../../middleware/wifi_nxp;../../../../../../middleware/wifi_nxp/port/osa;../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/crypto;../../../../../../components/log;../../../../../../CMSIS/Core/Include;../../../../../../middleware/sdmmc/common;../../../../../../middleware/sdmmc/osa
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../controller/configs/mbedtls;..;../../../../../../rtos/freertos/freertos-kernel/include
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1189xxxxx_cm33_flexspi_nor.scf
  link misc: ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm33/mdk/libethermind_bt_a2dp.lib ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm33/mdk/libethermind_bt_avrcp.lib ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm33/mdk/libethermind_bt_bip.lib ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm33/mdk/libethermind_bt_bpp.lib ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm33/mdk/libethermind_bt_core.lib ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm33/mdk/libethermind_bt_ctn.lib ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm33/mdk/libethermind_bt_ftp.lib ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm33/mdk/libethermind_bt_ga.lib ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm33/mdk/libethermind_bt_gatt.lib ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm33/mdk/libethermind_bt_hfp.lib ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm33/mdk/libethermind_bt_hid.lib ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm33/mdk/libethermind_bt_map.lib ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm33/mdk/libethermind_bt_opp.lib ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm33/mdk/libethermind_bt_pan.lib ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm33/mdk/libethermind_bt_pbap.lib ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm33/mdk/libethermind_bt_protocol.lib ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm33/mdk/libethermind_bt_sap.lib ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm33/mdk/libethermind_bt_spp.lib ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm33/mdk/libethermind_bt_util.lib ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm33/mdk/libethermind_sbc_common.lib ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm33/mdk/libethermind_sbc_decoder.lib ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/btdm/cm33/mdk/libethermind_sbc_encoder.lib --remove --keep=*(._bt_*) --keep=*(._net_buf_pool*) --keep=*(._settings_handler_static*) --keep=mflash_drv.o(*) --legacyalign --entry=Reset_Handler --diag_suppress 6314 --predefine="-DXIP_BOOT_HEADER_ENABLE=0"
  group source
    ../: app_bluetooth_config.h main.c app_handsfree.c app_handsfree.h app_shell.c app_shell.h sco_audio_pl_ext.c ringtone.h edgefast_bluetooth_config.h edgefast_bluetooth_debug_config.h wifi_bt_module_config.h FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h wifi_bt_config.c wifi_bt_config.h sdmmc_config.c sdmmc_config.h
  group source/controller/configs/mbedtls
    ../controller/configs/mbedtls/: mbedtls_config_client.h
  group doc
    ../: readme.md
  group source/controller/configs
    ../controller/configs/lwip/: lwipopts.h lwippools.h
    ../controller/configs/wifi/: wifi_config.h
  group source/platform/configs
    ../platform/configs/: ffconf.h usb_host_config.h
  group component/audio
    ../../../../../../components/audio/: fsl_adapter_audio.h fsl_adapter_sai.c
  group component/i2c
    ../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group codec
    ../../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
    ../../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../../components/codec/wm8962/: fsl_wm8962.h fsl_wm8962.c
  group codec/port/wm8962
    ../../../../../../components/codec/port/wm8962/: fsl_codec_wm8962_adapter.c fsl_codec_wm8962_adapter.h
  group codec/port
    ../../../../../../components/codec/port/: fsl_codec_adapter.h
  group drivers
    ../../../../../../devices/MIMXRT1189/drivers/: fsl_lpi2c.c fsl_lpi2c.h fsl_sai.h fsl_sai.c fsl_sai_edma.h fsl_sai_edma.c fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_misc.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_dcdc.h fsl_dcdc.c fsl_edma.h fsl_edma_core.h fsl_edma.c fsl_flexspi.c fsl_flexspi.h fsl_iomuxc.h fsl_lpuart_edma.h fsl_lpuart_edma.c fsl_pmu.h fsl_pmu.c fsl_rgpio.h fsl_rgpio.c fsl_s3mu.c fsl_s3mu.h fsl_trdc.h fsl_trdc.c fsl_ele_base_api.h fsl_ele_base_api.c fsl_edma_soc.h fsl_edma_soc.c fsl_memory.h fsl_usdhc.c fsl_usdhc.h
    ../../../../../../devices/MIMXRT1189/drivers/cm33/: fsl_cache.c fsl_cache.h
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h fsl_os_abstraction_config.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: heap_4.c ReadMe.url
  group utilities
    ../../../../../../devices/MIMXRT1189/utilities/shell/: fsl_shell.c fsl_shell.h
    ../../../../../../devices/MIMXRT1189/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../../devices/MIMXRT1189/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1189/utilities/str/: fsl_str.c fsl_str.h
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group bt_ble/bluetooth/export/eOSAL
    ../../../../../../middleware/wireless/ethermind/bluetooth/export/eOSAL/: eBT_assert.h eBT_config.h eBT_debug_api.h eBT_fops.h eBT_os.h eBT_serial.h eBT_timer.h
  group bt_ble/bluetooth/export/include
    ../../../../../../middleware/wireless/ethermind/bluetooth/export/include/: BT_a2dp_api.h BT_analyzer.h BT_api.h BT_assigned_numbers.h BT_at_parser_api.h BT_att_api.h BT_avctp_api.h BT_avdtp_api.h BT_avrcp_api.h BT_avrcp_ca_api.h BT_bip_api.h BT_bnep_api.h BT_bottom_half.h BT_bpp_api.h BT_common.h BT_ctn_api.h BT_dbase_api.h BT_device_queue.h BT_error.h BT_ftp_api.h BT_gap_api.h BT_gatt_db_api.h BT_hci_api.h BT_hdp_api.h BT_hfp_ag_api.h BT_hfp_unit_api.h BT_hid_device_api.h BT_hid_host_api.h BT_irobex_api.h BT_jpl_api.h BT_map_api.h BT_mcap_api.h BT_obex_api.h BT_opp_api.h BT_pan_api.h BT_pbap_api.h BT_racp.h BT_rfcomm_api.h BT_sap_api.h BT_sdp_api.h BT_security.h BT_sm_api.h BT_smp_api.h BT_snoop.h BT_spp_api.h BT_status.h BT_storage.h BT_version.h fsm_defines.h fsm_engine.h gatt_defines.h hci_transport.h l2cap.h write_task.h
  group bt_ble/bluetooth/export/vendor
    ../../../../../../middleware/wireless/ethermind/bluetooth/export/vendor/: vendor_specific_commands.h vendor_specific_init.c vendor_specific_init.h
  group bt_ble/bluetooth/private/protocols/att
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/att/: att.h
  group bt_ble/bluetooth/private/protocols/avctp
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avctp/: avctp.h
  group bt_ble/bluetooth/private/protocols/avdtp
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avdtp/: avdtp.h
  group bt_ble/bluetooth/private/protocols/bnep
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/bnep/: bnep.h
  group bt_ble/bluetooth/private/protocols/dbase
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/dbase/: database.h
  group bt_ble/bluetooth/private/protocols/hci_1.2
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/hci_1.2/: hci_h.h
  group bt_ble/bluetooth/private/protocols/mcap
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/mcap/: mcap.h
  group bt_ble/bluetooth/private/protocols/obex
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/obex/: obex.h
  group bt_ble/bluetooth/private/protocols/rfcomm
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/rfcomm/: rfcomm.h
  group bt_ble/bluetooth/private/protocols/sdp
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sdp/: sdp.h
  group bt_ble/bluetooth/private/protocols/sm
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sm/: sm.h sm_extern.h sm_internal.h
  group bt_ble/bluetooth/private/protocols/smp
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/smp/: smp.h smp_extern.h smp_fsm.h smp_fsm_engine.h smp_internal.h
  group bt_ble/bluetooth/private/utils/aes_cmac
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/aes_cmac/: aes_cmac.h
  group bt_ble/bluetooth/private/utils/at_parser
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/at_parser/: at_parser_hsp_hfp.h
  group bt_ble/bluetooth/private/utils/object_parser
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/object_parser/: object_parser_api.h tokenizer.h
  group bt_ble/bluetooth/private/utils/racp
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/racp/: racp.h
  group bt_ble/bluetooth/private/utils/storage
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/storage/: storage.h
  group bt_ble/bluetooth/private/utils/xml_parser
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/xml_parser/: xml_common_defines.h xml_encoder.h xml_parser.h
  group bt_ble/port/osal/src/freertos
    ../../../../../../middleware/wireless/ethermind/port/osal/src/freertos/: EM_assert.h EM_config.c EM_config.h EM_debug.c EM_debug.h EM_debug_api.h EM_debug_internal.h EM_fops.c EM_fops.h EM_os.c EM_os.h EM_serial.c EM_serial.h EM_timer.c EM_timer.h EM_timer_internal.h
  group bt_ble/port/pal/mcux/bluetooth
    ../../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth/: BT_assert.h BT_config.h BT_debug.h BT_debug_api.h BT_fops.h BT_os.h BT_status_pl.c BT_storage_pl.c BT_storage_pl.h BT_timer.h btsnoop_pl.c btsnoop_pl.h sco_audio_pl.c sco_audio_pl.h ctn_pl.c ctn_pl.h ftp_pl.c ftp_pl.h hci_uart_internal.h ht_read_task_pl.c map_pl.c map_pl.h obex_pl.c obex_pl.h pbap_pl.c pbap_pl.h write_task_extern_pl.h write_task_pl.c write_task_pl.h littlefs_pl.c littlefs_pl.h fw_loader_uart.c fw_loader_uart.h hci_uart.c hci_uart.h hci_uart_internal.h
  group bt_ble/port/pal/mcux/ethal
    ../../../../../../middleware/wireless/ethermind/port/pal/mcux/ethal/: ethal_assert.h ethal_config.c ethal_config.h ethal_debug.c ethal_debug.h ethal_debug_api.h ethal_debug_internal.h ethal_fops.c ethal_fops.h ethal_os.c ethal_os.h ethal_serial.c ethal_serial.h ethal_timer.c ethal_timer.h ethal_timer_internal.h
  group bt_ble/port/pal/mcux/sbc
    ../../../../../../middleware/wireless/ethermind/port/pal/mcux/sbc/: sbc_os.h
  group bt_ble/port/pal/mcux
    ../../../../../../middleware/wireless/ethermind/port/pal/mcux/: EM_platform.c EM_platform.h
  group bt_ble/bluetooth/private/utils/sbc
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/sbc/: sbc_api.h
  group bt_ble/bluetooth/private/lib/config
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/config/: BT_features.h BT_limits.h db_gen.h
  group bt_ble/bluetooth/export/extension
    ../../../../../../middleware/wireless/ethermind/bluetooth/export/extension/: aes_cmac_pl.c aes_cmac_pl.h BT_common_pl.c BT_common_pl.h device_queue_pl.c device_queue_pl.h sm_pl.c sm_pl.h sm_ssp_pl.c sm_ssp_pl.h smp_pl.c smp_pl.h gatt_db_pl.c gatt_db_pl.h
  group wifi/incl
    ../../../../../../middleware/wifi_nxp/incl/: WIFI_IW416_BOARD_AW_AM457_CAL_DATA_EXT.h wifi_config_default.h wifi_cal_data_ext.h wm_utils.h wmerrno.h wmlog.h wmtypes.h
  group wifi/wifidriver/incl
    ../../../../../../middleware/wifi_nxp/wifidriver/incl/: mlan_main_defs.h mlan_decl.h mlan_ioctl.h type_decls.h
  group wifi/wifi_bt_firmware/8801
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/8801/: sd8801_wlan.bin.inc sd8801_wlan.h 8801_cpu1.c
  group wifi/wifi_bt_firmware/IW416
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/IW416/: sduartIW416_wlan_bt.bin.inc sdIW416_wlan.bin.inc uartIW416_bt.bin.inc sduartIW416_wlan_bt.h sdIW416_wlan.h uartIW416_bt.h IW416_cpu12.c IW416_cpu1.c IW416_cpu2.c
  group wifi/wifi_bt_firmware/8987
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/8987/: sduart8987_wlan_bt.bin.inc sd8987_wlan.bin.inc uart8987_bt.bin.inc sduart8987_wlan_bt.h sd8987_wlan.h uart8987_bt.h 8987_cpu12.c 8987_cpu1.c 8987_cpu2.c
  group wifi/wifi_bt_firmware/nw61x
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/nw61x/: sduart_nw61x.bin.se.inc sd_nw61x.bin.se.inc uart_nw61x.bin.se.inc sduart_nw61x_se.h sd_nw61x_se.h uart_nw61x_se.h nw61x_cpu12_se.c nw61x_cpu1_se.c nw61x_cpu2_se.c
  group wifi/wifidriver
    ../../../../../../middleware/wifi_nxp/wifidriver/: sdio.c sdio.h wifi-sdio.h
  group wifi/firmware_dnld
    ../../../../../../middleware/wifi_nxp/firmware_dnld/: firmware_dnld.c firmware_dnld.h
  group edgefast/bluetooth/source/host
    ../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/host/: bt_pal_a2dp.c bt_pal_a2dp_internal.h bt_pal_avrcp.c bt_pal_avrcp_al_api.h bt_pal_avrcp_al_internal.c bt_pal_avrcp_al_internal.h bt_pal_avrcp_al_api.c bt_pal_avrcp_internal.h bt_pal_at.h bt_pal_att_internal.h bt_pal_avdtp_internal.h bt_pal_conn.c bt_pal_conn_internal.h bt_pal_data.c bt_pal_ead.c bt_pal_crypto.c bt_pal_crypto_internal.h bt_pal_gatt_internal.h bt_pal_hci_core.c bt_pal_hci_core.h bt_pal_adv.c bt_pal_adv.h bt_pal_br.c bt_pal_br.h bt_pal_id.c bt_pal_id.h bt_pal_scan.c bt_pal_scan.h bt_pal_ecc.c bt_pal_ecc.h bt_pal_addr.c bt_pal_addr_internal.h bt_pal_buf.c bt_pal_direction.c bt_pal_direction_internal.h bt_pal_hci_ecc.h bt_pal_keys.c bt_pal_keys.h bt_pal_keys_br.c bt_pal_l2cap.c bt_pal_l2cap_br.c bt_pal_l2cap_internal.h bt_pal_l2cap_br_internal.h bt_pal_l2cap_br_interface.h bt_pal_monitor.c bt_pal_monitor.h bt_pal_rfcomm.c bt_pal_rfcomm_internal.h bt_pal_spp.c bt_pal_rpa.c bt_pal_rpa.h bt_pal_settings.h bt_pal_settings.c bt_pal_sdp.c bt_pal_sdp_internal.h bt_pal_smp.c bt_pal_smp.h bt_pal_ssp.c bt_pal_ssp.h bt_pal_uuid.c bt_pal_hfp_ag.c bt_pal_hfp_hf.c bt_pal_hfp_internal.h
  group edgefast/bluetooth/source/host/a2dp_codec/sbc
    ../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/host/a2dp_codec/sbc/: a2dp_codec_sbc.c
  group edgefast/bluetooth/include/bluetooth
    ../../../../../../middleware/edgefast_bluetooth/include/bluetooth/: a2dp.h avrcp.h a2dp_codec_sbc.h addr.h att.h avdtp.h bluetooth.h direction.h buf.h l2cap.h rfcomm.h spp.h sdp.h conn.h crypto.h gap.h gatt.h hci.h byteorder.h hci_types.h ead.h hci_raw.h hci_vs.h hfp_hf.h hfp_ag.h iso.h testing.h uuid.h
  group edgefast/bluetooth/common
    ../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/common/: addr.c
  group edgefast/bluetooth/include/sys
    ../../../../../../middleware/edgefast_bluetooth/include/sys/: util.h util_internal.h util_loops.h util_macro.h printk.h check.h byteorder.h ring_buffer.h ffs.h work_queue.h slist.h dlist.h atomic.h
  group edgefast/bluetooth/include/zephyr
    ../../../../../../middleware/edgefast_bluetooth/include/zephyr/: types.h
  group edgefast/bluetooth/porting
    ../../../../../../middleware/edgefast_bluetooth/source/porting/: ring_buffer.c porting.c porting.h utf8.c work_queue.c buf.c slist.c atomic_c.c
  group edgefast/bluetooth/porting/errno
    ../../../../../../middleware/edgefast_bluetooth/source/porting/errno/: errno.h
  group edgefast/bluetooth/porting/fifo
    ../../../../../../middleware/edgefast_bluetooth/source/porting/fifo/: fifo.c fifo.h
  group bt_ble/port/pal/mcux/edgefast_support
    ../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/: bt_db_gen.c
    ../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/platform/: host_msd_fatfs.c host_msd_fatfs.h bt_ble_platform.c bt_ble_platform.h bt_ble_settings.c bt_ble_settings.h
  group edgefast/bluetooth/include/toolchain
    ../../../../../../middleware/edgefast_bluetooth/include/toolchain/: common.h gcc.h iar.h armcc.h
  group edgefast/bluetooth/include
    ../../../../../../middleware/edgefast_bluetooth/include/: toolchain.h
  group edgefast/bluetooth/include/net
    ../../../../../../middleware/edgefast_bluetooth/include/net/: buf.h
  group component/common_task
    ../../../../../../components/common_task/: fsl_component_common_task.h fsl_component_common_task.c
  group component/ele_crypto
    ../../../../../../components/ele_crypto/: ele_crypto.c ele_crypto.h ele_crypto_internal.h
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group flash/mflash/mimxrt1180
    ../../../../../../components/flash/mflash/mimxrt1180/: mflash_drv.h mflash_drv.c
  group flash/mflash
    ../../../../../../components/flash/mflash/: mflash_file.h mflash_file.c mflash_common.h
  group component/gpio
    ../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_rgpio.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group device
    ../../../../../../devices/MIMXRT1189/: fsl_device_registers.h MIMXRT1189_cm33.h MIMXRT1189_cm33_features.h system_MIMXRT1189_cm33.c system_MIMXRT1189_cm33.h
  group startup
    ../../../../../../devices/MIMXRT1189/arm/: startup_MIMXRT1189_cm33.S
  group xip
    ../../../../xip/: evkmimxrt1180_flexspi_nor_config.c evkmimxrt1180_flexspi_nor_config.h
    ../../../../../../devices/MIMXRT1189/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
  group bt_ble/port/pal/mcux/bluetooth/controller
    ../../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth/controller/: controller.h controller_wifi_nxp.c controller_hci_uart.h
  group fatfs/source/fsl_usb_disk
    ../../../../../../middleware/fatfs/source/fsl_usb_disk/: fsl_usb_disk.h fsl_usb_disk_freertos.c
  group fatfs/source
    ../../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure
    ../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.c port.c portasm.c portasm.h portmacro.h portmacrocommon.h
  group littlefs
    ../../../../../../middleware/littlefs/: lfs.c lfs_util.c lfs.h lfs_util.h
  group mbedtls/include/mbedtls
    ../../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h psa_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/include/psa
    ../../../../../../middleware/mbedtls/include/psa/: crypto.h crypto_builtin_composites.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group mbedtls/library
    ../../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum_internal.h bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cmac.c common.h constant_time.c constant_time_internal.h constant_time_invasive.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_invasive.h entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c mps_common.h mps_error.h mps_reader.c mps_reader.h mps_trace.c mps_trace.h net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c ssl_tls13_keys.h threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/port/ele_s400
    ../../../../../../middleware/mbedtls/port/ele_s400/: ele_mbedtls.c ele_mbedtls.h ele_s400_mbedtls_config.h ele_fw.h ele_entropy.c aes_alt.h aes_alt.c ccm_alt.h ccm_alt.c gcm_alt.h gcm_alt.c rsa_alt.h rsa_alt.c threading_alt.h sha256_alt.c sha256_alt.h sha512_alt.c sha512_alt.h hmac_alt.c
  group sdmmc/host
    ../../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
    ../../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt ChangeLogKSDK.txt
  group sdmmc/src
    ../../../../../../middleware/sdmmc/sdio/: fsl_sdio.c
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../../middleware/sdmmc/sdio/: fsl_sdio.h
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sdio
    ../../../../../../middleware/sdmmc/sdio/: ChangeLogKSDK.txt
  group usb/host
    ../../../../../../middleware/usb/host/: usb_host_ehci.c usb_host_ehci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c usb_host.h usb_host_hci.h usb_host_devices.h usb_host_framework.h
  group usb/host/class
    ../../../../../../middleware/usb/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_msd.c usb_host_msd.h usb_host_msd_ufi.c
  group usb/phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group wifi/sdio_nxp_abs
    ../../../../../../middleware/wifi_nxp/sdio_nxp_abs/: mlan_sdio.c fwdnld_sdio.c
  group wifi/sdio_nxp_abs/incl
    ../../../../../../middleware/wifi_nxp/sdio_nxp_abs/incl/: fwdnld_sdio.h mlan_sdio_defs.h mlan_sdio.h mlan_sdio_api.h
  group wifi/incl/wifidriver
    ../../../../../../middleware/wifi_nxp/incl/wifidriver/: wifi-decl.h wifi.h wifi_events.h
  group wifi/wifi_bt_firmware
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/: wlan_bt_fw.h
  group wifi/fwdnld_intf_abs
    ../../../../../../middleware/wifi_nxp/fwdnld_intf_abs/: fwdnld_intf_abs.c fwdnld_intf_abs.h
  group component/wifi_bt_module/AzureWave/tx_pwr_limits
    ../../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits/: wlan_txpwrlimit_cfg_WW.h wlan_txpwrlimit_cfg_WW_rw610.h
  group component/wifi_bt_module/Murata/tx_pwr_limits
    ../../../../../../components/wifi_bt_module/Murata/tx_pwr_limits/: wlan_txpwrlimit_cfg_murata_1XK_WW.h wlan_txpwrlimit_cfg_murata_1ZM_WW.h wlan_txpwrlimit_cfg_murata_2DS_WW.h wlan_txpwrlimit_cfg_murata_2EL_WW.h
  group component/wifi_bt_module/u-blox/tx_pwr_limits
    ../../../../../../components/wifi_bt_module/u-blox/tx_pwr_limits/: wlan_txpwrlimit_cfg_jody_w5_WW.h
  group component/wifi_bt_module/incl
    ../../../../../../components/wifi_bt_module/incl/: wifi_bt_module_config.h
  group wifi/incl/port/osa
    ../../../../../../middleware/wifi_nxp/incl/port/osa/: osa.h mem_pool.h mem_pool_config.h slist.h stack_simple.h
  group wifi/port/osa
    ../../../../../../middleware/wifi_nxp/port/osa/: osa.c mem_pool.c mem_pool_config.c slist.c stack_simple.c osa_freertos.h osa_freertos.c
  group edgefast/bluetooth/crypto
    ../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/crypto/: bt_crypto.c bt_crypto.h
  group component/log
    ../../../../../../components/log/: fsl_component_log.h fsl_component_log_config.h fsl_component_log.c
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group sdmmc/osa
    ../../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
target handsfree flexspi_nor_release (ARM-ADS)
  device: MIMXRT1189CVM8B:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU)  DSP
  output: handsfree.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=0, NDEBUG, CPU_MIMXRT1189CVM8B_cm33, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, APPL_USE_STANDARD_IO, GATT_CLIENT, GATT_DB, FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0, FSL_OSA_MAIN_FUNC_ENABLE=0, HAL_UART_ADAPTER_FIFO=1, FSL_FEATURE_FLASH_PAGE_SIZE_BYTES=4096, HAL_AUDIO_DMA_INIT_ENABLE=0, HAL_UART_DMA_INIT_ENABLE=0, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, SDK_OS_FREE_RTOS, FSL_OSA_TASK_ENABLE=1, SDIO_ENABLED=1, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING=1, SDK_DEBUGCONSOLE_UART=1, CONFIG_BT_BREDR=1, CONFIG_BT_PERIPHERAL=1, CONFIG_BT_CENTRAL=1, CONFIG_BT_SMP=1, CONFIG_BT_DEVICE_NAME='\"edgefast_hfp\"', OSA_USED=1, SHELL_USE_COMMON_TASK=0, SHELL_TASK_STACK_SIZE=2048, SHELL_TASK_PRIORITY=configMAX_PRIORITIES-2, LPUART_RING_BUFFER_SIZE=1024U, HAL_UART_DMA_ENABLE=1, LFS_NO_INTRINSICS=1, LFS_NO_ERROR=1, CONFIG_ARM=1, EDGEFAST_BT_LITTLEFS_MFLASH, MBEDTLS_CONFIG_FILE='\"ele_s400_mbedtls_config.h\"', MBEDTLS_MCUX_ELE_S400_API, MCUXPRESSO_SDK, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8962_ENABLE, DEBUG_CONSOLE_RX_ENABLE=0, LOG_ENABLE_ASYNC_MODE=1, LOG_MAX_ARGUMENT_COUNT=10, LOG_ENABLE_OVERWRITE=0, CACHE_MODE_WRITE_THROUGH=1, MFLASH_FILE_BASEADDR=14221312, SERIAL_PORT_TYPE_UART=1, LWIP_DNS=1, LWIP_NETIF_HOSTNAME=1, LWIP_IGMP=1, _XOPEN_SOURCE=500
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1189xxxxx_cm33_flexspi_nor.scf
  link misc: as above
