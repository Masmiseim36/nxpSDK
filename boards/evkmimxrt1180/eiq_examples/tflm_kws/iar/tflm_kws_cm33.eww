<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>tflm_kws_cm33</project>
        <configuration>flexspi_nor_hyperram_release</configuration>
      </member>
      <member>
        <project>tflm_kws_cm33</project>
        <configuration>flexspi_nor_hyperram_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_hyperram_release</name>
      <member>
        <project>tflm_kws_cm33</project>
        <configuration>flexspi_nor_hyperram_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_hyperram_debug</name>
      <member>
        <project>tflm_kws_cm33</project>
        <configuration>flexspi_nor_hyperram_debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/tflm_kws_cm33.ewp</path>
  </project>
</workspace>
