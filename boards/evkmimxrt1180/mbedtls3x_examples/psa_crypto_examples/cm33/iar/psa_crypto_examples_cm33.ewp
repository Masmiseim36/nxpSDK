# IAR project psa_crypto_examples_cm33.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1189xxx8_M33 NXP MIMXRT1189xxx8_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=0; CPU_MIMXRT1189CVM8B_cm33; MBEDTLS_CONFIG_FILE="mcux_mbedtls_config.h"; MCUXPRESSO_SDK; PSA_CRYPTO_DRIVER_ELE_S4XX; SERIAL_PORT_TYPE_UART=1; CACHE_MODE_WRITE_THROUGH=1; FSL_FEATURE_SOC_ELE_S4XX
  ICCARM.CCDiagSuppress: Pe546,Pe188,Pe111,Pa084,Pe068,Pe177,Pe223,Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../components/psa_crypto_driver/osal/baremetal; ../../../../../../middleware/mbedtls3x/port; ../../../../../../firmware/edgelock; ../../../../../../middleware/mbedtls3x/include; ../../../../../../middleware/mbedtls3x/library; ../../../../../../devices/MIMXRT1189/drivers; ../../../../../../devices/MIMXRT1189; ../../../../../../devices/MIMXRT1189/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1189/utilities; ../../../../../../devices/MIMXRT1189/xip; ../../../../xip; ../../../../../../devices/MIMXRT1189/drivers/cm33; ../../../../../../components/silicon_id/socs; ../../../../../../components/silicon_id; ../../../../../../components/ele_crypto; ../../../../../../components/psa_crypto_driver/ele_s4xx; ../../../../../../components/psa_crypto_driver/ele_s4xx/include; ../../../../../../components/psa_crypto_driver/ele_s4xx/include/common; ../../../../../../components/psa_crypto_driver/ele_s4xx/include/opaque; ../../../../../../components/psa_crypto_driver/ele_s4xx/include/transparent; ../../../../../../components/psa_crypto_driver/osal; ../../../../../../CMSIS/Core/Include; ../../../../../../devices/MIMXRT1189/utilities/str
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.bin
  ILINK.IlinkOutputFile: psa_crypto_examples_cm33.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x8000
  ILINK.IlinkIcfFile: MIMXRT1189xxxxx_cm33_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=0; NDEBUG; CPU_MIMXRT1189CVM8B_cm33; MBEDTLS_CONFIG_FILE="mcux_mbedtls_config.h"; MCUXPRESSO_SDK; PSA_CRYPTO_DRIVER_ELE_S4XX; SERIAL_PORT_TYPE_UART=1; CACHE_MODE_WRITE_THROUGH=1; FSL_FEATURE_SOC_ELE_S4XX
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: crypto_examples.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group evkmimxrt1180/mbedtls3x_examples/psa_crypto_examples/cm33
    ../: hardware_init.c app.h
  group doc
    ../: readme.md
  group component/psa_crypto_driver/osal
    ../../../../../../components/psa_crypto_driver/osal/: osal_mutex.h
  group component/psa_crypto_driver/osal/baremetal
    ../../../../../../components/psa_crypto_driver/osal/baremetal/: osal_mutex.c osal_mutex_platform.h
  group component/psa_crypto_driver/ele_s4xx
    ../../../../../../components/psa_crypto_driver/ele_s4xx/: ele_s4xx.h ele_fw.h ele_s4xx_crypto_primitives.h ele_s4xx_crypto_primitives.h
  group component/psa_crypto_driver/ele_s4xx/src/common
    ../../../../../../components/psa_crypto_driver/ele_s4xx/src/common/: mcux_psa_s4xx_common_init.c mcux_psa_s4xx_entropy.c mcux_psa_s4xx_common_key_management.c mcux_psa_s4xx_common_key_management.c
  group component/psa_crypto_driver/ele_s4xx/src/opaque
    ../../../../../../components/psa_crypto_driver/ele_s4xx/src/opaque/: mcux_psa_s4xx_opaque_init.c mcux_psa_s4xx_opaque_key_generation.c mcux_psa_s4xx_opaque_asymmetric_signature.c mcux_psa_s4xx_opaque_cipher.c mcux_psa_s4xx_opaque_aead.c mcux_psa_s4xx_opaque_mac.c
  group component/psa_crypto_driver/ele_s4xx/src/transparent
    ../../../../../../components/psa_crypto_driver/ele_s4xx/src/transparent/: mcux_psa_s4xx_init.c mcux_psa_s4xx_key_generation.c mcux_psa_s4xx_hash.c mcux_psa_s4xx_aead.c mcux_psa_s4xx_cipher.c mcux_psa_s4xx_asymmetric_encryption.c mcux_psa_s4xx_asymmetric_signature.c
  group component/psa_crypto_driver/ele_s4xx/include/common
    ../../../../../../components/psa_crypto_driver/ele_s4xx/include/common/: mcux_psa_s4xx_common_init.h mcux_psa_s4xx_entropy.h mcux_psa_s4xx_common_key_management.h mcux_psa_s4xx_common_key_management.h
  group component/psa_crypto_driver/ele_s4xx/include/opaque
    ../../../../../../components/psa_crypto_driver/ele_s4xx/include/opaque/: mcux_psa_s4xx_opaque_init.h mcux_psa_s4xx_opaque_key_generation.h mcux_psa_s4xx_opaque_asymmetric_signature.h mcux_psa_s4xx_opaque_cipher.h mcux_psa_s4xx_opaque_aead.h mcux_psa_s4xx_opaque_mac.h
  group component/psa_crypto_driver/ele_s4xx/include/transparent
    ../../../../../../components/psa_crypto_driver/ele_s4xx/include/transparent/: mcux_psa_s4xx_init.h mcux_psa_s4xx_key_generation.h mcux_psa_s4xx_hash.h mcux_psa_s4xx_aead.h mcux_psa_s4xx_cipher.h mcux_psa_s4xx_asymmetric_encryption.h mcux_psa_s4xx_asymmetric_signature.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/silicon_id
    ../../../../../../components/silicon_id/socs/imxrt1180/: fsl_silicon_id_soc.c
    ../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
    ../../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group component/ele_crypto
    ../../../../../../components/ele_crypto/: ele_crypto.c ele_crypto.h ele_crypto_internal.h
  group mbedtls3x/port
    ../../../../../../middleware/mbedtls3x/port/: mcux_mbedtls_config.h mcux_mbedtls_accelerator_config.h mcux_psa_defines.h mcux_mbedtls_psa_crypto_config.h mcux_mbedtls_accelerator_config.h mcux_psa_defines.h mcux_mbedtls_config.h mcux_mbedtls_accelerator_config.h
  group mbedtls3x/library
    ../../../../../../middleware/mbedtls3x/library/: psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers_no_static.c psa_crypto_ecp.c psa_crypto_ffdh.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_pake.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c aes.c aesni.c aesni.h alignment.h aesce.c aesce.h aria.c asn1parse.c asn1write.c base64.c base64_internal.h bignum.c bignum_core.h bignum_core.c bignum_mod.c bignum_mod.h bignum_mod_raw.c bignum_mod_raw.h bignum_mod_raw_invasive.h block_cipher.c block_cipher_internal.h bn_mul.h camellia.c ccm.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cipher_wrap.h cmac.c common.h constant_time.c constant_time_impl.h constant_time_internal.h ctr_drbg.c ctr.h des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_curves_new.c ecp_internal_alt.h ecp_invasive.h entropy.c entropy_poll.c entropy_poll.h error.c gcm.c hkdf.c hmac_drbg.c lmots.c lmots.h lms.c md.c md_psa.h md_wrap.h md5.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c padlock.h pem.c pk.c pk_ecc.c pk_internal.h pk_wrap.c pk_wrap.h pkcs5.c pkcs12.c pkparse.c pkwrite.c pkwrite.h platform.c platform_util.c poly1305.c psa_crypto_aead.h psa_crypto_cipher.h psa_crypto_core.h psa_crypto_core_common.h psa_crypto_driver_wrappers_no_static.h psa_crypto_driver_wrappers.h psa_crypto_ecp.h psa_crypto_ffdh.h psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.h psa_crypto_pake.h psa_crypto_random_impl.h psa_crypto_rsa.h psa_crypto_se.h psa_crypto_slot_management.h psa_crypto_storage.h psa_util_internal.h psa_util.c ripemd160.c rsa.c rsa_alt_helpers.c rsa_alt_helpers.h rsa_internal.h sha1.c sha3.c sha256.c sha512.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write.c x509write_crt.c x509write_csr.c x509_internal.h pkcs7.c debug.c debug_internal.h mps_common.h mps_error.h mps_reader.c mps_reader.h mps_trace.c mps_trace.h net_sockets.c ssl_cache.c ssl_ciphersuites.c ssl_ciphersuites_internal.h ssl_client.c ssl_client.h ssl_cookie.c ssl_debug_helpers.h ssl_debug_helpers_generated.c ssl_misc.h ssl_msg.c ssl_ticket.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_invasive.h ssl_tls13_keys.c ssl_tls13_keys.h ssl_tls13_server.c
  group mbedtls3x/include/mbedtls
    ../../../../../../middleware/mbedtls3x/include/mbedtls/: aes.h aria.h asn1.h asn1write.h base64.h bignum.h block_cipher.h build_info.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cipher.h cmac.h compat-2.x.h config_adjust_legacy_crypto.h config_adjust_legacy_from_psa.h config_adjust_psa_from_legacy.h config_adjust_psa_superset_legacy.h config_adjust_ssl.h config_adjust_x509.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h error.h gcm.h hkdf.h hmac_drbg.h lms.h mbedtls_config.h md.h md5.h memory_buffer_alloc.h nist_kw.h oid.h pem.h pk.h pkcs5.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h private_access.h psa_util.h ripemd160.h rsa.h sha1.h sha3.h sha256.h sha512.h threading.h timing.h version.h pkcs7.h x509.h x509_crl.h x509_crt.h x509_csr.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_ticket.h net_sockets.h
  group mbedtls3x/include/psa
    ../../../../../../middleware/mbedtls3x/include/psa/: build_info.h crypto.h crypto_adjust_auto_enabled.h crypto_adjust_config_key_pair_types.h crypto_adjust_config_synonyms.h crypto_builtin_composites.h crypto_builtin_key_derivation.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_key_derivation.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_legacy.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group firmware/edgelock
    ../../../../../../firmware/edgelock/: mxrt1180b0-1c00-ahab-container.img mxrt1180b0-ahab-container.img mxrt1180b0alt-1c00-ahab-container.img mxrt1180b0alt-ahab-container.img mxrt1180b0el2goprov-1c00-ahab-container.img mxrt1180b0el2goprov-ahab-container.img mxrt1180b0oemprov-1c00-ahab-container.img mxrt1180b0oemprov-ahab-container.img Readme_rt1180.md SCR.txt
  group drivers
    ../../../../../../devices/MIMXRT1189/drivers/: fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_misc.h fsl_rgpio.h fsl_rgpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_s3mu.c fsl_s3mu.h fsl_ele_base_api.h fsl_ele_base_api.c
    ../../../../../../devices/MIMXRT1189/drivers/cm33/: fsl_cache.c fsl_cache.h
  group device
    ../../../../../../devices/MIMXRT1189/: fsl_device_registers.h MIMXRT1189_cm33.h MIMXRT1189_cm33_features.h system_MIMXRT1189_cm33.c system_MIMXRT1189_cm33.h
  group utilities
    ../../../../../../devices/MIMXRT1189/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1189/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../../devices/MIMXRT1189/utilities/str/: fsl_str.c fsl_str.h
  group startup
    ../../../../../../devices/MIMXRT1189/iar/: startup_MIMXRT1189_cm33.s
  group xip
    ../../../../../../devices/MIMXRT1189/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1180_flexspi_nor_config.c evkmimxrt1180_flexspi_nor_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
