# Keil uVision project mbedtls_selftest_cm33.uvprojx, settings and files
target mbedtls_selftest_cm33 flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1189CVM8C:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: mbedtls_selftest_cm33.out
  AfterMake: fromelf.exe --output "$Lmbedtls_selftest.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=0, MBEDTLS_CONFIG_FILE='\"ele_s400_mbedtls_config.h\"', FREESCALE_KSDK_BM, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8C_cm33, MIMXRT1189_cm33_SERIES, CACHE_MODE_WRITE_THROUGH=1, MBEDTLS_MCUX_ELE_S400_API
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../xip;../../../../../../devices/MIMXRT1189/xip;../../../../../../devices/MIMXRT1189/drivers;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MIMXRT1189;../../../../../../devices/MIMXRT1189/periph;../../../../../../devices/MIMXRT1189/drivers/cm33;../../../../../../devices/MIMXRT1189/utilities/debug_console_lite;../../../../../../devices/MIMXRT1189/utilities/str;../../../../../../components/silicon_id;../../../../../../components/silicon_id/socs;../../../../../../components/uart;../../../../../../components/ele_crypto;../../../../../../middleware/mbedtls/include;../../../../../../middleware/mbedtls/library;../../../../../../middleware/mbedtls/port/ele_s400
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8C_cm33, MIMXRT1189_cm33_SERIES
  asm misc: -include ../mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1189xxxxx_cm33_flexspi_nor.scf
  link misc: --remove --predefine=\"-DXIP_BOOT_HEADER_ENABLE=0\" --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x8000" --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: selftest.c mcux_config.h mcux_config.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group xip
    ../../../../xip/: evkmimxrt1180_flexspi_nor_config.c evkmimxrt1180_flexspi_nor_config.h
    ../../../../../../devices/MIMXRT1189/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group drivers
    ../../../../../../devices/MIMXRT1189/drivers/: fsl_pmu.h fsl_pmu.c fsl_clock.h fsl_clock.c fsl_dcdc.c fsl_dcdc.h fsl_ele_base_api.c fsl_ele_base_api.h fsl_gpc.c fsl_gpc.h fsl_iomuxc.h fsl_memory.c fsl_memory.h fsl_misc.h fsl_soc_src.c fsl_soc_src.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_rgpio.h fsl_rgpio.c fsl_s3mu.c fsl_s3mu.h
    ../../../../../../devices/MIMXRT1189/drivers/cm33/: fsl_cache.c fsl_cache.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv8m_mpu.h
  group device
    ../../../../../../devices/MIMXRT1189/: fsl_device_registers.h MIMXRT1189_cm33.h MIMXRT1189_cm33_COMMON.h MIMXRT1189_cm33_features.h system_MIMXRT1189_cm33.c system_MIMXRT1189_cm33.h
  group device/periph
    ../../../../../../devices/MIMXRT1189/periph/: PERI_ADC.h PERI_ANADIG.h PERI_ANADIG_LDO_BBSM.h PERI_ANADIG_MISC.h PERI_ANADIG_OSC.h PERI_ANADIG_PLL.h PERI_ANADIG_PMU.h PERI_ANADIG_TEMPSENSOR.h PERI_AOI.h PERI_ASRC.h PERI_AXBS.h PERI_BBNSM.h PERI_BLK_CTRL_BBSMMIX.h PERI_BLK_CTRL_NS_AONMIX.h PERI_BLK_CTRL_S_AONMIX.h PERI_BLK_CTRL_WAKEUPMIX.h PERI_CACHE_ECC_MCM.h PERI_CAN.h PERI_CCM.h PERI_CMP.h PERI_DAC.h PERI_DCDC.h PERI_DMA.h PERI_DMA4.h PERI_ECAT.h PERI_EIM.h PERI_ENETC_GLOBAL.h PERI_ENETC_PCI_TYPE0.h PERI_ENETC_PF_EMDIO.h PERI_ENETC_PF_TMR.h PERI_ENETC_SI.h PERI_ENETC_VF_PCI_TYPE0.h PERI_EQDC.h PERI_ERM.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXSPI.h PERI_FLEXSPI_SLV.h PERI_GPC_CPU_CTRL.h PERI_GPC_GLOBAL.h PERI_GPC_SYS_SLEEP_CTRL.h PERI_GPT.h PERI_I2S.h PERI_I3C.h PERI_IEE.h PERI_IEE_APC.h PERI_IERC_IERB.h PERI_IERC_PCI.h PERI_IOMUXC.h PERI_IOMUXC_AON.h PERI_KPP.h PERI_LPI2C.h PERI_LPIT.h PERI_LPSPI.h PERI_LPTMR.h PERI_LPUART.h PERI_M7_MCM.h PERI_MECC.h PERI_MSGINTR.h PERI_MU.h PERI_NETC_ENETC.h PERI_NETC_ETH_LINK.h PERI_NETC_IERB.h PERI_NETC_PORT.h PERI_NETC_PRIV.h PERI_NETC_PSEUDO_LINK.h PERI_NETC_SW.h PERI_NETC_SW_ENETC.h PERI_OCOTP_FSB.h PERI_OSC_RC_400M.h PERI_OTFAD.h PERI_PDM.h PERI_PHY_LDO.h PERI_PLL.h PERI_PWM.h PERI_RGPIO.h PERI_RTWDOG.h PERI_S3MU.h PERI_SEMA42.h PERI_SEMC.h PERI_SINC.h PERI_SPDIF.h PERI_SRC_GENERAL.h PERI_SRC_MIF_LN28FDSOI_SPLLRAM.h PERI_SRC_MIF_S28SPREGH.h PERI_SRC_MIF_S28SPREGH_PSWA.h PERI_SRC_MIX_SLICE.h PERI_SYSPM.h PERI_SYS_CTR_COMPARE.h PERI_SYS_CTR_CONTROL.h PERI_SYS_CTR_READ.h PERI_TCM_ECC_MCM.h PERI_TMPSNS.h PERI_TMR.h PERI_TPM.h PERI_TRDC.h PERI_TSTMR.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_VMBANDGAP.h PERI_VREF.h PERI_XBAR_NUM_OUT221.h PERI_XBAR_NUM_OUT32.h PERI_XCACHE.h
  group startup/arm
    ../../../../../../devices/MIMXRT1189/arm/: startup_MIMXRT1189_cm33.S
  group utilities
    ../../../../../../devices/MIMXRT1189/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
    ../../../../../../devices/MIMXRT1189/utilities/: fsl_memcpy.S
  group utilities/str
    ../../../../../../devices/MIMXRT1189/utilities/str/: fsl_str.h fsl_str.c
  group component/silicon_id
    ../../../../../../components/silicon_id/: fsl_silicon_id.h fsl_silicon_id.c
    ../../../../../../components/silicon_id/socs/imxrt1180/: fsl_silicon_id_soc.c
  group component
    ../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
  group utilities/debug_console_lite
    ../../../../../../devices/MIMXRT1189/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/ele_crypto
    ../../../../../../components/ele_crypto/: ele_crypto.c ele_crypto.h ele_crypto_internal.h
  group mbedtls/include/mbedtls
    ../../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h psa_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/include/psa
    ../../../../../../middleware/mbedtls/include/psa/: crypto.h crypto_builtin_composites.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group mbedtls/library
    ../../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum_internal.h bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cmac.c common.h constant_time.c constant_time_internal.h constant_time_invasive.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_invasive.h entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c mps_common.h mps_error.h mps_reader.c mps_reader.h mps_trace.c mps_trace.h net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c ssl_tls13_keys.h threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/port/ele_s400
    ../../../../../../middleware/mbedtls/port/ele_s400/: ele_mbedtls.c ele_mbedtls.h ele_s400_mbedtls_config.h ele_fw.h ele_entropy.c aes_alt.h aes_alt.c ccm_alt.h ccm_alt.c gcm_alt.h gcm_alt.c rsa_alt.h rsa_alt.c threading_alt.h sha256_alt.c sha256_alt.h sha512_alt.c sha512_alt.h hmac_alt.c
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
target mbedtls_selftest_cm33 flexspi_nor_release (ARM-ADS)
  device: MIMXRT1189CVM8C:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: mbedtls_selftest_cm33.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=0, MBEDTLS_CONFIG_FILE='\"ele_s400_mbedtls_config.h\"', FREESCALE_KSDK_BM, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8C_cm33, MIMXRT1189_cm33_SERIES, CACHE_MODE_WRITE_THROUGH=1, MBEDTLS_MCUX_ELE_S400_API
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1189xxxxx_cm33_flexspi_nor.scf
  link misc: as above
