# IAR project freertos_message_buffers_cm7.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1189xxx8_M7 NXP MIMXRT1189xxx8_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1189CVM8B_cm7; __USE_SHMEM; FLEXSPI_IN_USE; MCUXPRESSO_SDK; MULTICORE_APP=1; SDK_OS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MIMXRT1189/utilities/str; ../../../../../../devices/MIMXRT1189/utilities/debug_console_lite; ../../../../../../devices/MIMXRT1189/drivers; ../../../../../../middleware/multicore/mcmgr/src; ../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F; ../../../../../../devices/MIMXRT1189; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1189/xip; ../../../../xip; ../../../../../../devices/MIMXRT1189/drivers/cm7; ../../../../../../components/silicon_id/socs; ../../../../../../components/silicon_id; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: freertos_message_buffers_cm7.out
  ILINK.IlinkConfigDefines: __use_shmem__=1; __multicore__=1
  ILINK.IlinkIcfFile: MIMXRT1189xxxxx_cm7_ram.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1189CVM8B_cm7; __USE_SHMEM; FLEXSPI_IN_USE; MCUXPRESSO_SDK; MULTICORE_APP=1; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group source
    ../: main_remote.c FreeRTOSConfig.h
  group doc
    ../: readme.md
  group mcmgr
    ../../../../../../middleware/multicore/mcmgr/src/: mcmgr_internal_core_api_imxrt1180.c mcmgr_mu_internal.c mcmgr.h mcmgr_internal_core_api.h mcmgr.c
  group utilities
    ../../../../../../devices/MIMXRT1189/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1189/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../devices/MIMXRT1189/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_misc.h fsl_rgpio.h fsl_rgpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_mu.h fsl_mu.c
    ../../../../../../devices/MIMXRT1189/drivers/cm7/: fsl_cache.c fsl_cache.h
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/IAR/ARM_CM4F
    ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url
  group device
    ../../../../../../devices/MIMXRT1189/: fsl_device_registers.h MIMXRT1189_cm7.h MIMXRT1189_cm7_features.h system_MIMXRT1189_cm7.c system_MIMXRT1189_cm7.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/silicon_id
    ../../../../../../components/silicon_id/socs/imxrt1180/: fsl_silicon_id_soc.c
    ../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
    ../../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group startup
    ../../../../../../devices/MIMXRT1189/iar/: startup_MIMXRT1189_cm7.s
  group xip
    ../../../../../../devices/MIMXRT1189/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1180_flexspi_nor_config.c evkmimxrt1180_flexspi_nor_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
