# Keil uVision project hello_world_cm7.uvprojx, settings and files
target hello_world_cm7 debug (ARM-ADS)
  device: MIMXRT1189CVM8B:cm7 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world_cm7.out
  AfterMake: fromelf.exe --output "$Lcore1_image.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT1189CVM8B_cm7, MCMGR_HANDLE_EXCEPTIONS=1, __SEMIHOST_HARDFAULT_DISABLE=1, FLEXSPI_IN_USE, MCUXPRESSO_SDK, MULTICORE_APP=1
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../../../devices/MIMXRT1189/utilities/debug_console_lite;../../../../../../middleware/multicore/mcmgr/src;../../../../../../devices/MIMXRT1189/drivers;../../../../../../devices/MIMXRT1189;../../../../../../components/uart;../../../../../../components/lists;../../../../../../devices/MIMXRT1189/xip;../../../../xip;../../../../../../devices/MIMXRT1189/drivers/cm7;../../../../../../components/silicon_id/socs;../../../../../../components/silicon_id;../../../../../../devices/MIMXRT1189/utilities/str;../../../../../../CMSIS/Core/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1189xxxxx_cm7_ram.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314 --predefine="-D__multicore__=1"
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group source
    ../: hello_world_core1.c
  group doc
    ../: readme.md
  group mcmgr
    ../../../../../../middleware/multicore/mcmgr/src/: mcmgr_internal_core_api_imxrt1180.c mcmgr_mu_internal.c mcmgr.h mcmgr_internal_core_api.h mcmgr.c
  group utilities
    ../../../../../../devices/MIMXRT1189/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c fsl_assert.h
    ../../../../../../devices/MIMXRT1189/utilities/str/: fsl_str.c fsl_str.h
  group drivers
    ../../../../../../devices/MIMXRT1189/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_iomuxc.h fsl_misc.h fsl_rgpio.h fsl_rgpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_mu.h fsl_mu.c fsl_ele_base_api.h fsl_ele_base_api.c fsl_s3mu.c fsl_s3mu.h
    ../../../../../../devices/MIMXRT1189/drivers/cm7/: fsl_cache.c fsl_cache.h
  group device
    ../../../../../../devices/MIMXRT1189/: fsl_device_registers.h MIMXRT1189_cm7.h MIMXRT1189_cm7_features.h system_MIMXRT1189_cm7.c system_MIMXRT1189_cm7.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMXRT1189/arm/: startup_MIMXRT1189_cm7.S
  group xip
    ../../../../../../devices/MIMXRT1189/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1180_flexspi_nor_config.c evkmimxrt1180_flexspi_nor_config.h
  group component/silicon_id
    ../../../../../../components/silicon_id/socs/imxrt1180/: fsl_silicon_id_soc.c
    ../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
    ../../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
target hello_world_cm7 release (ARM-ADS)
  device: MIMXRT1189CVM8B:cm7 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world_cm7.out
  AfterMake: fromelf.exe --output "$Lcore1_image.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1189CVM8B_cm7, MCMGR_HANDLE_EXCEPTIONS=1, __SEMIHOST_HARDFAULT_DISABLE=1, FLEXSPI_IN_USE, MCUXPRESSO_SDK, MULTICORE_APP=1
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1189xxxxx_cm7_ram.scf
  link misc: as above
