# IAR project rpmsg_lite_pingpong_cm33.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1189xxx8_M33 NXP MIMXRT1189xxx8_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=0; CORE1_IMAGE_COPY_TO_RAM; CPU_MIMXRT1189CVM8B_cm33; __USE_SHMEM; MCUXPRESSO_SDK; SDK_OS_BAREMETAL; MULTICORE_APP=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imxrt1180; ../../../../../../middleware/multicore/rpmsg_lite/lib/include/environment/bm; ../../../../../../middleware/multicore/rpmsg_lite/lib/include; ../../../../../../devices/MIMXRT1189/utilities/str; ../../../../../../devices/MIMXRT1189/utilities/debug_console_lite; ../../../../../../devices/MIMXRT1189/drivers; ../../../../../../middleware/multicore/mcmgr/src; ../../../../../../devices/MIMXRT1189; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1189/xip; ../../../../xip; ../../../../../../devices/MIMXRT1189/drivers/cm33; ../../../../../../components/silicon_id/socs; ../../../../../../components/silicon_id; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.bin
  ILINK.IlinkOutputFile: rpmsg_lite_pingpong_cm33.out
  ILINK.IlinkKeepSymbols: _rpmsg_lite_pingpong_cm7_image
  ILINK.IlinkConfigDefines: __use_shmem__=1; __stack_size__=0x400; __heap_size__=0x2000; __multicore__=1
  ILINK.IlinkIcfFile: MIMXRT1189xxxxx_cm33_flexspi_nor.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=0; NDEBUG; CORE1_IMAGE_COPY_TO_RAM; CPU_MIMXRT1189CVM8B_cm33; __USE_SHMEM; MCUXPRESSO_SDK; SDK_OS_BAREMETAL; MULTICORE_APP=1
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group source
    ../: main_master.c rpmsg_config.h
  group doc
    ../: readme.md
  group mcmgr
    ../../../../../../middleware/multicore/mcmgr/src/: mcmgr_internal_core_api_imxrt1180.c mcmgr_mu_internal.c mcmgr.h mcmgr_internal_core_api.h mcmgr.c
  group rpmsg_lite/include
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_lite.h rpmsg_ns.h llist.h rpmsg_default_config.h virtio_ring.h virtqueue.h rpmsg_compiler.h rpmsg_env.h
  group rpmsg_lite/include/platform/imxrt1180
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imxrt1180/: rpmsg_platform.h
  group rpmsg_lite/include/environment/bm
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/environment/bm/: rpmsg_env_specific.h
  group rpmsg_lite/rpmsg_lite
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c
  group rpmsg_lite/rpmsg_lite/porting/platform/imxrt1180
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/platform/imxrt1180/: rpmsg_platform.c
  group rpmsg_lite/rpmsg_lite/porting/environment
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_bm.c
  group rpmsg_lite/common
    ../../../../../../middleware/multicore/rpmsg_lite/lib/common/: llist.c
  group rpmsg_lite/virtio
    ../../../../../../middleware/multicore/rpmsg_lite/lib/virtio/: virtqueue.c
  group utilities
    ../../../../../../devices/MIMXRT1189/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT1189/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../devices/MIMXRT1189/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_misc.h fsl_rgpio.h fsl_rgpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_mu.h fsl_mu.c
    ../../../../../../devices/MIMXRT1189/drivers/cm33/: fsl_cache.c fsl_cache.h
  group device
    ../../../../../../devices/MIMXRT1189/: fsl_device_registers.h MIMXRT1189_cm33.h MIMXRT1189_cm33_features.h system_MIMXRT1189_cm33.c system_MIMXRT1189_cm33.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/silicon_id
    ../../../../../../components/silicon_id/socs/imxrt1180/: fsl_silicon_id_soc.c
    ../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
    ../../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group startup
    ../../../../../../devices/MIMXRT1189/iar/: startup_MIMXRT1189_cm33.s
  group xip
    ../../../../../../devices/MIMXRT1189/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../xip/: evkmimxrt1180_flexspi_nor_config.c evkmimxrt1180_flexspi_nor_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
