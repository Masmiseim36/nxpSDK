# Keil uVision project erpc_server_matrix_multiply_uart_cm33.uvprojx, settings and files
target erpc_server_matrix_multiply_uart_cm33 debug (ARM-ADS)
  device: MIMXRT1189CVM8C:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: erpc_server_matrix_multiply_uart_cm33.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8C_cm33, MIMXRT1189_cm33_SERIES
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../xip;../../../../../../devices/MIMXRT1189/xip;../../../../../../devices/MIMXRT1189/drivers;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../CMSIS/Driver/Include;../../../../../../devices/MIMXRT1189;../../../../../../devices/MIMXRT1189/periph;../../../../../../devices/MIMXRT1189/drivers/cm33;../../../../../../devices/MIMXRT1189/cmsis_drivers;../../../../../../devices/MIMXRT1189/utilities/debug_console_lite;../../../../../../devices/MIMXRT1189/utilities/str;../../../../../../components/silicon_id;../../../../../../components/silicon_id/socs;../../../../../../components/uart;../../../../../../middleware/multicore/erpc/erpc_c/infra;../../../../../../middleware/multicore/erpc/erpc_c/setup;../../../../../../middleware/multicore/erpc/erpc_c/port;../../../../../../middleware/multicore/erpc/erpc_c/transports;../../../../../../middleware/multicore/erpc/erpc_c/config;../../../../../../middleware/multicore/erpc/examples/MCUXPRESSO_SDK;../../../../../../middleware/multicore/erpc/examples/MCUXPRESSO_SDK/erpc_matrix_multiply/service
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8C_cm33, MIMXRT1189_cm33_SERIES
  asm misc: -include ../mcux_config.h
  asm include: as above
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1189xxxxx_cm33_ram.scf
  link misc: --remove --predefine="-D__stack_size__=0x400" --predefine="-D__heap_size__=0x2000" --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: run_uart.py RTE_Device.h main_server.c erpc_config_gen.h mcux_config.h mcux_config.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group xip
    ../../../../xip/: evkmimxrt1180_flexspi_nor_config.c evkmimxrt1180_flexspi_nor_config.h
    ../../../../../../devices/MIMXRT1189/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group drivers
    ../../../../../../devices/MIMXRT1189/drivers/: fsl_pmu.h fsl_pmu.c fsl_clock.h fsl_clock.c fsl_dcdc.c fsl_dcdc.h fsl_edma_soc.c fsl_edma_soc.h fsl_ele_base_api.c fsl_ele_base_api.h fsl_gpc.c fsl_gpc.h fsl_iomuxc.h fsl_memory.c fsl_memory.h fsl_misc.h fsl_soc_src.c fsl_soc_src.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_edma.h fsl_edma_core.h fsl_edma.c fsl_lpuart_edma.h fsl_lpuart_edma.c fsl_lpuart.h fsl_lpuart.c fsl_rgpio.h fsl_rgpio.c fsl_s3mu.c fsl_s3mu.h
    ../../../../../../devices/MIMXRT1189/drivers/cm33/: fsl_cache.c fsl_cache.h
    ../../../../../../devices/MIMXRT1189/cmsis_drivers/: fsl_lpuart_cmsis.h fsl_lpuart_cmsis.c
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv8m_mpu.h
  group CMSIS_driver/Include
    ../../../../../../CMSIS/Driver/Include/: Driver_USART.h Driver_Common.h
  group device
    ../../../../../../devices/MIMXRT1189/: fsl_device_registers.h MIMXRT1189_cm33.h MIMXRT1189_cm33_COMMON.h MIMXRT1189_cm33_features.h system_MIMXRT1189_cm33.c system_MIMXRT1189_cm33.h
  group device/periph
    ../../../../../../devices/MIMXRT1189/periph/: PERI_ADC.h PERI_ANADIG.h PERI_ANADIG_LDO_BBSM.h PERI_ANADIG_MISC.h PERI_ANADIG_OSC.h PERI_ANADIG_PLL.h PERI_ANADIG_PMU.h PERI_ANADIG_TEMPSENSOR.h PERI_AOI.h PERI_ASRC.h PERI_AXBS.h PERI_BBNSM.h PERI_BLK_CTRL_BBSMMIX.h PERI_BLK_CTRL_NS_AONMIX.h PERI_BLK_CTRL_S_AONMIX.h PERI_BLK_CTRL_WAKEUPMIX.h PERI_CACHE_ECC_MCM.h PERI_CAN.h PERI_CCM.h PERI_CMP.h PERI_DAC.h PERI_DCDC.h PERI_DMA.h PERI_DMA4.h PERI_ECAT.h PERI_EIM.h PERI_ENETC_GLOBAL.h PERI_ENETC_PCI_TYPE0.h PERI_ENETC_PF_EMDIO.h PERI_ENETC_PF_TMR.h PERI_ENETC_SI.h PERI_ENETC_VF_PCI_TYPE0.h PERI_EQDC.h PERI_ERM.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXSPI.h PERI_FLEXSPI_SLV.h PERI_GPC_CPU_CTRL.h PERI_GPC_GLOBAL.h PERI_GPC_SYS_SLEEP_CTRL.h PERI_GPT.h PERI_I2S.h PERI_I3C.h PERI_IEE.h PERI_IEE_APC.h PERI_IERC_IERB.h PERI_IERC_PCI.h PERI_IOMUXC.h PERI_IOMUXC_AON.h PERI_KPP.h PERI_LPI2C.h PERI_LPIT.h PERI_LPSPI.h PERI_LPTMR.h PERI_LPUART.h PERI_M7_MCM.h PERI_MECC.h PERI_MSGINTR.h PERI_MU.h PERI_NETC_ENETC.h PERI_NETC_ETH_LINK.h PERI_NETC_IERB.h PERI_NETC_PORT.h PERI_NETC_PRIV.h PERI_NETC_PSEUDO_LINK.h PERI_NETC_SW.h PERI_NETC_SW_ENETC.h PERI_OCOTP_FSB.h PERI_OSC_RC_400M.h PERI_OTFAD.h PERI_PDM.h PERI_PHY_LDO.h PERI_PLL.h PERI_PWM.h PERI_RGPIO.h PERI_RTWDOG.h PERI_S3MU.h PERI_SEMA42.h PERI_SEMC.h PERI_SINC.h PERI_SPDIF.h PERI_SRC_GENERAL.h PERI_SRC_MIF_LN28FDSOI_SPLLRAM.h PERI_SRC_MIF_S28SPREGH.h PERI_SRC_MIF_S28SPREGH_PSWA.h PERI_SRC_MIX_SLICE.h PERI_SYSPM.h PERI_SYS_CTR_COMPARE.h PERI_SYS_CTR_CONTROL.h PERI_SYS_CTR_READ.h PERI_TCM_ECC_MCM.h PERI_TMPSNS.h PERI_TMR.h PERI_TPM.h PERI_TRDC.h PERI_TSTMR.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_VMBANDGAP.h PERI_VREF.h PERI_XBAR_NUM_OUT221.h PERI_XBAR_NUM_OUT32.h PERI_XCACHE.h
  group startup/arm
    ../../../../../../devices/MIMXRT1189/arm/: startup_MIMXRT1189_cm33.S
  group utilities
    ../../../../../../devices/MIMXRT1189/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
    ../../../../../../devices/MIMXRT1189/utilities/: fsl_memcpy.S
  group utilities/str
    ../../../../../../devices/MIMXRT1189/utilities/str/: fsl_str.h fsl_str.c
  group component/silicon_id
    ../../../../../../components/silicon_id/: fsl_silicon_id.h fsl_silicon_id.c
    ../../../../../../components/silicon_id/socs/imxrt1180/: fsl_silicon_id_soc.c
  group component
    ../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
  group utilities/debug_console_lite
    ../../../../../../devices/MIMXRT1189/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group erpc/erpc/erpc_c/infra
    ../../../../../../middleware/multicore/erpc/erpc_c/infra/: erpc_version.h erpc_codec.hpp erpc_basic_codec.hpp erpc_transport.hpp erpc_message_buffer.hpp erpc_message_loggers.hpp erpc_common.h erpc_manually_constructed.hpp erpc_crc16.hpp erpc_basic_codec.cpp erpc_message_buffer.cpp erpc_message_loggers.cpp erpc_crc16.cpp erpc_client_server_common.hpp erpc_pre_post_action.h erpc_pre_post_action.cpp erpc_utils.hpp erpc_utils.cpp erpc_simple_server.hpp erpc_simple_server.cpp erpc_server.hpp erpc_server.cpp erpc_framed_transport.hpp erpc_framed_transport.cpp
  group erpc/erpc/erpc_c/setup
    ../../../../../../middleware/multicore/erpc/erpc_c/setup/: erpc_transport_setup.h erpc_mbf_setup.h erpc_server_setup.h erpc_server_setup.cpp erpc_setup_mbf_dynamic.cpp erpc_setup_uart_cmsis.cpp
  group erpc/erpc/erpc_c/port
    ../../../../../../middleware/multicore/erpc/erpc_c/port/: erpc_setup_extensions.h erpc_endianness_agnostic_example.h erpc_endianness_undefined.h erpc_config_internal.h erpc_port.h erpc_port_stdlib.cpp
  group erpc/erpc/erpc_c/config
    ../../../../../../middleware/multicore/erpc/erpc_c/config/: erpc_config.h
  group erpc/erpc/erpc_c/transports
    ../../../../../../middleware/multicore/erpc/erpc_c/transports/: erpc_uart_cmsis_transport.hpp erpc_uart_cmsis_transport.cpp
  group erpc/erpc/examples/MCUXPRESSO_SDK
    ../../../../../../middleware/multicore/erpc/examples/MCUXPRESSO_SDK/: erpc_error_handler.h erpc_error_handler.cpp
  group erpc/erpc/examples/MCUXPRESSO_SDK/erpc_matrix_multiply/service
    ../../../../../../middleware/multicore/erpc/examples/MCUXPRESSO_SDK/erpc_matrix_multiply/service/: erpc_matrix_multiply_common.h erpc_matrix_multiply_common.hpp erpc_matrix_multiply_server.hpp erpc_matrix_multiply_server.cpp erpc_matrix_multiply_interface.hpp erpc_matrix_multiply_interface.cpp c_erpc_matrix_multiply_server.h c_erpc_matrix_multiply_server.cpp
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
target erpc_server_matrix_multiply_uart_cm33 hyperram_debug (ARM-ADS)
  device: MIMXRT1189CVM8C:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: erpc_server_matrix_multiply_uart_cm33.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, USE_HYPERRAM=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8C_cm33, MIMXRT1189_cm33_SERIES
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: as above
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1189xxxxx_cm33_hyperram.scf
  link misc: as above
target erpc_server_matrix_multiply_uart_cm33 flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1189CVM8C:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: erpc_server_matrix_multiply_uart_cm33.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=0, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8C_cm33, MIMXRT1189_cm33_SERIES
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: as above
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1189xxxxx_cm33_flexspi_nor.scf
  link misc: --remove --predefine=\"-DXIP_BOOT_HEADER_ENABLE=0\" --predefine="-D__stack_size__=0x400" --predefine="-D__heap_size__=0x2000" --entry=Reset_Handler --info=sizes,totals,unused,veneers
target erpc_server_matrix_multiply_uart_cm33 release (ARM-ADS)
  device: MIMXRT1189CVM8C:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: erpc_server_matrix_multiply_uart_cm33.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8C_cm33, MIMXRT1189_cm33_SERIES
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: as above
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1189xxxxx_cm33_ram.scf
  link misc: as above
target erpc_server_matrix_multiply_uart_cm33 hyperram_release (ARM-ADS)
  device: MIMXRT1189CVM8C:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: erpc_server_matrix_multiply_uart_cm33.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, USE_HYPERRAM=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8C_cm33, MIMXRT1189_cm33_SERIES
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: as above
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1189xxxxx_cm33_hyperram.scf
  link misc: as above
target erpc_server_matrix_multiply_uart_cm33 flexspi_nor_release (ARM-ADS)
  device: MIMXRT1189CVM8C:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: erpc_server_matrix_multiply_uart_cm33.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=0, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8C_cm33, MIMXRT1189_cm33_SERIES
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: as above
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1189xxxxx_cm33_flexspi_nor.scf
  link misc: as above
