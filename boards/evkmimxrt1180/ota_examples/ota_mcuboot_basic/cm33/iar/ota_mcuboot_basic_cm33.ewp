# IAR project ota_mcuboot_basic_cm33.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1189xxx8_M33 NXP MIMXRT1189xxx8_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=0; PRINTF_ADVANCED_ENABLE=1; SHELL_PRINT_COPYRIGHT=0; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1189CVM8C_cm33; MIMXRT1189_cm33_SERIES; SERIAL_PORT_TYPE_UART=1; MFLASH_FILE_BASEADDR=14221312
  ICCARM.IExtraOptions: --diag_suppress=Pe257  --diag_suppress=Pa082,Pa050 --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../xip; ../../../../../../devices/MIMXRT1189/xip; ../../../../../../devices/MIMXRT1189/drivers; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT1189; ../../../../../../devices/MIMXRT1189/periph; ../../../../../../devices/MIMXRT1189/drivers/cm33; ../../../../../../devices/MIMXRT1189/utilities/debug_console; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1189/utilities/str; ../../../../../../components/silicon_id; ../../../../../../components/silicon_id/socs; ../../../../../../devices/MIMXRT1189/utilities/shell; ../../../../../../components/serial_manager; ../../../../../../components/uart; ../../../../../../components/flash/mflash; ../../../../../../components/flash/mflash/mimxrt1180; ../../../../../../middleware/mcuboot_opensource/ext/tinycrypt/lib/include; ../../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/app_support; ../../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/include; ../../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/include/mcuboot_config; ../../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT1189CVM8C_cm33; MIMXRT1189_cm33_SERIES
  AARM.AUserIncludes: as above
  AARM.PreInclude: ../mcux_config.h
  OBJCOPY.OOCOutputFile: ota_mcuboot_basic.bin
  ILINK.IlinkOutputFile: ota_mcuboot_basic_cm33.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x400
  ILINK.IlinkIcfFile: MIMXRT1189xxxxx_cm33_flexspi_nor_mcuboot.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=0; PRINTF_ADVANCED_ENABLE=1; SHELL_PRINT_COPYRIGHT=0; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1189CVM8C_cm33; MIMXRT1189_cm33_SERIES; SERIAL_PORT_TYPE_UART=1; MFLASH_FILE_BASEADDR=14221312
  ICCARM.CCOptLevel: 3
  group source
    ../: ota_mcuboot_basic.c xmodem.c xmodem.h platform_bindings.c platform_bindings.h flash_partitioning.h flash_partitioning.c sblconfig.h fsl_debug_console_conf.h mcux_config.h mcux_config.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group xip
    ../../../../xip/: evkmimxrt1180_flexspi_nor_config.c evkmimxrt1180_flexspi_nor_config.h
    ../../../../../../devices/MIMXRT1189/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group drivers
    ../../../../../../devices/MIMXRT1189/drivers/: fsl_pmu.h fsl_pmu.c fsl_clock.h fsl_clock.c fsl_dcdc.c fsl_dcdc.h fsl_ele_base_api.c fsl_ele_base_api.h fsl_gpc.c fsl_gpc.h fsl_iomuxc.h fsl_memory.c fsl_memory.h fsl_misc.h fsl_soc_src.c fsl_soc_src.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_flexspi.c fsl_flexspi.h fsl_lpuart.h fsl_lpuart.c fsl_rgpio.h fsl_rgpio.c fsl_s3mu.c fsl_s3mu.h
    ../../../../../../devices/MIMXRT1189/drivers/cm33/: fsl_cache.c fsl_cache.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group device
    ../../../../../../devices/MIMXRT1189/: fsl_device_registers.h MIMXRT1189_cm33.h MIMXRT1189_cm33_COMMON.h MIMXRT1189_cm33_features.h system_MIMXRT1189_cm33.c system_MIMXRT1189_cm33.h
  group device/periph
    ../../../../../../devices/MIMXRT1189/periph/: PERI_ADC.h PERI_ANADIG.h PERI_ANADIG_LDO_BBSM.h PERI_ANADIG_MISC.h PERI_ANADIG_OSC.h PERI_ANADIG_PLL.h PERI_ANADIG_PMU.h PERI_ANADIG_TEMPSENSOR.h PERI_AOI.h PERI_ASRC.h PERI_AXBS.h PERI_BBNSM.h PERI_BLK_CTRL_BBSMMIX.h PERI_BLK_CTRL_NS_AONMIX.h PERI_BLK_CTRL_S_AONMIX.h PERI_BLK_CTRL_WAKEUPMIX.h PERI_CACHE_ECC_MCM.h PERI_CAN.h PERI_CCM.h PERI_CMP.h PERI_DAC.h PERI_DCDC.h PERI_DMA.h PERI_DMA4.h PERI_ECAT.h PERI_EIM.h PERI_ENETC_GLOBAL.h PERI_ENETC_PCI_TYPE0.h PERI_ENETC_PF_EMDIO.h PERI_ENETC_PF_TMR.h PERI_ENETC_SI.h PERI_ENETC_VF_PCI_TYPE0.h PERI_EQDC.h PERI_ERM.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXSPI.h PERI_FLEXSPI_SLV.h PERI_GPC_CPU_CTRL.h PERI_GPC_GLOBAL.h PERI_GPC_SYS_SLEEP_CTRL.h PERI_GPT.h PERI_I2S.h PERI_I3C.h PERI_IEE.h PERI_IEE_APC.h PERI_IERC_IERB.h PERI_IERC_PCI.h PERI_IOMUXC.h PERI_IOMUXC_AON.h PERI_KPP.h PERI_LPI2C.h PERI_LPIT.h PERI_LPSPI.h PERI_LPTMR.h PERI_LPUART.h PERI_M7_MCM.h PERI_MECC.h PERI_MSGINTR.h PERI_MU.h PERI_NETC_ENETC.h PERI_NETC_ETH_LINK.h PERI_NETC_IERB.h PERI_NETC_PORT.h PERI_NETC_PRIV.h PERI_NETC_PSEUDO_LINK.h PERI_NETC_SW.h PERI_NETC_SW_ENETC.h PERI_OCOTP_FSB.h PERI_OSC_RC_400M.h PERI_OTFAD.h PERI_PDM.h PERI_PHY_LDO.h PERI_PLL.h PERI_PWM.h PERI_RGPIO.h PERI_RTWDOG.h PERI_S3MU.h PERI_SEMA42.h PERI_SEMC.h PERI_SINC.h PERI_SPDIF.h PERI_SRC_GENERAL.h PERI_SRC_MIF_LN28FDSOI_SPLLRAM.h PERI_SRC_MIF_S28SPREGH.h PERI_SRC_MIF_S28SPREGH_PSWA.h PERI_SRC_MIX_SLICE.h PERI_SYSPM.h PERI_SYS_CTR_COMPARE.h PERI_SYS_CTR_CONTROL.h PERI_SYS_CTR_READ.h PERI_TCM_ECC_MCM.h PERI_TMPSNS.h PERI_TMR.h PERI_TPM.h PERI_TRDC.h PERI_TSTMR.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_VMBANDGAP.h PERI_VREF.h PERI_XBAR_NUM_OUT221.h PERI_XBAR_NUM_OUT32.h PERI_XCACHE.h
  group startup/iar
    ../../../../../../devices/MIMXRT1189/iar/: startup_MIMXRT1189_cm33.s
  group utilities
    ../../../../../../devices/MIMXRT1189/utilities/debug_console/: fsl_assert.h fsl_assert.c
    ../../../../../../devices/MIMXRT1189/utilities/shell/: fsl_shell.h fsl_shell.c
  group utilities/str
    ../../../../../../devices/MIMXRT1189/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console
    ../../../../../../devices/MIMXRT1189/utilities/debug_console/: fsl_debug_console.h fsl_debug_console.c
  group component
    ../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/silicon_id
    ../../../../../../components/silicon_id/: fsl_silicon_id.h fsl_silicon_id.c
    ../../../../../../components/silicon_id/socs/imxrt1180/: fsl_silicon_id_soc.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group flash/mflash
    ../../../../../../components/flash/mflash/: mflash_common.h mflash_file.c mflash_file.h
  group flash/mflash/mimxrt1180
    ../../../../../../components/flash/mflash/mimxrt1180/: mflash_drv.c mflash_drv.h
  group tinycrypt/include/tinycrypt
    ../../../../../../middleware/mcuboot_opensource/ext/tinycrypt/lib/include/tinycrypt/: aes.h cbc_mode.h ccm_mode.h cmac_mode.h constants.h ctr_mode.h ctr_prng.h ecc.h ecc_dsa.h hmac.h hmac_prng.h sha256.h utils.h ecc_platform_specific.h
  group tinycrypt/source
    ../../../../../../middleware/mcuboot_opensource/ext/tinycrypt/lib/source/: aes_decrypt.c aes_encrypt.c cbc_mode.c ccm_mode.c cmac_mode.c ctr_mode.c ctr_prng.c ecc.c ecc_dsa.c hmac.c hmac_prng.c sha256.c utils.c
  group bootutil/app_support/app_support
    ../../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/app_support/: mcuboot_app_support.c mcuboot_app_support.h
  group bootutil/app_support/include
    ../../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/include/: flash_map.h
  group bootutil/app_support/include/mcuboot_config
    ../../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/include/mcuboot_config/: mcuboot_config.h
  group bootutil/app_support/include/sysflash
    ../../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/include/sysflash/: sysflash.h
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
