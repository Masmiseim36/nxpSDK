# IAR project soem_servo_motor_bm_cm33.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1189xxx8_M33 NXP MIMXRT1189xxx8_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=0; CPU_MIMXRT1189CVM8B_cm33; SDK_DEBUGCONSOLE_UART; SERIAL_PORT_TYPE_UART=1; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK; SDK_OS_BAREMETAL
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pa039,Pe111
  ICCARM.CCIncludePath2: ../../../../../../../middleware/soem/osal/baremetal; ..; ../../../../../../../platform/drivers/netc/socs/imxrt1180; ../../../../../../../devices/MIMXRT1189/drivers; ../../../../../../../components/phy/device/phyrtl8211f; ../../../../../../../components/phy/device/phyrtl8201; ../../../../../../../middleware/soem/oshw/mcux-sdk; ../../../../../../../middleware/soem/oshw/mcux-sdk/netc_ep; ../../../../../../../middleware/soem/soem; ../../../../../../../middleware/soem/osal; ../../../../../../../devices/MIMXRT1189; ../../../../../../../devices/MIMXRT1189/utilities/debug_console; ../../../../../../../components/uart; ../../../../../../../components/serial_manager; ../../../../../../../components/lists; ../../../../../../../devices/MIMXRT1189/utilities; ../../../../../../../devices/MIMXRT1189/xip; ../../../../../xip; ../../../../../../../devices/MIMXRT1189/drivers/cm33; ../../../../../../../components/silicon_id/socs; ../../../../../../../components/silicon_id; ../../../../../../../components/phy; ../../../../../../../CMSIS/Core/Include; ../../../../../../../devices/MIMXRT1189/utilities/str
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: soem_servo_motor_bm.bin
  ILINK.IlinkOutputFile: soem_servo_motor_bm_cm33.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x10000
  ILINK.IlinkIcfFile: MIMXRT1189xxxxx_cm33_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1189CVM8B_cm33; SDK_DEBUGCONSOLE_UART; SERIAL_PORT_TYPE_UART=1; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK; SDK_OS_BAREMETAL
  ICCARM.CCOptLevel: 0
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.bin
  ILINK.IlinkIcfFile: MIMXRT1189xxxxx_cm33_ram.icf
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=0; NDEBUG; CPU_MIMXRT1189CVM8B_cm33; SDK_DEBUGCONSOLE_UART; SERIAL_PORT_TYPE_UART=1; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK; SDK_OS_BAREMETAL
  ICCARM.CCOptLevel: 0
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source
    ../: soem_servo_motor.c axis_nc.c axis_nc.h cia402.c cia402.h servo.c servo.h
  group doc
    ../: readme.md
  group drivers
    ../../../../../../../devices/MIMXRT1189/drivers/: fsl_msgintr.h fsl_msgintr.c fsl_gpt.c fsl_gpt.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_misc.h fsl_rgpio.h fsl_rgpio.c fsl_pmu.h fsl_pmu.c fsl_dcdc.h fsl_dcdc.c fsl_memory.h fsl_ele_base_api.h fsl_ele_base_api.c fsl_s3mu.c fsl_s3mu.h
    ../../../../../../../devices/MIMXRT1189/drivers/cm33/: fsl_cache.c fsl_cache.h
  group drivers/netc
    ../../../../../../../platform/drivers/netc/socs/imxrt1180/: fsl_netc_soc.c fsl_netc_soc.h
    ../../../../../../../devices/MIMXRT1189/drivers/: fsl_netc.h fsl_netc_ierb.h fsl_netc_ierb.c fsl_netc_timer.h fsl_netc_timer.c fsl_netc_mdio.h fsl_netc_mdio.c fsl_netc_endpoint.h fsl_netc_endpoint.c fsl_netc_switch.h fsl_netc_switch.c
  group drivers/netc/netc_hw
    ../../../../../../../devices/MIMXRT1189/drivers/netc_hw/: fsl_netc_hw.h fsl_netc_hw.c fsl_netc_hw_port.c fsl_netc_hw_port.h fsl_netc_hw_si.c fsl_netc_hw_si.h fsl_netc_hw_enetc.c fsl_netc_hw_enetc.h
  group component/phy
    ../../../../../../../components/phy/device/phyrtl8211f/: fsl_phyrtl8211f.h fsl_phyrtl8211f.c
    ../../../../../../../components/phy/device/phyrtl8201/: fsl_phyrtl8201.h fsl_phyrtl8201.c
    ../../../../../../../components/phy/: fsl_phy.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/silicon_id
    ../../../../../../../components/silicon_id/socs/imxrt1180/: fsl_silicon_id_soc.c
    ../../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
    ../../../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group soem/oshw/mcux-sdk
    ../../../../../../../middleware/soem/oshw/mcux-sdk/: nicdrv.c nicdrv.h oshw.c oshw.h soem_port.c soem_port.h
  group soem/oshw/mcux-sdk/netc_ep
    ../../../../../../../middleware/soem/oshw/mcux-sdk/netc_ep/: soem_netc_ep.h netc_ep.c netc_ep.h
  group soem/soem
    ../../../../../../../middleware/soem/soem/: ethercat.h ethercatbase.c ethercatbase.h ethercatcoe.c ethercatcoe.h ethercatconfig.c ethercatconfig.h ethercatconfiglist.h ethercatdc.c ethercatdc.h ethercateoe.c ethercateoe.h ethercatfoe.c ethercatfoe.h ethercatmain.c ethercatmain.h ethercatprint.c ethercatprint.h ethercatsoe.c ethercatsoe.h ethercattype.h
  group soem/osal
    ../../../../../../../middleware/soem/osal/: osal.h
  group soem/osal/baremetal
    ../../../../../../../middleware/soem/osal/baremetal/: osal.c osal_defs.h
  group device
    ../../../../../../../devices/MIMXRT1189/: fsl_device_registers.h MIMXRT1189_cm33.h MIMXRT1189_cm33_features.h system_MIMXRT1189_cm33.c system_MIMXRT1189_cm33.h
  group utilities
    ../../../../../../../devices/MIMXRT1189/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/MIMXRT1189/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../../../devices/MIMXRT1189/utilities/str/: fsl_str.c fsl_str.h
  group startup
    ../../../../../../../devices/MIMXRT1189/iar/: startup_MIMXRT1189_cm33.s
  group xip
    ../../../../../../../devices/MIMXRT1189/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../../xip/: evkmimxrt1180_flexspi_nor_config.c evkmimxrt1180_flexspi_nor_config.h
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
