<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>soem_servo_motor_cm33</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
      <member>
        <project>soem_servo_motor_cm33</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>soem_servo_motor_cm33</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_debug</name>
      <member>
        <project>soem_servo_motor_cm33</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>soem_servo_motor_cm33</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_release</name>
      <member>
        <project>soem_servo_motor_cm33</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/soem_servo_motor_cm33.ewp</path>
  </project>
</workspace>
