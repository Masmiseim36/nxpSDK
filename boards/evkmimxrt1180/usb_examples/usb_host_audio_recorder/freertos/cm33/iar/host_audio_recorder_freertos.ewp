# IAR project host_audio_recorder_freertos.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1189xxx8_M33 NXP MIMXRT1189xxx8_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; _DEBUG=1; CPU_MIMXRT1189CVM8B_cm33; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; USB_AUDIO_RECORDER_SDCARD_BUFFER_LENGTH=3072; USB_AUDIO_RECORDER_SDCARD_WRITE_LENGTH=1024; USB_STACK_FREERTOS; DATA_SECTION_IS_CACHEABLE=0; USB_STACK_FREERTOS_HEAP_SIZE=32768; configAPPLICATION_ALLOCATED_HEAP=1; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; SD_ENABLED; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../..; ../../../../../../../middleware/usb/example/boards/evkmimxrt1180/usb_host_audio_recorder/freertos/cm33; ../../../../../../../middleware/usb/example/boards/evkmimxrt1180/usb_host_audio_recorder/freertos; ../../../../../../../components/gpio; ../../../../../../../devices/MIMXRT1189/drivers; ../../../../../../../middleware/fatfs/source/fsl_sd_disk; ../../../../../../../middleware/fatfs/source; ../../../../../../../middleware/sdmmc/host/usdhc; ../../../../../../../middleware/sdmmc/sd; ../../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../../middleware/usb/host/class; ../../../../../../../components/lists; ../../../../../../../components/uart; ../../../../../../../components/serial_manager; ../../../../../../../components/silicon_id/socs; ../../../../../../../components/silicon_id; ../../../../../../../devices/MIMXRT1189; ../../../../../../../devices/MIMXRT1189/drivers/cm33; ../../../../../xip; ../../../../../../../devices/MIMXRT1189/xip; ../../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../../../middleware/usb/host; ../../../../../../../middleware/usb/include; ../../../../../../../middleware/usb/phy; ../../../../../../../devices/MIMXRT1189/utilities/str; ../../../../../../../devices/MIMXRT1189/utilities/debug_console; ../../../../../../../middleware/sdmmc/common; ../../../../../../../middleware/sdmmc/osa; ../../../../../../../components/osa; ../../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../..; ../../../../..
  OBJCOPY.OOCOutputFile: cm33_image.bin
  ILINK.IlinkOutputFile: host_audio_recorder_freertos.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000; __heap_noncacheable__=1
  ILINK.IlinkIcfFile: MIMXRT1189xxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=0; CPU_MIMXRT1189CVM8B_cm33; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; USB_AUDIO_RECORDER_SDCARD_BUFFER_LENGTH=3072; USB_AUDIO_RECORDER_SDCARD_WRITE_LENGTH=1024; USB_STACK_FREERTOS; DATA_SECTION_IS_CACHEABLE=0; USB_STACK_FREERTOS_HEAP_SIZE=32768; configAPPLICATION_ALLOCATED_HEAP=1; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; SD_ENABLED; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1189xxxxx_cm33_flexspi_nor.icf
configuration hyperram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HYPERRAM; DEBUG; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; CPU_MIMXRT1189CVM8B_cm33; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; USB_AUDIO_RECORDER_SDCARD_BUFFER_LENGTH=3072; USB_AUDIO_RECORDER_SDCARD_WRITE_LENGTH=1024; USB_STACK_FREERTOS; USB_STACK_FREERTOS_HEAP_SIZE=32768; configAPPLICATION_ALLOCATED_HEAP=1; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; DATA_SECTION_IS_CACHEABLE=1; SD_ENABLED; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1189xxxxx_cm33_hyperram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; _DEBUG=0; CPU_MIMXRT1189CVM8B_cm33; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; USB_AUDIO_RECORDER_SDCARD_BUFFER_LENGTH=3072; USB_AUDIO_RECORDER_SDCARD_WRITE_LENGTH=1024; USB_STACK_FREERTOS; DATA_SECTION_IS_CACHEABLE=0; USB_STACK_FREERTOS_HEAP_SIZE=32768; configAPPLICATION_ALLOCATED_HEAP=1; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; SD_ENABLED; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=0; NDEBUG; CPU_MIMXRT1189CVM8B_cm33; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; USB_AUDIO_RECORDER_SDCARD_BUFFER_LENGTH=3072; USB_AUDIO_RECORDER_SDCARD_WRITE_LENGTH=1024; USB_STACK_FREERTOS; DATA_SECTION_IS_CACHEABLE=0; USB_STACK_FREERTOS_HEAP_SIZE=32768; configAPPLICATION_ALLOCATED_HEAP=1; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; SD_ENABLED; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1189xxxxx_cm33_flexspi_nor.icf
configuration hyperram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_HYPERRAM; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; CPU_MIMXRT1189CVM8B_cm33; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; USB_AUDIO_RECORDER_SDCARD_BUFFER_LENGTH=3072; USB_AUDIO_RECORDER_SDCARD_WRITE_LENGTH=1024; USB_STACK_FREERTOS; USB_STACK_FREERTOS_HEAP_SIZE=32768; configAPPLICATION_ALLOCATED_HEAP=1; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; DATA_SECTION_IS_CACHEABLE=1; SD_ENABLED; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1189xxxxx_cm33_hyperram.icf
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h sdmmc_config.c sdmmc_config.h
  group source
    ../: app.h app.c audio_recorder.c audio_recorder.h ffconf.h usb_host_config.h FreeRTOSConfig.h
  group doc
    ../: readme.txt
  group component/gpio
    ../../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_rgpio.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/silicon_id
    ../../../../../../../components/silicon_id/socs/imxrt1180/: fsl_silicon_id_soc.c
    ../../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
    ../../../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group component/osa
    ../../../../../../../components/osa/: fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c
  group drivers
    ../../../../../../../devices/MIMXRT1189/drivers/: fsl_usdhc.c fsl_usdhc.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_dcdc.h fsl_dcdc.c fsl_iomuxc.h fsl_lpuart.h fsl_lpuart.c fsl_memory.h fsl_misc.h fsl_pmu.h fsl_pmu.c fsl_rgpio.h fsl_rgpio.c
    ../../../../../../../devices/MIMXRT1189/drivers/cm33/: fsl_cache.c fsl_cache.h
  group fatfs/source
    ../../../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_sd_disk
    ../../../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group sdmmc/host
    ../../../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
    ../../../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt ChangeLogKSDK.txt
  group sdmmc/src
    ../../../../../../../middleware/sdmmc/sd/: fsl_sd.c
    ../../../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../../../middleware/sdmmc/sd/: fsl_sd.h
    ../../../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sd
    ../../../../../../../middleware/sdmmc/sd/: ChangeLogKSDK.txt
  group sdmmc/osa
    ../../../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group freertos/freertos-kernel
    ../../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable
    ../../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group usb/host
    ../../../../../../../middleware/usb/host/: usb_host_ehci.c usb_host_ehci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c usb_host.h usb_host_hci.h usb_host_devices.h usb_host_framework.h
  group usb/host/class
    ../../../../../../../middleware/usb/host/class/: usb_host_audio.c usb_host_audio.h usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h
  group usb/phy
    ../../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group usb/include
    ../../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group device
    ../../../../../../../devices/MIMXRT1189/: fsl_device_registers.h MIMXRT1189_cm33.h MIMXRT1189_cm33_features.h system_MIMXRT1189_cm33.c system_MIMXRT1189_cm33.h
  group startup
    ../../../../../../../devices/MIMXRT1189/iar/: startup_MIMXRT1189_cm33.s
  group xip
    ../../../../../xip/: evkmimxrt1180_flexspi_nor_config.c evkmimxrt1180_flexspi_nor_config.h
    ../../../../../../../devices/MIMXRT1189/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
  group utilities
    ../../../../../../../devices/MIMXRT1189/utilities/: fsl_assert.c
    ../../../../../../../devices/MIMXRT1189/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MIMXRT1189/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
