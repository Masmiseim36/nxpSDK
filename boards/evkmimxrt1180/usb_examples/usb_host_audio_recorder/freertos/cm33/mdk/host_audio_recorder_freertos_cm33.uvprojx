# Keil uVision project host_audio_recorder_freertos_cm33.uvprojx, settings and files
target host_audio_recorder_freertos_cm33 debug (ARM-ADS)
  device: MIMXRT1189CVM8C:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: host_audio_recorder_freertos_cm33.out
  AfterMake: fromelf.exe --output "$Lhost_audio_recorder_freertos.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, USB_AUDIO_RECORDER_SDCARD_BUFFER_LENGTH=3072, USB_AUDIO_RECORDER_SDCARD_WRITE_LENGTH=1024, USB_STACK_FREERTOS, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8C_cm33, MIMXRT1189_cm33_SERIES, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, SERIAL_PORT_TYPE_UART=1, USE_RTOS=1, SD_ENABLED=1, SDK_OS_FREE_RTOS
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../../xip;../../../../../../../devices/MIMXRT1189/xip;../../../../../../../devices/MIMXRT1189/drivers;../../../../../../../CMSIS/Core/Include;../../../../../../../CMSIS/Core/Include/m-profile;../../../../../../../devices/MIMXRT1189;../../../../../../../devices/MIMXRT1189/periph;../../../../../../../devices/MIMXRT1189/drivers/cm33;../../../../../../../devices/MIMXRT1189/utilities/debug_console;../../../../../../../components/lists;../../../../../../../devices/MIMXRT1189/utilities/str;../../../../../../../components/silicon_id;../../../../../../../components/silicon_id/socs;../../../../../../../components/serial_manager;../../../../../../../components/gpio;../../../../../../../components/uart;../../../../../../../components/osa;../../../../../../../middleware/usb/include;../../../../../../../middleware/usb/host;../../../../../../../middleware/usb/config/host/ehci;../../../../../../../middleware/usb/host/class;../../../../../../../middleware/usb/phy;../../../../../../../middleware/fatfs/source;../../../../../../../middleware/fatfs/template;../../../../../../../middleware/fatfs/source/fsl_sd_disk;../../../../../../../middleware/sdmmc/common;../../../../../../../middleware/sdmmc/osa;../../../../../../../middleware/sdmmc/sd;../../../../../../../middleware/sdmmc/host/usdhc;../../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure;../../../../../../../rtos/freertos/freertos-kernel/template
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8C_cm33, MIMXRT1189_cm33_SERIES, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING
  asm misc: -include ../mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1189xxxxx_cm33_ram.scf
  link misc: --remove --predefine=\"-D__heap_noncacheable__=1\" --predefine=\"-D__heap_size__=0x2000\" --predefine=\"-D__stack_size__=0x2000\" --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: app.c app.h audio_recorder.c audio_recorder.h sdmmc_config.c sdmmc_config.h hardware_init.c pin_mux.c pin_mux.h FreeRTOSConfig_Gen.h ffconf_gen.h fsl_debug_console_conf.h fsl_os_abstraction_config.h mcux_config.h mcux_config.h mcux_config.h usb_host_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c
  group xip
    ../../../../../xip/: evkmimxrt1180_flexspi_nor_config.c evkmimxrt1180_flexspi_nor_config.h
    ../../../../../../../devices/MIMXRT1189/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group drivers
    ../../../../../../../devices/MIMXRT1189/drivers/: fsl_pmu.h fsl_pmu.c fsl_clock.h fsl_clock.c fsl_dcdc.c fsl_dcdc.h fsl_ele_base_api.c fsl_ele_base_api.h fsl_gpc.c fsl_gpc.h fsl_iomuxc.h fsl_memory.c fsl_memory.h fsl_misc.h fsl_soc_src.c fsl_soc_src.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_rgpio.h fsl_rgpio.c fsl_s3mu.c fsl_s3mu.h fsl_usdhc.c fsl_usdhc.h
    ../../../../../../../devices/MIMXRT1189/drivers/cm33/: fsl_cache.c fsl_cache.h
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv8m_mpu.h
  group device
    ../../../../../../../devices/MIMXRT1189/: fsl_device_registers.h MIMXRT1189_cm33.h MIMXRT1189_cm33_COMMON.h MIMXRT1189_cm33_features.h system_MIMXRT1189_cm33.c system_MIMXRT1189_cm33.h
  group device/periph
    ../../../../../../../devices/MIMXRT1189/periph/: PERI_ADC.h PERI_ANADIG.h PERI_ANADIG_LDO_BBSM.h PERI_ANADIG_MISC.h PERI_ANADIG_OSC.h PERI_ANADIG_PLL.h PERI_ANADIG_PMU.h PERI_ANADIG_TEMPSENSOR.h PERI_AOI.h PERI_ASRC.h PERI_AXBS.h PERI_BBNSM.h PERI_BLK_CTRL_BBSMMIX.h PERI_BLK_CTRL_NS_AONMIX.h PERI_BLK_CTRL_S_AONMIX.h PERI_BLK_CTRL_WAKEUPMIX.h PERI_CACHE_ECC_MCM.h PERI_CAN.h PERI_CCM.h PERI_CMP.h PERI_DAC.h PERI_DCDC.h PERI_DMA.h PERI_DMA4.h PERI_ECAT.h PERI_EIM.h PERI_ENETC_GLOBAL.h PERI_ENETC_PCI_TYPE0.h PERI_ENETC_PF_EMDIO.h PERI_ENETC_PF_TMR.h PERI_ENETC_SI.h PERI_ENETC_VF_PCI_TYPE0.h PERI_EQDC.h PERI_ERM.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXSPI.h PERI_FLEXSPI_SLV.h PERI_GPC_CPU_CTRL.h PERI_GPC_GLOBAL.h PERI_GPC_SYS_SLEEP_CTRL.h PERI_GPT.h PERI_I2S.h PERI_I3C.h PERI_IEE.h PERI_IEE_APC.h PERI_IERC_IERB.h PERI_IERC_PCI.h PERI_IOMUXC.h PERI_IOMUXC_AON.h PERI_KPP.h PERI_LPI2C.h PERI_LPIT.h PERI_LPSPI.h PERI_LPTMR.h PERI_LPUART.h PERI_M7_MCM.h PERI_MECC.h PERI_MSGINTR.h PERI_MU.h PERI_NETC_ENETC.h PERI_NETC_ETH_LINK.h PERI_NETC_IERB.h PERI_NETC_PORT.h PERI_NETC_PRIV.h PERI_NETC_PSEUDO_LINK.h PERI_NETC_SW.h PERI_NETC_SW_ENETC.h PERI_OCOTP_FSB.h PERI_OSC_RC_400M.h PERI_OTFAD.h PERI_PDM.h PERI_PHY_LDO.h PERI_PLL.h PERI_PWM.h PERI_RGPIO.h PERI_RTWDOG.h PERI_S3MU.h PERI_SEMA42.h PERI_SEMC.h PERI_SINC.h PERI_SPDIF.h PERI_SRC_GENERAL.h PERI_SRC_MIF_LN28FDSOI_SPLLRAM.h PERI_SRC_MIF_S28SPREGH.h PERI_SRC_MIF_S28SPREGH_PSWA.h PERI_SRC_MIX_SLICE.h PERI_SYSPM.h PERI_SYS_CTR_COMPARE.h PERI_SYS_CTR_CONTROL.h PERI_SYS_CTR_READ.h PERI_TCM_ECC_MCM.h PERI_TMPSNS.h PERI_TMR.h PERI_TPM.h PERI_TRDC.h PERI_TSTMR.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_VMBANDGAP.h PERI_VREF.h PERI_XBAR_NUM_OUT221.h PERI_XBAR_NUM_OUT32.h PERI_XCACHE.h
  group startup/arm
    ../../../../../../../devices/MIMXRT1189/arm/: startup_MIMXRT1189_cm33.S
  group utilities
    ../../../../../../../devices/MIMXRT1189/utilities/debug_console/: fsl_assert.h fsl_assert.c
    ../../../../../../../devices/MIMXRT1189/utilities/: fsl_memcpy.S
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group utilities/str
    ../../../../../../../devices/MIMXRT1189/utilities/str/: fsl_str.h fsl_str.c
  group component/silicon_id
    ../../../../../../../components/silicon_id/: fsl_silicon_id.h fsl_silicon_id.c
    ../../../../../../../components/silicon_id/socs/imxrt1180/: fsl_silicon_id_soc.c
  group component
    ../../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
  group utilities/debug_console
    ../../../../../../../devices/MIMXRT1189/utilities/debug_console/: fsl_debug_console.h fsl_debug_console.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/gpio
    ../../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_rgpio.c
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/osa
    ../../../../../../../components/osa/: fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h
  group usb/include
    ../../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group usb/host
    ../../../../../../../middleware/usb/host/: usb_host.h usb_host_hci.h usb_host_devices.h usb_host_framework.h usb_host_ehci.c usb_host_ehci.h usb_host_hci.c usb_host_devices.c usb_host_framework.c
  group usb/host/class
    ../../../../../../../middleware/usb/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_audio.c usb_host_audio.h
  group usb/phy
    ../../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group fatfs/source
    ../../../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group source/template
    ../../../../../../../middleware/fatfs/template/: ffconf.h
  group fatfs/source/fsl_sd_disk
    ../../../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group sdmmc/common
    ../../../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h fsl_sdmmc_common.c
  group sdmmc/osa
    ../../../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group sdmmc/sd
    ../../../../../../../middleware/sdmmc/sd/: fsl_sd.c fsl_sd.h
  group sdmmc/host/usdhc
    ../../../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h fsl_sdmmc_host.h
  group sdmmc/host/usdhc/blocking
    ../../../../../../../middleware/sdmmc/host/usdhc/blocking/: fsl_sdmmc_host.c
  group freertos/freertos-kernel
    ../../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable
    ../../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure
    ../../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.c port.c portasm.c portasm.h portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/template
    ../../../../../../../rtos/freertos/freertos-kernel/template/: FreeRTOSConfig.h
  group doc
    ../: readme.md examples_shared_readme.md audio_10_microphone.jpg audio_20_microphone.jpg device_manager.jpg open_uart.jpg PCM2WAV.jpg sdcard_insert.jpg
target host_audio_recorder_freertos_cm33 hyperram_debug (ARM-ADS)
  device: MIMXRT1189CVM8C:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: host_audio_recorder_freertos_cm33.out
  AfterMake: as above
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, USB_HOST_CONFIG_BUFFER_PROPERTY_CACHEABLE=1, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, USE_HYPERRAM=1, USB_AUDIO_RECORDER_SDCARD_BUFFER_LENGTH=3072, USB_AUDIO_RECORDER_SDCARD_WRITE_LENGTH=1024, USB_STACK_FREERTOS, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8C_cm33, MIMXRT1189_cm33_SERIES, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, SERIAL_PORT_TYPE_UART=1, USE_RTOS=1, SD_ENABLED=1, SDK_OS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1189xxxxx_cm33_hyperram.scf
  link misc: --remove --predefine=\"-D__heap_size__=0x2000\" --predefine=\"-D__stack_size__=0x2000\" --entry=Reset_Handler --info=sizes,totals,unused,veneers
target host_audio_recorder_freertos_cm33 flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1189CVM8C:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: host_audio_recorder_freertos_cm33.out
  AfterMake: as above
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=0, USB_AUDIO_RECORDER_SDCARD_BUFFER_LENGTH=3072, USB_AUDIO_RECORDER_SDCARD_WRITE_LENGTH=1024, USB_STACK_FREERTOS, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8C_cm33, MIMXRT1189_cm33_SERIES, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, SERIAL_PORT_TYPE_UART=1, USE_RTOS=1, SD_ENABLED=1, SDK_OS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1189xxxxx_cm33_flexspi_nor.scf
  link misc: --remove --predefine=\"-D__heap_noncacheable__=1\" --legacyalign --predefine=\"-DXIP_BOOT_HEADER_ENABLE=0\" --predefine=\"-D__heap_size__=0x2000\" --predefine=\"-D__stack_size__=0x2000\" --entry=Reset_Handler --info=sizes,totals,unused,veneers
target host_audio_recorder_freertos_cm33 release (ARM-ADS)
  device: MIMXRT1189CVM8C:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: host_audio_recorder_freertos_cm33.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, USB_AUDIO_RECORDER_SDCARD_BUFFER_LENGTH=3072, USB_AUDIO_RECORDER_SDCARD_WRITE_LENGTH=1024, USB_STACK_FREERTOS, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8C_cm33, MIMXRT1189_cm33_SERIES, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, SERIAL_PORT_TYPE_UART=1, USE_RTOS=1, SD_ENABLED=1, SDK_OS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1189xxxxx_cm33_ram.scf
  link misc: as above
target host_audio_recorder_freertos_cm33 hyperram_release (ARM-ADS)
  device: MIMXRT1189CVM8C:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: host_audio_recorder_freertos_cm33.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, USB_HOST_CONFIG_BUFFER_PROPERTY_CACHEABLE=1, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, USE_HYPERRAM=1, USB_AUDIO_RECORDER_SDCARD_BUFFER_LENGTH=3072, USB_AUDIO_RECORDER_SDCARD_WRITE_LENGTH=1024, USB_STACK_FREERTOS, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8C_cm33, MIMXRT1189_cm33_SERIES, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, SERIAL_PORT_TYPE_UART=1, USE_RTOS=1, SD_ENABLED=1, SDK_OS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1189xxxxx_cm33_hyperram.scf
  link misc: as above
target host_audio_recorder_freertos_cm33 flexspi_nor_release (ARM-ADS)
  device: MIMXRT1189CVM8C:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: host_audio_recorder_freertos_cm33.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=0, USB_AUDIO_RECORDER_SDCARD_BUFFER_LENGTH=3072, USB_AUDIO_RECORDER_SDCARD_WRITE_LENGTH=1024, USB_STACK_FREERTOS, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8C_cm33, MIMXRT1189_cm33_SERIES, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, SERIAL_PORT_TYPE_UART=1, USE_RTOS=1, SD_ENABLED=1, SDK_OS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1189xxxxx_cm33_flexspi_nor.scf
  link misc: as above
