# Keil uVision project wifi_wpa_supplicant_cm33.uvprojx, settings and files
target wifi_wpa_supplicant_cm33 flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1189CVM8C:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: wifi_wpa_supplicant_cm33.out
  AfterMake: fromelf.exe --output "$Lwifi_wpa_supplicant.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=0, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, MBEDTLS_CONFIG_FILE='\"wpa_supp_ele_s400_mbedtls_config.h\"', USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8C_cm33, MIMXRT1189_cm33_SERIES, OSA_USED, SERIAL_PORT_TYPE_UART=1, WIFI_IW416_BOARD_MURATA_1XK_M2, CACHE_MODE_WRITE_THROUGH=1, CONFIG_NXP_WIFI_SOFTAP_SUPPORT=1, MBEDTLS_MCUX_ELE_S400_API, PRINTF_FLOAT_ENABLE=1, SO_REUSE=1, SDK_OS_FREE_RTOS, FSL_OSA_TASK_ENABLE=1, CONFIG_HOSTAPD=1, SDIO_ENABLED=1
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../xip;../../../../../../devices/MIMXRT1189/xip;../../../../../../devices/MIMXRT1189/drivers;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MIMXRT1189;../../../../../../devices/MIMXRT1189/periph;../../../../../../devices/MIMXRT1189/drivers/cm33;../../../../../../devices/MIMXRT1189/utilities/debug_console;../../../../../../components/lists;../../../../../../devices/MIMXRT1189/utilities/str;../../../../../../components/silicon_id;../../../../../../components/silicon_id/socs;../../../../../../components/serial_manager;../../../../../../components/gpio;../../../../../../components/uart;../../../../../../components/osa;../../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits;../../../../../../components/wifi_bt_module/Murata/tx_pwr_limits;../../../../../../components/wifi_bt_module/u-blox/tx_pwr_limits;../../../../../../components/wifi_bt_module/incl;../../../../../../components/ele_crypto;../../../../../../middleware/wifi_nxp;../../../../../../middleware/wifi_nxp/incl;../../../../../../middleware/wifi_nxp/incl/port/osa;../../../../../../middleware/wifi_nxp/port/osa;../../../../../../middleware/wifi_nxp/incl/port;../../../../../../middleware/wifi_nxp/incl/wifidriver;../../../../../../middleware/wifi_nxp/wifi_bt_firmware;../../../../../../middleware/wifi_nxp/wifidriver;../../../../../../middleware/wifi_nxp/wifidriver/incl;../../../../../../middleware/wifi_nxp/wifi_bt_firmware/IW416;../../../../../../middleware/wifi_nxp/wifi_bt_firmware/8987;../../../../../../middleware/wifi_nxp/wifi_bt_firmware/nw61x;../../../../../../middleware/wifi_nxp/wifi_bt_firmware/iw610;../../../../../../middleware/wifi_nxp/firmware_dnld;../../../../../../middleware/wifi_nxp/sdio_nxp_abs;../../../../../../middleware/wifi_nxp/sdio_nxp_abs/incl;../../../../../../middleware/wifi_nxp/fwdnld_intf_abs;../../../../../../middleware/wifi_nxp/incl/port/net;../../../../../../middleware/wifi_nxp/incl/port/net/hooks;../../../../../../middleware/wifi_nxp/dhcpd;../../../../../../middleware/wifi_nxp/incl/wlcmgr;../../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if;../../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if/incl;../../../../../../middleware/wifi_nxp/certs;../../../../../../middleware/wifi_nxp/port/net;../../../../../../middleware/wifi_nxp/cli;../../../../../../middleware/wifi_nxp/nw_utils;../../../../../../middleware/wifi_nxp/wls;../../../../../../middleware/mbedtls/include;../../../../../../middleware/mbedtls/library;../../../../../../middleware/mbedtls/port/ele_s400;../../../../../../middleware/lwip/port;../../../../../../middleware/lwip/src/include;../../../../../../middleware/lwip/port/sys_arch/dynamic;../../../../../../middleware/wireless/wpa_supplicant-rtos;../../../../../../middleware/wireless/wpa_supplicant-rtos/src;../../../../../../middleware/wireless/wpa_supplicant-rtos/src/utils;../../../../../../middleware/wireless/wpa_supplicant-rtos/src/common;../../../../../../middleware/wireless/wpa_supplicant-rtos/src/crypto;../../../../../../middleware/wireless/wpa_supplicant-rtos/src/ap;../../../../../../middleware/wireless/wpa_supplicant-rtos/src/drivers;../../../../../../middleware/wireless/wpa_supplicant-rtos/src/eap_common;../../../../../../middleware/wireless/wpa_supplicant-rtos/src/eap_peer;../../../../../../middleware/wireless/wpa_supplicant-rtos/src/eap_server;../../../../../../middleware/wireless/wpa_supplicant-rtos/src/eapol_auth;../../../../../../middleware/wireless/wpa_supplicant-rtos/src/eapol_supp;../../../../../../middleware/wireless/wpa_supplicant-rtos/src/fst;../../../../../../middleware/wireless/wpa_supplicant-rtos/src/l2_packet;../../../../../../middleware/wireless/wpa_supplicant-rtos/src/p2p;../../../../../../middleware/wireless/wpa_supplicant-rtos/src/pae;../../../../../../middleware/wireless/wpa_supplicant-rtos/src/radius;../../../../../../middleware/wireless/wpa_supplicant-rtos/src/rsn_supp;../../../../../../middleware/wireless/wpa_supplicant-rtos/src/tls;../../../../../../middleware/wireless/wpa_supplicant-rtos/src/wps;../../../../../../middleware/wireless/wpa_supplicant-rtos/port/mbedtls;../../../../../../middleware/wireless/wpa_supplicant-rtos/hostapd;../../../../../../middleware/wireless/wpa_supplicant-rtos/wpa_supplicant;../../../../../../middleware/wireless/wpa_supplicant-rtos/freertos;../../../../../../middleware/wireless/wpa_supplicant-rtos/freertos/src;../../../../../../middleware/sdmmc/common;../../../../../../middleware/sdmmc/osa;../../../../../../middleware/sdmmc/sdio;../../../../../../middleware/sdmmc/host/usdhc;../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure;../../../../../../rtos/freertos/freertos-kernel/template/ARM_CM33_3_priority_bits
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8C_cm33, MIMXRT1189_cm33_SERIES, OSA_USED
  asm misc: -include ../mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1189xxxxx_cm33_flexspi_nor.scf
  link misc: --remove --predefine=\"-DXIP_BOOT_HEADER_ENABLE=0\" --predefine=\"-D__stack_size__=0x400\" --predefine=\"-D__heap_size__=0x400\" --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: main.c pin_mux.c pin_mux.h lwippools.h lwiphooks.h FreeRTOSConfig.h lwipopts.h wifi_config.h hardware_init.c app.h sdmmc_config.c sdmmc_config.h wifi_bt_config.c wifi_bt_config.h FreeRTOSConfigBoard.h fsl_debug_console_conf.h fsl_os_abstraction_config.h mcux_config.h mcux_config.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c
  group xip
    ../../../../xip/: evkmimxrt1180_flexspi_nor_config.c evkmimxrt1180_flexspi_nor_config.h
    ../../../../../../devices/MIMXRT1189/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group drivers
    ../../../../../../devices/MIMXRT1189/drivers/: fsl_pmu.h fsl_pmu.c fsl_clock.h fsl_clock.c fsl_dcdc.c fsl_dcdc.h fsl_ele_base_api.c fsl_ele_base_api.h fsl_gpc.c fsl_gpc.h fsl_iomuxc.h fsl_memory.c fsl_memory.h fsl_misc.h fsl_soc_src.c fsl_soc_src.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_rgpio.h fsl_rgpio.c fsl_s3mu.c fsl_s3mu.h fsl_usdhc.c fsl_usdhc.h
    ../../../../../../devices/MIMXRT1189/drivers/cm33/: fsl_cache.c fsl_cache.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv8m_mpu.h
  group device
    ../../../../../../devices/MIMXRT1189/: fsl_device_registers.h MIMXRT1189_cm33.h MIMXRT1189_cm33_COMMON.h MIMXRT1189_cm33_features.h system_MIMXRT1189_cm33.c system_MIMXRT1189_cm33.h
  group device/periph
    ../../../../../../devices/MIMXRT1189/periph/: PERI_ADC.h PERI_ANADIG.h PERI_ANADIG_LDO_BBSM.h PERI_ANADIG_MISC.h PERI_ANADIG_OSC.h PERI_ANADIG_PLL.h PERI_ANADIG_PMU.h PERI_ANADIG_TEMPSENSOR.h PERI_AOI.h PERI_ASRC.h PERI_AXBS.h PERI_BBNSM.h PERI_BLK_CTRL_BBSMMIX.h PERI_BLK_CTRL_NS_AONMIX.h PERI_BLK_CTRL_S_AONMIX.h PERI_BLK_CTRL_WAKEUPMIX.h PERI_CACHE_ECC_MCM.h PERI_CAN.h PERI_CCM.h PERI_CMP.h PERI_DAC.h PERI_DCDC.h PERI_DMA.h PERI_DMA4.h PERI_ECAT.h PERI_EIM.h PERI_ENETC_GLOBAL.h PERI_ENETC_PCI_TYPE0.h PERI_ENETC_PF_EMDIO.h PERI_ENETC_PF_TMR.h PERI_ENETC_SI.h PERI_ENETC_VF_PCI_TYPE0.h PERI_EQDC.h PERI_ERM.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXSPI.h PERI_FLEXSPI_SLV.h PERI_GPC_CPU_CTRL.h PERI_GPC_GLOBAL.h PERI_GPC_SYS_SLEEP_CTRL.h PERI_GPT.h PERI_I2S.h PERI_I3C.h PERI_IEE.h PERI_IEE_APC.h PERI_IERC_IERB.h PERI_IERC_PCI.h PERI_IOMUXC.h PERI_IOMUXC_AON.h PERI_KPP.h PERI_LPI2C.h PERI_LPIT.h PERI_LPSPI.h PERI_LPTMR.h PERI_LPUART.h PERI_M7_MCM.h PERI_MECC.h PERI_MSGINTR.h PERI_MU.h PERI_NETC_ENETC.h PERI_NETC_ETH_LINK.h PERI_NETC_IERB.h PERI_NETC_PORT.h PERI_NETC_PRIV.h PERI_NETC_PSEUDO_LINK.h PERI_NETC_SW.h PERI_NETC_SW_ENETC.h PERI_OCOTP_FSB.h PERI_OSC_RC_400M.h PERI_OTFAD.h PERI_PDM.h PERI_PHY_LDO.h PERI_PLL.h PERI_PWM.h PERI_RGPIO.h PERI_RTWDOG.h PERI_S3MU.h PERI_SEMA42.h PERI_SEMC.h PERI_SINC.h PERI_SPDIF.h PERI_SRC_GENERAL.h PERI_SRC_MIF_LN28FDSOI_SPLLRAM.h PERI_SRC_MIF_S28SPREGH.h PERI_SRC_MIF_S28SPREGH_PSWA.h PERI_SRC_MIX_SLICE.h PERI_SYSPM.h PERI_SYS_CTR_COMPARE.h PERI_SYS_CTR_CONTROL.h PERI_SYS_CTR_READ.h PERI_TCM_ECC_MCM.h PERI_TMPSNS.h PERI_TMR.h PERI_TPM.h PERI_TRDC.h PERI_TSTMR.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_VMBANDGAP.h PERI_VREF.h PERI_XBAR_NUM_OUT221.h PERI_XBAR_NUM_OUT32.h PERI_XCACHE.h
  group startup/arm
    ../../../../../../devices/MIMXRT1189/arm/: startup_MIMXRT1189_cm33.S
  group utilities
    ../../../../../../devices/MIMXRT1189/utilities/debug_console/: fsl_assert.h fsl_assert.c
    ../../../../../../devices/MIMXRT1189/utilities/: fsl_memcpy.S
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group utilities/str
    ../../../../../../devices/MIMXRT1189/utilities/str/: fsl_str.h fsl_str.c
  group component/silicon_id
    ../../../../../../components/silicon_id/: fsl_silicon_id.h fsl_silicon_id.c
    ../../../../../../components/silicon_id/socs/imxrt1180/: fsl_silicon_id_soc.c
  group component
    ../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
  group utilities/debug_console
    ../../../../../../devices/MIMXRT1189/utilities/debug_console/: fsl_debug_console.h fsl_debug_console.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/gpio
    ../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_rgpio.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h
  group component/wifi_bt_module/AzureWave/tx_pwr_limits
    ../../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits/: wlan_txpwrlimit_cfg_WW.h wlan_txpwrlimit_cfg_WW_rw610.h
  group component/wifi_bt_module/Murata/tx_pwr_limits
    ../../../../../../components/wifi_bt_module/Murata/tx_pwr_limits/: wlan_txpwrlimit_cfg_murata_1XK_WW.h wlan_txpwrlimit_cfg_murata_1ZM_WW.h wlan_txpwrlimit_cfg_murata_2EL_WW.h wlan_txpwrlimit_cfg_murata_NH.h
  group component/wifi_bt_module/u-blox/tx_pwr_limits
    ../../../../../../components/wifi_bt_module/u-blox/tx_pwr_limits/: wlan_txpwrlimit_cfg_jody_w5_WW.h
  group component/wifi_bt_module/incl
    ../../../../../../components/wifi_bt_module/incl/: wifi_bt_module_config.h
  group component/ele_crypto
    ../../../../../../components/ele_crypto/: ele_crypto.c ele_crypto.h ele_crypto_internal.h
  group wifi/port/osa
    ../../../../../../middleware/wifi_nxp/port/osa/: osa_freertos.h osa_freertos.c osa.c mem_pool.c mem_pool_config.c slist.c stack_simple.c osa_cli.c
  group wifi/incl/port/osa
    ../../../../../../middleware/wifi_nxp/incl/port/osa/: osa.h mem_pool.h mem_pool_config.h slist.h stack_simple.h
  group wifi/incl
    ../../../../../../middleware/wifi_nxp/incl/: wifi_config_default.h wifi_cal_data_ext.h wm_utils.h wmerrno.h wmlog.h wmtypes.h wifi_cal_data_frdmrw61x_1ant.h wifi_cal_data_rw61x_1ant.h wifi_cal_data_rw61x_1ant_diversity.h wifi_cal_data_rw61x_2ant.h wifi_cal_data_rw61x_3ant_diversity.h wifi_cal_data_override.h WIFI_IW416_BOARD_AW_AM457_CAL_DATA_EXT.h dhcp-server.h nxp_wifi.h wmstats.h cli.h cli_utils.h iperf.h wifi_ping.h
  group wifi/incl/wifidriver
    ../../../../../../middleware/wifi_nxp/incl/wifidriver/: wifi-decl.h wifi.h wifi_events.h wifi_nxp.h
  group wifi/wifidriver/incl
    ../../../../../../middleware/wifi_nxp/wifidriver/incl/: mlan_decl.h mlan_ioctl.h type_decls.h mlan_main_defs.h mlan.h mlan_11ac.h mlan_11ax.h mlan_11h.h mlan_11n.h mlan_11n_aggr.h mlan_11n_rxreorder.h mlan_11v.h mlan_action.h mlan_11k.h mlan_mbo.h mlan_api.h mlan_fw.h mlan_ieee.h mlan_init.h mlan_join.h mlan_main.h mlan_meas.h mlan_remap_mem_operations.h mlan_uap.h mlan_util.h mlan_wmm.h
  group wifi/wifi_bt_firmware
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/: wlan_bt_fw.h
  group wifi/wifi_bt_firmware/IW416
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/IW416/: sduartIW416_wlan_bt.bin.inc sdIW416_wlan.bin.inc uartIW416_bt.bin.inc sduartIW416_wlan_bt.h sdIW416_wlan.h uartIW416_bt.h IW416_cpu12.c IW416_cpu1.c IW416_cpu2.c
  group wifi/wifi_bt_firmware/8987
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/8987/: sduart8987_wlan_bt.bin.inc sd8987_wlan.bin.inc uart8987_bt.bin.inc sduart8987_wlan_bt.h sd8987_wlan.h uart8987_bt.h 8987_cpu12.c 8987_cpu1.c 8987_cpu2.c
  group wifi/wifi_bt_firmware/nw61x
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/nw61x/: sduart_nw61x.bin.se.inc sd_nw61x.bin.se.inc uart_nw61x.bin.se.inc sduart_nw61x_se.h sd_nw61x_se.h uart_nw61x_se.h nw61x_cpu12_se.c nw61x_cpu1_se.c nw61x_cpu2_se.c
  group wifi/wifi_bt_firmware/iw610
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/iw610/: sduartspi_iw610.bin.se.inc sd_iw610.bin.se.inc uartspi_iw610.bin.se.inc sduart_iw610.bin.se.inc uart_iw610_bt.bin.se.inc sduart_iw610_se.h sd_iw610_se.h uart_iw610_se.h iw610_cpu12_se.c iw610_cpu2_se.c iw610_cpu1_se.c
  group wifi/wifidriver
    ../../../../../../middleware/wifi_nxp/wifidriver/: sdio.c sdio.h mlan_11ac.c mlan_11ax.c mlan_11d.c mlan_11h.c mlan_11n.c mlan_11n_aggr.c mlan_11n_rxreorder.c mlan_11v.c mlan_action.c mlan_11k.c mlan_mbo.c mlan_api.c mlan_cfp.c mlan_cmdevt.c mlan_glue.c mlan_init.c mlan_join.c mlan_misc.c mlan_scan.c mlan_shim.c mlan_sta_cmd.c mlan_sta_cmdresp.c mlan_sta_event.c mlan_sta_ioctl.c mlan_sta_rx.c mlan_txrx.c mlan_wmm.c wifi-debug.c wifi-debug.h wifi-internal.h wifi-mem.c wifi.c wifi_common.h wifi_pwrmgr.c wifi-wps.c wifi-uap.c mlan_uap_ioctl.c mlan_uap_cmdevent.c wifi-sdio.c wifi-sdio.h
  group wifi/firmware_dnld
    ../../../../../../middleware/wifi_nxp/firmware_dnld/: firmware_dnld.c firmware_dnld.h
  group wifi/incl/port/net
    ../../../../../../middleware/wifi_nxp/incl/port/net/: wm_net.h wm_net.h wm_net.h
  group wifi/port/net
    ../../../../../../middleware/wifi_nxp/port/net/: net.c netif_decl.h wifi_netif.c net.c netif_decl.h wifi_netif.c
  group wifi/incl/port/net/hooks
    ../../../../../../middleware/wifi_nxp/incl/port/net/hooks/: lwip_default_hooks.h
  group wifi/port/net/hooks
    ../../../../../../middleware/wifi_nxp/port/net/hooks/: lwip_default_hooks.c
  group wifi/dhcpd
    ../../../../../../middleware/wifi_nxp/dhcpd/: dhcp-bootp.h dhcp-priv.h dhcp-server-main.c dhcp-server.c dns-server.c dns.h dhcp-bootp.h dhcp-priv.h dhcp-server-main.c dhcp-server.c dns-server.c dns.h dhcp-server-cli.c
  group wifi/incl/wlcmgr
    ../../../../../../middleware/wifi_nxp/incl/wlcmgr/: wlan.h wlan_11d.h wlan_tests.h
  group wifi/wifidriver/wpa_supp_if/incl
    ../../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if/incl/: rtos_wpa_supp_if.h wifi_nxp_internal.h
  group wifi/wifidriver/wpa_supp_if
    ../../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if/: wifi_nxp.c rtos_wpa_supp_if.c wifi_nxp_internal.c
  group wifi/certs
    ../../../../../../middleware/wifi_nxp/certs/: ca-cert.h client-cert.h client-key.h server-cert.h server-key.h dh-param.h
  group wifi/wlcmgr
    ../../../../../../middleware/wifi_nxp/wlcmgr/: wlan.c wlan_txpwrlimit_cfg.c wlan_basic_cli.c wlan_enhanced_tests.c wlan_tests.c wlan_test_mode_tests.c
  group wifi
    ../../../../../../middleware/wifi_nxp/: ChangeLogKSDK.txt CMakeLists.txt
  group wifi/sdio_nxp_abs
    ../../../../../../middleware/wifi_nxp/sdio_nxp_abs/: mlan_sdio.c fwdnld_sdio.c
  group wifi/sdio_nxp_abs/incl
    ../../../../../../middleware/wifi_nxp/sdio_nxp_abs/incl/: fwdnld_sdio.h mlan_sdio_defs.h mlan_sdio.h mlan_sdio_api.h
  group wifi/fwdnld_intf_abs
    ../../../../../../middleware/wifi_nxp/fwdnld_intf_abs/: fwdnld_intf_abs.c fwdnld_intf_abs.h
  group wifi/cli
    ../../../../../../middleware/wifi_nxp/cli/: cli_mem.h cli.c cli_mem_simple.c cli_utils.c wifi_shell.h wifi_shell.c
  group wifi/nw_utils
    ../../../../../../middleware/wifi_nxp/nw_utils/: wifi_ping.c iperf.c network_cfg.h
  group wifi/wls
    ../../../../../../middleware/wifi_nxp/wls/: range_kalman.h range_kalman.c wls_api.c wls_api.h wls_param_defines.h wls_processing.c wls_processing.h wls_QR_algorithm.c wls_QR_algorithm.h wls_radix4Fft.h wls_radix4Fft.c wls_structure_defs.h wls_subspace_processing.h wls_subspace_processing.c
  group mbedtls/include/mbedtls
    ../../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h psa_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/include/psa
    ../../../../../../middleware/mbedtls/include/psa/: crypto.h crypto_builtin_composites.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group mbedtls/library
    ../../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum_internal.h bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cmac.c common.h constant_time.c constant_time_internal.h constant_time_invasive.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_invasive.h entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c mps_common.h mps_error.h mps_reader.c mps_reader.h mps_trace.c mps_trace.h net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c ssl_tls13_keys.h threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/port/ele_s400
    ../../../../../../middleware/mbedtls/port/ele_s400/: ele_mbedtls.c ele_mbedtls.h ele_s400_mbedtls_config.h ele_fw.h ele_entropy.c aes_alt.h aes_alt.c ccm_alt.h ccm_alt.c gcm_alt.h gcm_alt.c rsa_alt.h rsa_alt.c threading_alt.h sha256_alt.c sha256_alt.h sha512_alt.c sha512_alt.h hmac_alt.c
  group lwip/port/arch
    ../../../../../../middleware/lwip/port/arch/: cc.h perf.h
  group lwip/src/api
    ../../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/core
    ../../../../../../middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/src/core/ipv4
    ../../../../../../middleware/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/src/core/ipv6
    ../../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip/src/include/compat/posix
    ../../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/compat/posix/net
    ../../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/sys
    ../../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/stdc
    ../../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/lwip
    ../../../../../../middleware/lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/priv
    ../../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h memp_priv.h memp_std.h mem_priv.h nd6_priv.h raw_priv.h sockets_priv.h tcpip_priv.h tcp_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../../middleware/lwip/src/include/lwip/prot/: acd.h autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip/src/include/netif
    ../../../../../../middleware/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lwip/src/include/netif/ppp
    ../../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h ppp_impl.h ppp_opts.h upap.h vj.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip/src/netif
    ../../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lwip/src/netif/ppp/polarssl
    ../../../../../../middleware/lwip/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
  group lwip/port/sys_arch/dynamic/arch
    ../../../../../../middleware/lwip/port/sys_arch/dynamic/arch/: sys_arch.h
  group lwip/port/sys_arch/dynamic
    ../../../../../../middleware/lwip/port/sys_arch/dynamic/: sys_arch.c
  group lwip/src/apps/lwiperf
    ../../../../../../middleware/lwip/src/apps/lwiperf/: lwiperf.c
  group lwip/src/include/lwip/apps
    ../../../../../../middleware/lwip/src/include/lwip/apps/: lwiperf.h
  group wpa_supplicant-rtos/port/mbedtls
    ../../../../../../middleware/wireless/wpa_supplicant-rtos/port/mbedtls/: wpa_supp_mbedtls_config.h wpa_supp_els_pkc_mbedtls_config.h wpa_supp_ele_s400_mbedtls_config.h supp_crypto.c supp_crypto.h
  group wpa_supplicant-rtos/src/common
    ../../../../../../middleware/wireless/wpa_supplicant-rtos/src/common/: wpa_common.c ieee802_11_common.c hw_features_common.c wpa_ctrl.c sae.c dragonfly.c gas.c dpp.c dpp_auth.c dpp_backup.c dpp_crypto.c dpp_pkex.c dpp_reconfig.c dpp_tcp.c gas_server.c brcm_vendor.h ctrl_iface_common.h defs.h dhcp.h dpp.h dpp_i.h dragonfly.h eapol_common.h gas.h hw_features_common.h ieee802_11_common.h ieee802_11_defs.h ieee802_1x_defs.h linux_bridge.h linux_vlan.h ocv.h privsep_commands.h ptksa_cache.h qca-vendor-attr.h qca-vendor.h sae.h tnc.h version.h wpa_common.h wpa_ctrl.h wpa_helpers.h gas_server.h
  group wpa_supplicant-rtos/src/drivers
    ../../../../../../middleware/wireless/wpa_supplicant-rtos/src/drivers/: driver_common.c drivers.c driver_freertos.c driver.h driver_hostap.h driver_freertos.h rfkill.h
  group wpa_supplicant-rtos/src/l2_packet
    ../../../../../../middleware/wireless/wpa_supplicant-rtos/src/l2_packet/: l2_packet.h l2_packet_freertos.c
  group wpa_supplicant-rtos/src/utils
    ../../../../../../middleware/wireless/wpa_supplicant-rtos/src/utils/: base64.c common.c wpabuf.c bitfield.c os_freertos.c crc32.c ip_addr.c block_alloc.c dl_list.h wpa_debug.c uuid.c eloop_freertos.c json.c base64.h bitfield.h block_alloc.h browser.h build_config.h common.h config.h const_time.h crc32.h edit.h eloop.h ext_password.h ext_password_i.h http-utils.h includes.h ip_addr.h json.h module_tests.h os.h pcsc_funcs.h platform.h state_machine.h trace.h uuid.h wpabuf.h wpa_debug.h xml-utils.h
  group wpa_supplicant-rtos/wpa_supplicant
    ../../../../../../middleware/wireless/wpa_supplicant-rtos/wpa_supplicant/: ap.h autoscan.h bgscan.h bss.h bssid_ignore.h config.h config_ssid.h ctrl_iface.h dpp_supplicant.h driver_i.h gas_query.h hs20_supplicant.h ibss_rsn.h interworking.h mesh.h mesh_mpm.h mesh_rsn.h notify.h offchannel.h p2p_supplicant.h scan.h sme.h wifi_display.h wmm_ac.h wnm_sta.h wpas_glue.h wpas_kay.h wpa_supplicant_i.h wps_supplicant.h config.c notify.c bss.c eap_register.c op_classes.c rrm.c wmm_ac.c config_none.c sme.c wpa_supplicant.c events.c bssid_ignore.c wpas_glue.c scan.c robust_av.c ctrl_iface.c ctrl_iface_udp.c mbo.c wnm_sta.c README bgscan.c bgscan_simple.c bgscan_learn.c ap.c p2p_supplicant.c p2p_supplicant_sd.c gas_query.c offchannel.c wps_supplicant.c dpp_supplicant.c interworking.c
  group wpa_supplicant-rtos/wpa_supplicant/binder
    ../../../../../../middleware/wireless/wpa_supplicant-rtos/wpa_supplicant/binder/: binder.h
  group wpa_supplicant-rtos/wpa_supplicant/dbus
    ../../../../../../middleware/wireless/wpa_supplicant-rtos/wpa_supplicant/dbus/: dbus_common.h dbus_new.h
  group wpa_supplicant-rtos/freertos/src
    ../../../../../../middleware/wireless/wpa_supplicant-rtos/freertos/src/: supp_main.h supp_api.h wpa_cli.h wpa_cli.c supp_main.c supp_api.c
  group wpa_supplicant-rtos/src/ap
    ../../../../../../middleware/wireless/wpa_supplicant-rtos/src/ap/: ap_config.c ap_drv_ops.c ap_list.c ap_mlme.c authsrv.c beacon.c bss_load.c dfs.c drv_callbacks.c eap_user_db.c hostapd.c hw_features.c ieee802_11_auth.c ieee802_11.c ieee802_11_he.c ieee802_11_ht.c ieee802_11_shared.c ieee802_11_vht.c ieee802_1x.c neighbor_db.c p2p_hostapd.c pmksa_cache_auth.c preauth_auth.c rrm.c sta_info.c tkip_countermeasures.c utils.c wmm.c ctrl_iface_ap.c mbo_ap.c wpa_auth.c wpa_auth_ie.c wpa_auth_ft.c wpa_auth_glue.c wps_hostapd.c wnm_ap.c acs.h gas_query_ap.c accounting.h airtime_policy.h ap_config.h ap_drv_ops.h ap_list.h ap_mlme.h authsrv.h beacon.h bss_load.h ctrl_iface_ap.h dfs.h dhcp_snoop.h fils_hlp.h gas_query_ap.h gas_serv.h hostapd.h hs20.h hw_features.h ieee802_11_auth.h ieee802_11.h ieee802_1x.h mbo_ap.h ndisc_snoop.h neighbor_db.h p2p_hostapd.h pmksa_cache_auth.h preauth_auth.h rrm.h sta_info.h taxonomy.h tkip_countermeasures.h vlan.h vlan_init.h vlan_util.h wmm.h wnm_ap.h wpa_auth_glue.h wpa_auth.h wpa_auth_ie.h wpa_auth_i.h wpa_auth_kay.h wps_hostapd.h x_snoop.h dpp_hostapd.c dpp_hostapd.h acs.c eth_p_oui.c eth_p_oui.h gas_serv.c
  group wpa_supplicant-rtos/src/eap_common
    ../../../../../../middleware/wireless/wpa_supplicant-rtos/src/eap_common/: eap_common.c eap_wsc_common.c eap_peap_common.c chap.c eap_fast_common.c eap_sim_common.c chap.h eap_common.h eap_defs.h eap_eke_common.h eap_fast_common.h eap_gpsk_common.h eap_ikev2_common.h eap_pax_common.h eap_peap_common.h eap_psk_common.h eap_pwd_common.h eap_sake_common.h eap_sim_common.h eap_teap_common.h eap_tlv_common.h eap_ttls.h eap_wsc_common.h ikev2_common.h
  group wpa_supplicant-rtos/src/eap_server
    ../../../../../../middleware/wireless/wpa_supplicant-rtos/src/eap_server/: eap_server.c eap_server_identity.c eap_server_methods.c eap_server_wsc.c eap_server_tls.c eap_sim_db.c eap_server_ttls.c eap_server_tls_common.c eap_server_peap.c eap_server_mschapv2.c eap_server_md5.c eap_server_gtc.c eap_server_fast.c eap_server_sim.c eap_server_aka.c eap.h eap_i.h eap_methods.h eap_sim_db.h eap_tls_common.h ikev2.h tncs.h
  group wpa_supplicant-rtos/src/eapol_auth
    ../../../../../../middleware/wireless/wpa_supplicant-rtos/src/eapol_auth/: eapol_auth_sm.c eapol_auth_sm.h eapol_auth_sm_i.h
  group wpa_supplicant-rtos/src/crypto
    ../../../../../../middleware/wireless/wpa_supplicant-rtos/src/crypto/: aes-eax.c aes-encblock.c aes-ctr.c aes-cbc.c aes-siv.c aes-unwrap.c aes-wrap.c des-internal.c dh_groups.c rc4.c md4-internal.c md5.c md5-internal.c sha1-internal.c fips_prf_internal.c sha256-internal.c sha1.c sha256.c tls_none.c ms_funcs.c sha1-tlsprf.c sha1-prf.c sha256-prf.c sha1-pbkdf2.c aes-omac1.c aes-internal-enc.c aes-internal-dec.c aes-internal.c crypto_mbedtls2.c tls_mbedtls2.c sha256-kdf.c sha384-kdf.c sha512-kdf.c milenage.c aes.h aes_i.h aes_siv.h aes_wrap.h crypto.h des_i.h dh_group5.h dh_groups.h md5.h md5_i.h milenage.h ms_funcs.h random.h sha1.h sha1_i.h sha256.h sha256_i.h sha384.h sha384_i.h sha512.h sha512_i.h tls.h
  group wpa_supplicant-rtos/src/rsn_supp
    ../../../../../../middleware/wireless/wpa_supplicant-rtos/src/rsn_supp/: wpa.c preauth.c pmksa_cache.c wpa_ie.c wpa_ft.c pmksa_cache.h preauth.h wpa.h wpa_ie.h wpa_i.h
  group wpa_supplicant-rtos/src/p2p
    ../../../../../../middleware/wireless/wpa_supplicant-rtos/src/p2p/: p2p.c p2p_utils.c p2p_parse.c p2p_build.c p2p_go_neg.c p2p_sd.c p2p_pd.c p2p_invitation.c p2p_dev_disc.c p2p_group.c p2p.h p2p_i.h
  group wpa_supplicant-rtos/src/eap_peer
    ../../../../../../middleware/wireless/wpa_supplicant-rtos/src/eap_peer/: eap_wsc.c eap.c eap_methods.c eap_tls.c eap_tls_common.c eap_peap.c eap_ttls.c eap_mschapv2.c mschapv2.c eap_fast.c eap_fast_pac.c eap_gtc.c eap_sim.c eap_aka.c eap_config.h eap_fast_pac.h eap.h eap_i.h eap_methods.h eap_proxy.h eap_teap_pac.h eap_tls_common.h ikev2.h mschapv2.h tncc.h
  group wpa_supplicant-rtos/src/wps
    ../../../../../../middleware/wireless/wpa_supplicant-rtos/src/wps/: wps.c wps_common.c wps_attr_parse.c wps_attr_build.c wps_attr_process.c wps_dev_attr.c wps_enrollee.c wps_registrar.c http_client.h http.h httpread.h http_server.h upnp_xml.h wps_attr_parse.h wps_defs.h wps_dev_attr.h wps_er.h wps.h wps_i.h wps_upnp.h wps_upnp_i.h
  group wpa_supplicant-rtos/src/eapol_supp
    ../../../../../../middleware/wireless/wpa_supplicant-rtos/src/eapol_supp/: eapol_supp_sm.c eapol_supp_sm.h
  group wpa_supplicant-rtos/src/radius
    ../../../../../../middleware/wireless/wpa_supplicant-rtos/src/radius/: radius_server.c radius_das.c radius_client.c radius.c radius_client.h radius_das.h radius.h radius_server.h
  group wpa_supplicant-rtos/src/tls
    ../../../../../../middleware/wireless/wpa_supplicant-rtos/src/tls/: asn1.c asn1.h bignum.h pkcs1.h pkcs5.h pkcs8.h rsa.h tlsv1_client.h tlsv1_client_i.h tlsv1_common.h tlsv1_cred.h tlsv1_record.h tlsv1_server.h tlsv1_server_i.h x509v3.h
  group wpa_supplicant-rtos/src/fst
    ../../../../../../middleware/wireless/wpa_supplicant-rtos/src/fst/: fst_ctrl_aux.h fst_ctrl_defs.h fst_ctrl_iface.h fst_defs.h fst_group.h fst.h fst_iface.h fst_internal.h fst_session.h
  group wpa_supplicant-rtos/src/pae
    ../../../../../../middleware/wireless/wpa_supplicant-rtos/src/pae/: ieee802_1x_cp.h ieee802_1x_kay.h ieee802_1x_kay_i.h ieee802_1x_key.h ieee802_1x_secy_ops.h
  group wpa_supplicant-rtos/hostapd
    ../../../../../../middleware/wireless/wpa_supplicant-rtos/hostapd/: hlr_auc_gw.c ctrl_iface.c eap_register.c config_file.h ctrl_iface.h eap_register.h README
  group sdmmc/common
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h fsl_sdmmc_common.c
  group sdmmc/osa
    ../../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group sdmmc/sdio
    ../../../../../../middleware/sdmmc/sdio/: fsl_sdio.c fsl_sdio.h
  group sdmmc/host/usdhc
    ../../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h fsl_sdmmc_host.h
  group sdmmc/host/usdhc/non_blocking
    ../../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure
    ../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.c port.c portasm.c portasm.h portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/template/ARM_CM33_3_priority_bits
    ../../../../../../rtos/freertos/freertos-kernel/template/ARM_CM33_3_priority_bits/: FreeRTOSConfig_Gen.h
  group doc
    ../: readme.md wifi_examples_readme.md readme_modules.md examples_shared_readme.md
target wifi_wpa_supplicant_cm33 flexspi_nor_release (ARM-ADS)
  device: MIMXRT1189CVM8C:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: wifi_wpa_supplicant_cm33.out
  AfterMake: as above
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=0, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, MBEDTLS_CONFIG_FILE='\"wpa_supp_ele_s400_mbedtls_config.h\"', USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1189CVM8C_cm33, MIMXRT1189_cm33_SERIES, OSA_USED, SERIAL_PORT_TYPE_UART=1, WIFI_IW416_BOARD_MURATA_1XK_M2, CACHE_MODE_WRITE_THROUGH=1, CONFIG_NXP_WIFI_SOFTAP_SUPPORT=1, MBEDTLS_MCUX_ELE_S400_API, PRINTF_FLOAT_ENABLE=1, SO_REUSE=1, SDK_OS_FREE_RTOS, FSL_OSA_TASK_ENABLE=1, CONFIG_HOSTAPD=1, SDIO_ENABLED=1
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1189xxxxx_cm33_flexspi_nor.scf
  link misc: as above
