# Keil uVision project ota_bootloader.uvprojx, settings and files
target ota_bootloader flexspi_nor_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: IRAM(0x00080000,0x280000) IRAM2(0x00300000,0x200000) IROM(0x03000000,0x020000) IROM2(0x13000000,0x020000) XRAM(0x10300000,0x200000) XRAM2(0x20300000,0x200000) XRAM3(0x30300000,0x200000) XROM(0x10000000,0x020000) XROM2(0x20000000,0x020000) XROM3(0x30000000,0x020000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: ota_bootloader.out
  AfterMake: fromelf --bincombined -o "$L@L.bin" "#L"
  AfterMake: fromelf --m32combined -o "$L@L.srec" "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, NDEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, BL_TARGET_FLASH, MIMXRT595S
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -Wno-null-dereference  -Wno-unknown-attributes  -Wno-expansion-to-defined  -Wno-invalid-noreturn
  c include: ../../../../../middleware/mcu-boot/src/bootloader;../../../../../devices/MIMXRT595S;../../../../../devices/MIMXRT595S/drivers;../../../../../middleware/mcu-boot/targets/MIMXRT595S/src;../../../../../middleware/mcu-boot/components/osa;../../../../../middleware/mcu-boot/src/crc;../../../../../middleware/mcu-boot/src/include;../../../../../middleware/mcu-boot/src/memory;../../../../../middleware/mcu-boot/src/memory/src;../../../../../middleware/mcu-boot/src/startup;../../../../../middleware/mcu-boot/src/packet;../../../../../middleware/mcu-boot/src/property;../../../../../middleware/mcu-boot/src/utilities;../../../../../middleware/mcu-boot/src/drivers/microseconds;../../../../../components/lists;../../../../../components/osa;../../../../../CMSIS/Core/Include;../../../../../middleware/mcu-boot/src/drivers/flexspi;../../../../../middleware/mcu-boot/src/drivers/flexspi_nor
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=0
  asm include: ../../../../../middleware/mcu-boot/src/startup
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: ROM 0x10300000 size 0x200000
  memory RVCT7: ROM 0x20300000 size 0x200000
  memory RVCT8: ROM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: ../../../../../middleware/mcu-boot/targets/common/linker/arm/MIMXRT595S/MIMXRT595S_flash_bootloader.scf
  link misc: --remove --datacompressor off --entry=Reset_Handler
  group doc
    ../: readme.txt
  group source/bootloader
    ../../../../../middleware/mcu-boot/src/bootloader/: bl_reliable_update.h bl_version.h bootloader.h bl_context.h bl_peripheral_interface.h bl_user_entry.h bl_command.h bl_peripheral.h bl_shutdown_cleanup.h bl_app_crc_check.h
  group source/bootloader/src
    ../../../../../middleware/mcu-boot/src/bootloader/src/: bl_reliable_update_common.c bl_context.c bl_exception_handler.c bl_tree_root.c bl_app_crc_check.c
    ../../../../../middleware/mcu-boot/targets/MIMXRT595S/src/: bl_main.c
  group device
    ../../../../../devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h system_MIMXRT595S_cm33.h system_MIMXRT595S_cm33.c
  group drivers
    ../../../../../devices/MIMXRT595S/drivers/: fsl_clock.h fsl_clock.c fsl_crc.h fsl_crc.c fsl_usart.h fsl_usart.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_reset.h fsl_reset.c fsl_flexcomm.h fsl_flexcomm.c
  group startup
    ../../../../../middleware/mcu-boot/targets/MIMXRT595S/src/startup/arm/: startup_MIMXRT595S.s
    ../../../../../middleware/mcu-boot/src/startup/: ar_asm_macros.h
  group MIMXRT595S
    ../../../../../middleware/mcu-boot/targets/MIMXRT595S/src/: bootloader_config.h bl_clock_config_MIMXRT595S.c hardware_init_MIMXRT595S.c memory_map_MIMXRT595S.c external_memory_property_map_MIMXRT595S.c target_config.h bl_api.h bl_api.c
  group source/crc
    ../../../../../middleware/mcu-boot/src/crc/: crc16.h crc32.h
    ../../../../../middleware/mcu-boot/src/crc/src/: crc16.c crc32.c
  group source/include
    ../../../../../middleware/mcu-boot/src/include/: bootloader_common.h bootloader_core.h
  group source/memory
    ../../../../../middleware/mcu-boot/src/memory/: memory.h
  group source/memory/src
    ../../../../../middleware/mcu-boot/src/memory/src/: sram_init.h memory.c normal_memory.h normal_memory.c pattern_fill_mdk.s pattern_fill.h flexspi_nor_memory.c flexspi_nor_memory.h
  group source/packet
    ../../../../../middleware/mcu-boot/src/packet/: command_packet.h serial_packet.h
  group source/property
    ../../../../../middleware/mcu-boot/src/property/: property.h
  group source/utilities
    ../../../../../middleware/mcu-boot/src/utilities/: fsl_rtos_abstraction.h fsl_assert.h vector_table_info.h
  group source/utilities/src
    ../../../../../middleware/mcu-boot/src/utilities/src/: fsl_assert.c fsl_rtos_abstraction.c debug_util.c
  group source/property/src
    ../../../../../middleware/mcu-boot/src/property/src/: property_rt685s.c
  group source/startup
    ../../../../../middleware/mcu-boot/src/startup/: startup.c
  group source/drivers/microseconds
    ../../../../../middleware/mcu-boot/src/drivers/microseconds/: microseconds.h
    ../../../../../middleware/mcu-boot/src/drivers/microseconds/src/: microseconds_sysclk.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.c
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group source/drivers/flexspi
    ../../../../../middleware/mcu-boot/src/drivers/flexspi/: bl_flexspi.c bl_flexspi.h
  group source/drivers/flexspi_nor
    ../../../../../middleware/mcu-boot/src/drivers/flexspi_nor/: flexspi_nor_flash.c flexspi_nor_flash.h
