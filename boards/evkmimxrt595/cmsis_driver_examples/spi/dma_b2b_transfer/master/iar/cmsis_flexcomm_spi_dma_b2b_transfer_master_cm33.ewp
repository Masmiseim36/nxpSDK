# IAR project cmsis_flexcomm_spi_dma_b2b_transfer_master_cm33.ewp, settings and files
configuration flash_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT595S_M33 NXP MIMXRT595S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT595SFFOC_cm33; MIMXRT595S_cm33_SERIES; BOOT_HEADER_ENABLE=1
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../../flash_config; ../../../../../../../CMSIS/Core/Include; ../../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../../CMSIS/Driver/Include; ../../../../../../../devices/MIMXRT595S; ../../../../../../../devices/MIMXRT595S/periph; ../../../../../../../devices/MIMXRT595S/drivers; ../../../../../../../devices/MIMXRT595S/cmsis_drivers; ../../../../../../../devices/MIMXRT595S/utilities/debug_console_lite; ../../../../../../../devices/MIMXRT595S/utilities/str; ../../../../../../../components/uart
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT595SFFOC_cm33; MIMXRT595S_cm33_SERIES
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cmsis_flexcomm_spi_dma_b2b_transfer_master.bin
  ILINK.IlinkOutputFile: cmsis_flexcomm_spi_dma_b2b_transfer_master_cm33.out
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT595SFFOC_cm33; MIMXRT595S_cm33_SERIES; BOOT_HEADER_ENABLE=1
  ICCARM.CCOptLevel: 3
  group source
    ../: cmsis_spi_dma_b2b_transfer_master.c RTE_Device.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group flash_config
    ../../../../../flash_config/: flash_config.c flash_config.h
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group CMSIS_driver/Include
    ../../../../../../../CMSIS/Driver/Include/: Driver_SPI.h Driver_Common.h
  group device
    ../../../../../../../devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_COMMON.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group device/periph
    ../../../../../../../devices/MIMXRT595S/periph/: PERI_ADC.h PERI_AHB_SECURE_CTRL.h PERI_AXI_SWITCH_AMIB.h PERI_AXI_SWITCH_ASIB.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CASPER.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CMP.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUGGER_MAILBOX.h PERI_DMA.h PERI_DMIC.h PERI_FLEXCOMM.h PERI_FLEXIO.h PERI_FLEXSPI.h PERI_FREQME.h PERI_GPIO.h PERI_HASHCRYPT.h PERI_I2C.h PERI_I2S.h PERI_I3C.h PERI_INPUTMUX.h PERI_IOPCTL.h PERI_LCDIF.h PERI_MIPI_DSI_HOST.h PERI_MRT.h PERI_MU.h PERI_OCOTP.h PERI_OSTIMER.h PERI_OTFAD.h PERI_PINT.h PERI_PMC.h PERI_POWERQUAD.h PERI_PUF.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RTC.h PERI_SCT.h PERI_SEMA42.h PERI_SPI.h PERI_SYSCTL0.h PERI_SYSCTL1.h PERI_TRNG.h PERI_USART.h PERI_USBHSD.h PERI_USBHSDCD.h PERI_USBHSH.h PERI_USBPHY.h PERI_USDHC.h PERI_UTICK.h PERI_WWDT.h
  group startup/iar
    ../../../../../../../devices/MIMXRT595S/iar/: startup_MIMXRT595S_cm33.s
  group drivers
    ../../../../../../../devices/MIMXRT595S/drivers/: fsl_clock.c fsl_clock.h fsl_dsp.c fsl_dsp.h fsl_i2s_bridge.c fsl_i2s_bridge.h fsl_inputmux_connections.h fsl_memory.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_soc_mipi_dsi.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_flexcomm.h fsl_flexcomm.c fsl_usart.h fsl_usart.c fsl_spi_dma.c fsl_spi_dma.h fsl_spi.c fsl_spi.h fsl_flexspi.c fsl_flexspi.h fsl_iap.h fsl_iap.c fsl_inputmux.h fsl_inputmux.c fsl_dma.c fsl_dma.h fsl_gpio.h fsl_gpio.c fsl_iopctl.h
    ../../../../../../../devices/MIMXRT595S/cmsis_drivers/: fsl_spi_cmsis.h fsl_spi_cmsis.c
  group utilities
    ../../../../../../../devices/MIMXRT595S/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../../../devices/MIMXRT595S/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../../devices/MIMXRT595S/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
