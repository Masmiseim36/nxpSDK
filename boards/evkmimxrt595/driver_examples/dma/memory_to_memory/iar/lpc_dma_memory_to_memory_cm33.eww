<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>lpc_dma_memory_to_memory_cm33</project>
        <configuration>flash_debug</configuration>
      </member>
      <member>
        <project>lpc_dma_memory_to_memory_cm33</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_debug</name>
      <member>
        <project>lpc_dma_memory_to_memory_cm33</project>
        <configuration>flash_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_release</name>
      <member>
        <project>lpc_dma_memory_to_memory_cm33</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/lpc_dma_memory_to_memory_cm33.ewp</path>
  </project>
</workspace>
