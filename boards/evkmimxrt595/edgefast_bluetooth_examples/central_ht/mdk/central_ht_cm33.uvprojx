# Keil uVision project central_ht_cm33.uvprojx, settings and files
target central_ht_cm33 flash_debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: central_ht_cm33.out
  AfterMake: fromelf.exe --output "$Lcentral_ht.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CFG_BLE, LPUART_RING_BUFFER_SIZE=1024U, PRINTF_ADVANCED_ENABLE=1, SDK_DEBUGCONSOLE_UART=1, SDK_OS_FREE_RTOS, USE_RTOS=1, APPL_USE_STANDARD_IO, CONFIG_ARM=1, EDGEFAST_BT_LITTLEFS_MFLASH, FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0, FSL_FEATURE_FLASH_PAGE_SIZE_BYTES=4096, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, GATT_CLIENT, GATT_DB, HAL_UART_ADAPTER_FIFO=1, IOT_WIFI_ENABLE_SAVE_NETWORK=1, LFS_NO_ERROR=1, LFS_NO_INTRINSICS=1, MMC_DISK_ENABLE, MMC_ENABLED=1, SDIO_ENABLED=1, gMemManagerLight=0, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT595SFFOC_cm33, MIMXRT595S_cm33_SERIES, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING=1, OSA_USED, BOOT_HEADER_ENABLE=1, SERIAL_PORT_TYPE_UART=1, TIMER_PORT_TYPE_CTIMER=1, WIFI_IW612_BOARD_MURATA_2EL_M2, SDK_I2C_BASED_COMPONENT_USED=1, GENERIC_LIST_LIGHT=1, MFLASH_FILE_BASEADDR=7340032, MBEDTLS_CONFIG_FILE='\"ksdk_mbedtls_config.h\"', RPMSG_ADAPTER_NON_BLOCKING_MODE=1, ENABLE_RAM_VECTOR_TABLE, MBEDTLS_MCUX_ELS_PKC_API, REMOTE_CORE_BOOT_ADDRESS=0x02128000, LFS_THREADSAFE=1, LOG_ENABLE_ASYNC_MODE=1, LOG_MAX_ARGUMENT_COUNT=10, LOG_ENABLE_OVERWRITE=1
  c misc: -include ../edgefast_bluetooth_app.h -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../flash_config;../../../../../CMSIS/Core/Include;../../../../../CMSIS/Core/Include/m-profile;../../../../../devices/MIMXRT595S;../../../../../devices/MIMXRT595S/periph;../../../../../devices/MIMXRT595S/drivers;../../../../../devices/MIMXRT595S/utilities/debug_console;../../../../../components/lists;../../../../../devices/MIMXRT595S/utilities/str;../../../../../components/log;../../../../../components/serial_manager;../../../../../components/gpio;../../../../../components/timer;../../../../../components/timer_manager;../../../../../components/time_stamp;../../../../../components/uart;../../../../../components/osa;../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits;../../../../../components/wifi_bt_module/Murata/tx_pwr_limits;../../../../../components/wifi_bt_module/u-blox/tx_pwr_limits;../../../../../components/wifi_bt_module/incl;../../../../../components/pmic/pca9420;../../../../../components/power_manager/core;../../../../../components/power_manager/devices/MIMXRT595S;../../../../../components/flash/mflash;../../../../../components/flash/mflash/mimxrt595;../../../../../middleware/wifi_nxp;../../../../../middleware/wifi_nxp/incl;../../../../../middleware/wifi_nxp/incl/port/osa;../../../../../middleware/wifi_nxp/port/osa;../../../../../middleware/wifi_nxp/incl/port;../../../../../middleware/wifi_nxp/incl/wifidriver;../../../../../middleware/wifi_nxp/wifi_bt_firmware;../../../../../middleware/wifi_nxp/wifidriver;../../../../../middleware/wifi_nxp/wifidriver/incl;../../../../../middleware/wifi_nxp/wifi_bt_firmware/IW416;../../../../../middleware/wifi_nxp/wifi_bt_firmware/8987;../../../../../middleware/wifi_nxp/wifi_bt_firmware/nw61x;../../../../../middleware/wifi_nxp/wifi_bt_firmware/iw610;../../../../../middleware/wifi_nxp/firmware_dnld;../../../../../middleware/wifi_nxp/sdio_nxp_abs;../../../../../middleware/wifi_nxp/sdio_nxp_abs/incl;../../../../../middleware/wifi_nxp/fwdnld_intf_abs;../../../../../middleware/mbedtls/include;../../../../../middleware/mbedtls/library;../../../../../middleware/mbedtls/port/ksdk;../../../../../middleware/usb/include;../../../../../middleware/usb/host;../../../../../middleware/usb/config/host/ip3516hs;../../../../../middleware/usb/host/class;../../../../../middleware/usb/phy;../../../../../middleware/fatfs/source;../../../../../middleware/fatfs/source/fsl_usb_disk;../../../../../middleware/fatfs/source/fsl_mmc_disk;../../../../../middleware/littlefs;../../../../../middleware/wireless/framework/Common;../../../../../middleware/wireless/framework/services/DBG;../../../../../middleware/wireless/framework/platform/kw45_k32w1_mcxw71_nbu;../../../../../middleware/wireless/framework/platform/kw45_k32w1_mcxw71_nbu/configs;../../../../../middleware/wireless/framework/platform/kw47_mcxw72_nbu;../../../../../middleware/wireless/framework/platform/kw47_mcxw72_nbu/configs;../../../../../middleware/wireless/framework/platform/MIMXRT595S;../../../../../middleware/wireless/framework/services/LowPower;../../../../../middleware/sdmmc/common;../../../../../middleware/sdmmc/osa;../../../../../middleware/sdmmc/mmc;../../../../../middleware/sdmmc/sdio;../../../../../middleware/sdmmc/host/usdhc;../../../../../middleware/wireless/ethermind/bluetooth/export/eOSAL;../../../../../middleware/wireless/ethermind/bluetooth/export/include;../../../../../middleware/wireless/ethermind/bluetooth/export/vendor;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/att;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avctp;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avdtp;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/bnep;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/dbase;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/hci_1.2;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/mcap;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/obex;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/rfcomm;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sdp;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sm;../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/smp;../../../../../middleware/wireless/ethermind/bluetooth/private/utils/aes_cmac;../../../../../middleware/wireless/ethermind/bluetooth/private/utils/at_parser;../../../../../middleware/wireless/ethermind/bluetooth/private/utils/object_parser;../../../../../middleware/wireless/ethermind/bluetooth/private/utils/racp;../../../../../middleware/wireless/ethermind/bluetooth/private/utils/storage;../../../../../middleware/wireless/ethermind/bluetooth/private/utils/xml_parser;../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth;../../../../../middleware/wireless/ethermind/port/pal/mcux/ethal;../../../../../middleware/wireless/ethermind/port/pal/mcux/sbc;../../../../../middleware/wireless/ethermind/port/osal/src/freertos;../../../../../middleware/wireless/ethermind/port/pal/mcux;../../../../../middleware/wireless/ethermind/bluetooth/private/utils/sbc;../../../../../middleware/wireless/ethermind/bluetooth/export/extension;../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/config;../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/host;../../../../../middleware/edgefast_bluetooth/include;../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/crypto;../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/platform;../../../../../middleware/edgefast_bluetooth/source/impl/ethermind;../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/platform/configs;../../../../../middleware/edgefast_bluetooth/source/porting;../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth/controller;../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/controller/configs/lwip;../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/controller/configs/wifi;../../../../../middleware/edgefast_bluetooth/low_power/controller;../../../../../middleware/edgefast_bluetooth/source/services;../../../../../rtos/freertos/freertos-kernel/include;../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure;../../../../../rtos/freertos/freertos-kernel/template/ARM_CM33_3_priority_bits
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT595SFFOC_cm33, MIMXRT595S_cm33_SERIES, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, OSA_USED
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_flash.scf
  link misc: ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/ble/cm33/mdk/libethermind_ble_core.lib ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/ble/cm33/mdk/libethermind_ble_gatt.lib ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/ble/cm33/mdk/libethermind_ble_protocol.lib ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/ble/cm33/mdk/libethermind_ble_util.lib --remove --keep=*(._bt_*) --keep=*(._net_buf_pool*) --keep=*(._settings_handler_static*) --keep=mflash_drv.o(*) --legacyalign --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: edgefast_bluetooth_app.h central_ht.c central_ht.h main.c wifi_bt_module_config.h FreeRTOSConfigBoard.h pmic_support.c pmic_support.h sdmmc_config.c sdmmc_config.h wifi_bt_config.c wifi_bt_config.h hardware_init.c pin_mux.c pin_mux.h FreeRTOSConfig.h mbedtls_config_client.h fwk_board_lp.h fwk_board_lp.c host_low_power.c edgefast_bluetooth_audio_config.h edgefast_bluetooth_config.h fsl_debug_console_conf.h fsl_os_abstraction_config.h mcux_config.h usb_host_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv8m_mpu.h
  group device
    ../../../../../devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_COMMON.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group device/periph
    ../../../../../devices/MIMXRT595S/periph/: PERI_ADC.h PERI_AHB_SECURE_CTRL.h PERI_AXI_SWITCH_AMIB.h PERI_AXI_SWITCH_ASIB.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CASPER.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CMP.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUGGER_MAILBOX.h PERI_DMA.h PERI_DMIC.h PERI_FLEXCOMM.h PERI_FLEXIO.h PERI_FLEXSPI.h PERI_FREQME.h PERI_GPIO.h PERI_HASHCRYPT.h PERI_I2C.h PERI_I2S.h PERI_I3C.h PERI_INPUTMUX.h PERI_IOPCTL.h PERI_LCDIF.h PERI_MIPI_DSI_HOST.h PERI_MRT.h PERI_MU.h PERI_OCOTP.h PERI_OSTIMER.h PERI_OTFAD.h PERI_PINT.h PERI_PMC.h PERI_POWERQUAD.h PERI_PUF.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RTC.h PERI_SCT.h PERI_SEMA42.h PERI_SPI.h PERI_SYSCTL0.h PERI_SYSCTL1.h PERI_TRNG.h PERI_USART.h PERI_USBHSD.h PERI_USBHSDCD.h PERI_USBHSH.h PERI_USBPHY.h PERI_USDHC.h PERI_UTICK.h PERI_WWDT.h
  group startup/arm
    ../../../../../devices/MIMXRT595S/arm/: startup_MIMXRT595S_cm33.S
  group drivers
    ../../../../../devices/MIMXRT595S/drivers/: fsl_clock.c fsl_clock.h fsl_dsp.c fsl_dsp.h fsl_i2s_bridge.c fsl_i2s_bridge.h fsl_inputmux_connections.h fsl_memory.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_soc_mipi_dsi.h fsl_cache.c fsl_cache.h fsl_casper.h fsl_casper.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_ctimer.h fsl_ctimer.c fsl_flexcomm.h fsl_flexcomm.c fsl_usart_dma.h fsl_usart_dma.c fsl_usart.h fsl_usart.c fsl_i2c.h fsl_i2c.c fsl_flexspi.c fsl_flexspi.h fsl_hashcrypt.h fsl_hashcrypt.c fsl_iap.h fsl_iap.c fsl_inputmux.h fsl_inputmux.c fsl_dma.c fsl_dma.h fsl_gpio.h fsl_gpio.c fsl_iopctl.h fsl_rtc.h fsl_rtc.c fsl_ostimer.h fsl_ostimer.c fsl_trng.c fsl_trng.h fsl_usdhc.c fsl_usdhc.h
  group utilities
    ../../../../../devices/MIMXRT595S/utilities/debug_console/: fsl_assert.h fsl_assert.c
    ../../../../../devices/MIMXRT595S/utilities/: fsl_memcpy.S
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group utilities/str
    ../../../../../devices/MIMXRT595S/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console
    ../../../../../devices/MIMXRT595S/utilities/debug_console/: fsl_debug_console.h fsl_debug_console.c
  group component/log
    ../../../../../components/log/: fsl_component_log.h fsl_component_log.c fsl_component_log_config.h
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/gpio
    ../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_rt_gpio.c
  group component/timer
    ../../../../../components/timer/: fsl_adapter_timer.h fsl_adapter_ctimer.c
  group component/timer_manager
    ../../../../../components/timer_manager/: fsl_component_timer_manager.h fsl_component_timer_manager.c
  group component/time_stamp
    ../../../../../components/time_stamp/: fsl_adapter_time_stamp.h fsl_adapter_ostimer_time_stamp.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h
  group component/wifi_bt_module/AzureWave/tx_pwr_limits
    ../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits/: wlan_txpwrlimit_cfg_WW.h wlan_txpwrlimit_cfg_WW_rw610.h
  group component/wifi_bt_module/Murata/tx_pwr_limits
    ../../../../../components/wifi_bt_module/Murata/tx_pwr_limits/: wlan_txpwrlimit_cfg_murata_1XK_WW.h wlan_txpwrlimit_cfg_murata_1ZM_WW.h wlan_txpwrlimit_cfg_murata_2EL_WW.h wlan_txpwrlimit_cfg_murata_NH.h
  group component/wifi_bt_module/u-blox/tx_pwr_limits
    ../../../../../components/wifi_bt_module/u-blox/tx_pwr_limits/: wlan_txpwrlimit_cfg_jody_w5_WW.h
  group component/wifi_bt_module/incl
    ../../../../../components/wifi_bt_module/incl/: wifi_bt_module_config.h
  group component/pmic/pca9420
    ../../../../../components/pmic/pca9420/: fsl_pca9420.c fsl_pca9420.h
  group component/power_manager
    ../../../../../components/power_manager/core/: fsl_pm_core.h fsl_pm_core.c fsl_pm_config.h
  group component/devices/MIMXRT595S
    ../../../../../components/power_manager/devices/MIMXRT595S/: fsl_pm_device.c fsl_pm_device.h fsl_pm_device_config.h
  group flash/mflash
    ../../../../../components/flash/mflash/: mflash_common.h mflash_file.c mflash_file.h
  group flash/mflash/mimxrt595
    ../../../../../components/flash/mflash/mimxrt595/: mflash_drv.c mflash_drv.h
  group wifi/port/osa
    ../../../../../middleware/wifi_nxp/port/osa/: osa_freertos.h osa_freertos.c osa.c mem_pool.c mem_pool_config.c slist.c stack_simple.c
  group wifi/incl/port/osa
    ../../../../../middleware/wifi_nxp/incl/port/osa/: osa.h mem_pool.h mem_pool_config.h slist.h stack_simple.h
  group wifi/incl
    ../../../../../middleware/wifi_nxp/incl/: wifi_config_default.h wifi_cal_data_ext.h wm_utils.h wmerrno.h wmlog.h wmtypes.h wifi_cal_data_frdmrw61x_1ant.h wifi_cal_data_rw61x_1ant.h wifi_cal_data_rw61x_1ant_diversity.h wifi_cal_data_rw61x_2ant.h wifi_cal_data_rw61x_3ant_diversity.h wifi_cal_data_override.h WIFI_IW416_BOARD_AW_AM457_CAL_DATA_EXT.h
  group wifi/incl/wifidriver
    ../../../../../middleware/wifi_nxp/incl/wifidriver/: wifi-decl.h wifi.h wifi_events.h
  group wifi/wifidriver/incl
    ../../../../../middleware/wifi_nxp/wifidriver/incl/: mlan_decl.h mlan_ioctl.h type_decls.h mlan_main_defs.h
  group wifi/wifi_bt_firmware
    ../../../../../middleware/wifi_nxp/wifi_bt_firmware/: wlan_bt_fw.h
  group wifi/wifi_bt_firmware/IW416
    ../../../../../middleware/wifi_nxp/wifi_bt_firmware/IW416/: sduartIW416_wlan_bt.bin.inc sdIW416_wlan.bin.inc uartIW416_bt.bin.inc sduartIW416_wlan_bt.h sdIW416_wlan.h uartIW416_bt.h IW416_cpu12.c IW416_cpu1.c IW416_cpu2.c
  group wifi/wifi_bt_firmware/8987
    ../../../../../middleware/wifi_nxp/wifi_bt_firmware/8987/: sduart8987_wlan_bt.bin.inc sd8987_wlan.bin.inc uart8987_bt.bin.inc sduart8987_wlan_bt.h sd8987_wlan.h uart8987_bt.h 8987_cpu12.c 8987_cpu1.c 8987_cpu2.c
  group wifi/wifi_bt_firmware/nw61x
    ../../../../../middleware/wifi_nxp/wifi_bt_firmware/nw61x/: sduart_nw61x.bin.se.inc sd_nw61x.bin.se.inc uart_nw61x.bin.se.inc sduart_nw61x_se.h sd_nw61x_se.h uart_nw61x_se.h nw61x_cpu12_se.c nw61x_cpu1_se.c nw61x_cpu2_se.c
  group wifi/wifi_bt_firmware/iw610
    ../../../../../middleware/wifi_nxp/wifi_bt_firmware/iw610/: sduartspi_iw610.bin.se.inc sd_iw610.bin.se.inc uartspi_iw610.bin.se.inc sduart_iw610.bin.se.inc uart_iw610_bt.bin.se.inc sduart_iw610_se.h sd_iw610_se.h uart_iw610_se.h iw610_cpu12_se.c iw610_cpu2_se.c iw610_cpu1_se.c
  group wifi/wifidriver
    ../../../../../middleware/wifi_nxp/wifidriver/: sdio.c sdio.h wifi-sdio.h
  group wifi/firmware_dnld
    ../../../../../middleware/wifi_nxp/firmware_dnld/: firmware_dnld.c firmware_dnld.h
  group wifi/sdio_nxp_abs
    ../../../../../middleware/wifi_nxp/sdio_nxp_abs/: mlan_sdio.c fwdnld_sdio.c
  group wifi/sdio_nxp_abs/incl
    ../../../../../middleware/wifi_nxp/sdio_nxp_abs/incl/: fwdnld_sdio.h mlan_sdio_defs.h mlan_sdio.h mlan_sdio_api.h
  group wifi/fwdnld_intf_abs
    ../../../../../middleware/wifi_nxp/fwdnld_intf_abs/: fwdnld_intf_abs.c fwdnld_intf_abs.h
  group mbedtls/include/mbedtls
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h psa_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/include/psa
    ../../../../../middleware/mbedtls/include/psa/: crypto.h crypto_builtin_composites.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group mbedtls/library
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum_internal.h bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cmac.c common.h constant_time.c constant_time_internal.h constant_time_invasive.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_invasive.h entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c mps_common.h mps_error.h mps_reader.c mps_reader.h mps_trace.c mps_trace.h net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c ssl_tls13_keys.h threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/port/ksdk
    ../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c ccm_alt.h ecp_alt.h ecp_alt.c ecp_curves_alt.c ecp_alt_ksdk.c threading_alt.h
  group usb/include
    ../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group usb/host
    ../../../../../middleware/usb/host/: usb_host.h usb_host_hci.h usb_host_devices.h usb_host_framework.h usb_host_ip3516hs.c usb_host_ip3516hs.h usb_host_hci.c usb_host_devices.c usb_host_framework.c
  group usb/host/class
    ../../../../../middleware/usb/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_msd.c usb_host_msd.h usb_host_msd_ufi.c
  group usb/phy
    ../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group fatfs/source
    ../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_usb_disk
    ../../../../../middleware/fatfs/source/fsl_usb_disk/: fsl_usb_disk.h fsl_usb_disk_freertos.c
  group fatfs/source/fsl_mmc_disk
    ../../../../../middleware/fatfs/source/fsl_mmc_disk/: fsl_mmc_disk.c fsl_mmc_disk.h
  group littlefs
    ../../../../../middleware/littlefs/: lfs.c lfs.h lfs_util.c lfs_util.h
  group framework/Common
    ../../../../../middleware/wireless/framework/Common/: EmbeddedTypes.h fwk_hal_macros.h fwk_errno.h
  group framework/services/DBG
    ../../../../../middleware/wireless/framework/services/DBG/: fwk_debug.h
  group framework/platform/MIMXRT595S
    ../../../../../middleware/wireless/framework/platform/MIMXRT595S/: fwk_platform_lowpower.c fwk_platform_lowpower.h fwk_platform_lowpower_timer.h fwk_platform.c fwk_platform.h
  group framework/services/LowPower
    ../../../../../middleware/wireless/framework/services/LowPower/: PWR_Interface.h PWR.c README.md PWR_systicks.c
  group framework/services/LowPower/pics
    ../../../../../middleware/wireless/framework/services/LowPower/pics/: fig4.PNG fig8.PNG fig9.PNG fig10.PNG
  group sdmmc/common
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h fsl_sdmmc_common.c
  group sdmmc/osa
    ../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group sdmmc/mmc
    ../../../../../middleware/sdmmc/mmc/: fsl_mmc.c fsl_mmc.h
  group sdmmc/sdio
    ../../../../../middleware/sdmmc/sdio/: fsl_sdio.c fsl_sdio.h
  group sdmmc/host/usdhc
    ../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h fsl_sdmmc_host.h
  group sdmmc/host/usdhc/blocking
    ../../../../../middleware/sdmmc/host/usdhc/blocking/: fsl_sdmmc_host.c
  group edgefast/bluetooth
    ../../../../../middleware/edgefast_bluetooth/: readme.txt
  group bt_ble/bluetooth/export/eOSAL
    ../../../../../middleware/wireless/ethermind/bluetooth/export/eOSAL/: eBT_assert.h eBT_config.h eBT_debug_api.h eBT_fops.h eBT_os.h eBT_serial.h eBT_timer.h
  group bt_ble/bluetooth/export/include
    ../../../../../middleware/wireless/ethermind/bluetooth/export/include/: BT_a2dp_api.h BT_analyzer.h BT_api.h BT_assigned_numbers.h BT_at_parser_api.h BT_att_api.h BT_avctp_api.h BT_avdtp_api.h BT_avrcp_api.h BT_avrcp_ca_api.h BT_bip_api.h BT_bnep_api.h BT_bottom_half.h BT_bpp_api.h BT_common.h BT_ctn_api.h BT_dbase_api.h BT_device_queue.h BT_error.h BT_ftp_api.h BT_gap_api.h BT_gatt_db_api.h BT_hci_api.h BT_hdp_api.h BT_hfp_ag_api.h BT_hfp_unit_api.h BT_hid_device_api.h BT_hid_host_api.h BT_irobex_api.h BT_jpl_api.h BT_map_api.h BT_mcap_api.h BT_obex_api.h BT_opp_api.h BT_pan_api.h BT_pbap_api.h BT_racp.h BT_rfcomm_api.h BT_sap_api.h BT_sdp_api.h BT_security.h BT_sm_api.h BT_smp_api.h BT_snoop.h BT_spp_api.h BT_status.h BT_storage.h BT_version.h fsm_defines.h fsm_engine.h gatt_defines.h hci_transport.h l2cap.h write_task.h
  group bt_ble/bluetooth/export/vendor
    ../../../../../middleware/wireless/ethermind/bluetooth/export/vendor/: vendor_specific_commands.h vendor_specific_init.c vendor_specific_init.h
  group bt_ble/bluetooth/private/protocols/att
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/att/: att.h
  group bt_ble/bluetooth/private/protocols/avctp
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avctp/: avctp.h
  group bt_ble/bluetooth/private/protocols/avdtp
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avdtp/: avdtp.h
  group bt_ble/bluetooth/private/protocols/bnep
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/bnep/: bnep.h
  group bt_ble/bluetooth/private/protocols/dbase
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/dbase/: database.h
  group bt_ble/bluetooth/private/protocols/hci_1.2
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/hci_1.2/: hci_h.h
  group bt_ble/bluetooth/private/protocols/mcap
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/mcap/: mcap.h
  group bt_ble/bluetooth/private/protocols/obex
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/obex/: obex.h
  group bt_ble/bluetooth/private/protocols/rfcomm
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/rfcomm/: rfcomm.h
  group bt_ble/bluetooth/private/protocols/sdp
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sdp/: sdp.h
  group bt_ble/bluetooth/private/protocols/sm
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sm/: sm.h sm_extern.h sm_internal.h
  group bt_ble/bluetooth/private/protocols/smp
    ../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/smp/: smp.h smp_extern.h smp_fsm.h smp_fsm_engine.h smp_internal.h
  group bt_ble/bluetooth/private/utils/aes_cmac
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/aes_cmac/: aes_cmac.h
  group bt_ble/bluetooth/private/utils/at_parser
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/at_parser/: at_parser_hsp_hfp.h
  group bt_ble/bluetooth/private/utils/object_parser
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/object_parser/: object_parser_api.h tokenizer.h
  group bt_ble/bluetooth/private/utils/racp
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/racp/: racp.h
  group bt_ble/bluetooth/private/utils/storage
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/storage/: storage.h
  group bt_ble/bluetooth/private/utils/xml_parser
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/xml_parser/: xml_common_defines.h xml_encoder.h xml_parser.h
  group bt_ble/port/osal/src/freertos
    ../../../../../middleware/wireless/ethermind/port/osal/src/freertos/: EM_assert.h EM_config.c EM_config.h EM_debug.c EM_debug.h EM_debug_api.h EM_debug_internal.h EM_fops.c EM_fops.h EM_os.c EM_os.h EM_serial.c EM_serial.h EM_timer.c EM_timer.h EM_timer_internal.h
  group bt_ble/port/pal/mcux/bluetooth
    ../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth/: BT_assert.h BT_config.h BT_debug.h BT_debug_api.h BT_fops.h BT_os.h BT_status_pl.c BT_storage_pl.c BT_storage_pl.h BT_timer.h btsnoop_pl.c btsnoop_pl.h sco_audio_pl.c sco_audio_pl.h ctn_pl.c ctn_pl.h ftp_pl.c ftp_pl.h hci_uart_internal.h ht_read_task_pl.c map_pl.c map_pl.h obex_pl.c obex_pl.h pbap_pl.c pbap_pl.h write_task_extern_pl.h write_task_pl.c write_task_pl.h littlefs_pl.c littlefs_pl.h fw_loader_uart.c fw_loader_uart.h hci_uart.c hci_uart.h hci_uart_internal.h
  group bt_ble/port/pal/mcux/ethal
    ../../../../../middleware/wireless/ethermind/port/pal/mcux/ethal/: ethal_assert.h ethal_config.c ethal_config.h ethal_debug.c ethal_debug.h ethal_debug_api.h ethal_debug_internal.h ethal_fops.c ethal_fops.h ethal_os.c ethal_os.h ethal_serial.c ethal_serial.h ethal_timer.c ethal_timer.h ethal_timer_internal.h
  group bt_ble/port/pal/mcux/sbc
    ../../../../../middleware/wireless/ethermind/port/pal/mcux/sbc/: sbc_os.h
  group bt_ble/port/pal/mcux
    ../../../../../middleware/wireless/ethermind/port/pal/mcux/: EM_platform.c EM_platform.h
  group bt_ble/bluetooth/private/utils/sbc
    ../../../../../middleware/wireless/ethermind/bluetooth/private/utils/sbc/: sbc_api.h
  group bt_ble/bluetooth/export/extension
    ../../../../../middleware/wireless/ethermind/bluetooth/export/extension/: aes_cmac_pl.c aes_cmac_pl.h BT_common_pl.c BT_common_pl.h device_queue_pl.c device_queue_pl.h sm_pl.c sm_pl.h sm_ssp_pl.c sm_ssp_pl.h smp_pl.c smp_pl.h gatt_db_pl.c gatt_db_pl.h
  group bt_ble/bluetooth/private/lib/config
    ../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/config/: BT_features.h BT_limits.h db_gen.h
  group edgefast/bluetooth/source/impl/ethermind/host
    ../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/host/: bt_pal_att.c bt_pal_eatt.c bt_pal_att_internal.h bt_pal_conn.c bt_pal_conn_internal.h bt_pal_data.c bt_pal_ead.c bt_pal_crypto.c bt_pal_aes_ccm.c bt_pal_crypto_internal.h bt_pal_gatt.c bt_pal_gatt_internal.h bt_pal_hci_core.c bt_pal_hci_core.h bt_pal_adv.c bt_pal_adv.h bt_pal_br.c bt_pal_br.h bt_pal_id.c bt_pal_id.h bt_pal_long_wq.c bt_pal_long_wq.h bt_pal_iso.c bt_pal_iso_internal.h bt_pal_scan.c bt_pal_scan.h bt_pal_ecc.c bt_pal_ecc.h bt_pal_addr.c bt_pal_addr_internal.h bt_pal_buf.c bt_pal_buf_view.h bt_pal_direction.c bt_pal_direction_internal.h bt_pal_hci_ecc.h bt_pal_keys.c bt_pal_keys.h bt_pal_l2cap.c bt_pal_l2cap_internal.h bt_pal_l2cap_br_internal.h bt_pal_l2cap_br_interface.h bt_pal_monitor.c bt_pal_monitor.h bt_pal_rpa.c bt_pal_rpa.h bt_pal_settings.h bt_pal_settings.c bt_pal_smp.c bt_pal_smp_null.c bt_pal_smp.h bt_pal_ssp.h bt_pal_uuid.c
  group edgefast/bluetooth/include/bluetooth
    ../../../../../middleware/edgefast_bluetooth/include/bluetooth/: addr.h att.h bluetooth.h direction.h buf.h l2cap.h conn.h crypto.h gap.h gatt.h hci.h hci_types.h ead.h byteorder.h hci_raw.h hci_vs.h iso.h testing.h uuid.h
  group edgefast/bluetooth/source/impl/ethermind/common
    ../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/common/: addr.c
  group edgefast/bluetooth/source/impl/ethermind/crypto
    ../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/crypto/: bt_crypto.c bt_crypto.h
  group bt_ble/source/impl/ethermind/platform
    ../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/platform/: bt_ble_platform.c bt_ble_platform.h bt_ble_settings.c bt_ble_settings.h host_msd_fatfs.c host_msd_fatfs.h
  group bt_ble/source/impl/ethermind
    ../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/: bt_db_gen.c
  group edgefast/bluetooth/source/impl/ethermind/platform/configs
    ../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/platform/configs/: ffconf.h
  group edgefast/bluetooth/include/sys
    ../../../../../middleware/edgefast_bluetooth/include/sys/: util.h util_internal.h util_loops.h util_macro.h printk.h check.h byteorder.h ring_buffer.h ffs.h slist.h dlist.h atomic.h
  group edgefast/bluetooth/include/zephyr
    ../../../../../middleware/edgefast_bluetooth/include/zephyr/: types.h
  group edgefast/bluetooth/source/porting
    ../../../../../middleware/edgefast_bluetooth/source/porting/: ring_buffer.c porting.c porting.h system_c.h utf8.c
  group edgefast/bluetooth/source/porting/errno
    ../../../../../middleware/edgefast_bluetooth/source/porting/errno/: errno.h
  group edgefast/bluetooth/source/porting/fifo
    ../../../../../middleware/edgefast_bluetooth/source/porting/fifo/: fifo.c fifo.h
  group edgefast/bluetooth/source/porting/lifo
    ../../../../../middleware/edgefast_bluetooth/source/porting/lifo/: lifo.c lifo.h
  group edgefast/bluetooth/source/porting/poll
    ../../../../../middleware/edgefast_bluetooth/source/porting/poll/: poll.c poll.h
  group edgefast/bluetooth/source/porting/queue
    ../../../../../middleware/edgefast_bluetooth/source/porting/queue/: queue.c queue.h
  group edgefast/bluetooth/source/porting/sem
    ../../../../../middleware/edgefast_bluetooth/source/porting/sem/: sem.c sem.h
  group edgefast/bluetooth/source/porting/slab
    ../../../../../middleware/edgefast_bluetooth/source/porting/slab/: slab.c slab.h
  group edgefast/bluetooth/source/porting/slist
    ../../../../../middleware/edgefast_bluetooth/source/porting/slist/: slist.c
  group edgefast/bluetooth/source/porting/spinlock
    ../../../../../middleware/edgefast_bluetooth/source/porting/spinlock/: spinlock.h
  group edgefast/bluetooth/source/porting/thread
    ../../../../../middleware/edgefast_bluetooth/source/porting/thread/: thread.c thread.h
  group edgefast/bluetooth/source/porting/work
    ../../../../../middleware/edgefast_bluetooth/source/porting/work/: work.c work.h
  group edgefast/bluetooth/include/toolchain
    ../../../../../middleware/edgefast_bluetooth/include/toolchain/: common.h gcc.h iar.h armcc.h
  group edgefast/bluetooth/include
    ../../../../../middleware/edgefast_bluetooth/include/: toolchain.h
  group edgefast/bluetooth/source/porting/net
    ../../../../../middleware/edgefast_bluetooth/source/porting/net/: buf.c buf_simple.c
  group edgefast/bluetooth/include/net
    ../../../../../middleware/edgefast_bluetooth/include/net/: buf.h
  group edgefast/bluetooth/porting
    ../../../../../middleware/edgefast_bluetooth/source/porting/: atomic_c.c
  group bt_ble/port/pal/mcux/bluetooth/controller
    ../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth/controller/: controller.h controller_wifi_nxp.c controller_hci_uart.h controller.h controller_k32w.c controller_hci_uart.h
  group bt_ble/port/pal/mcux/bluetooth/controller/k32w061
    ../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth/controller/k32w061/: hci_black_box_bm.bin ot-rcp.bin ot_rcp_ble_hci_bb_bm_2_uart.bin ot_rcp_ble_hci_bb_bm_single_uart.bin readme.txt DK6-RN-0065-Production-Flash-Programmer.pdf hci_black_box_bm.bin JN-SW-4407+DK6+Production+Flash+Programmer+v2282.exe ot-rcp.bin ot_rcp_ble_hci_bb_bm_2_uart.bin ot_rcp_ble_hci_bb_bm_single_uart.bin
  group edgefast/bluetooth/source/impl/ethermind/controller/configs/lwip
    ../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/controller/configs/lwip/: lwipopts.h lwippools.h
  group edgefast/bluetooth/source/impl/ethermind/controller/configs/wifi
    ../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/controller/configs/wifi/: wifi_config.h
  group edgefast/bluetooth/low_power/controller
    ../../../../../middleware/edgefast_bluetooth/low_power/controller/: controller_low_power.h controller_low_power.c controller_low_power_config.h
  group edgefast/bluetooth/source/services
    ../../../../../middleware/edgefast_bluetooth/source/services/: hts.c
  group edgefast/bluetooth/include/bluetooth/services
    ../../../../../middleware/edgefast_bluetooth/include/bluetooth/services/: hts.h
  group freertos/freertos-kernel
    ../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable
    ../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure
    ../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.c port.c portasm.c portasm.h portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/template/ARM_CM33_3_priority_bits
    ../../../../../rtos/freertos/freertos-kernel/template/ARM_CM33_3_priority_bits/: FreeRTOSConfig_Gen.h
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
target central_ht_cm33 flash_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: central_ht_cm33.out
  AfterMake: fromelf.exe --output "$Lcentral_ht.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CFG_BLE, LPUART_RING_BUFFER_SIZE=1024U, PRINTF_ADVANCED_ENABLE=1, SDK_DEBUGCONSOLE_UART=1, SDK_OS_FREE_RTOS, USE_RTOS=1, APPL_USE_STANDARD_IO, CONFIG_ARM=1, EDGEFAST_BT_LITTLEFS_MFLASH, FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0, FSL_FEATURE_FLASH_PAGE_SIZE_BYTES=4096, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, GATT_CLIENT, GATT_DB, HAL_UART_ADAPTER_FIFO=1, IOT_WIFI_ENABLE_SAVE_NETWORK=1, LFS_NO_ERROR=1, LFS_NO_INTRINSICS=1, MMC_DISK_ENABLE, MMC_ENABLED=1, SDIO_ENABLED=1, gMemManagerLight=0, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT595SFFOC_cm33, MIMXRT595S_cm33_SERIES, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING=1, OSA_USED, BOOT_HEADER_ENABLE=1, SERIAL_PORT_TYPE_UART=1, TIMER_PORT_TYPE_CTIMER=1, WIFI_IW612_BOARD_MURATA_2EL_M2, SDK_I2C_BASED_COMPONENT_USED=1, GENERIC_LIST_LIGHT=1, MFLASH_FILE_BASEADDR=7340032, MBEDTLS_CONFIG_FILE='\"ksdk_mbedtls_config.h\"', RPMSG_ADAPTER_NON_BLOCKING_MODE=1, ENABLE_RAM_VECTOR_TABLE, MBEDTLS_MCUX_ELS_PKC_API, REMOTE_CORE_BOOT_ADDRESS=0x02128000, LFS_THREADSAFE=1, LOG_ENABLE_ASYNC_MODE=1, LOG_MAX_ARGUMENT_COUNT=10, LOG_ENABLE_OVERWRITE=1
  c misc: as above
  c include: as above
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_flash.scf
  link misc: as above
