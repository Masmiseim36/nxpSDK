# Keil uVision project tflm_kws_cm33.uvprojx, settings and files
target tflm_kws_cm33 flash_debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tflm_kws_cm33.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: DEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, __STDC_CONSTANT_MACROS, __CLK_TCK=1000000, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, SDK_DEBUGCONSOLE_UART, ARM_MATH_CM33, __FPU_PRESENT=1, TF_LITE_STATIC_MEMORY, MCUXPRESSO_SDK, SDK_I3C_BASED_COMPONENT_USED=1, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8904_ENABLE, DISABLEFLOAT16
  c misc: -ffp-mode=full  -fno-exceptions  -Wno-c++17-extensions  -fno-common  -fdata-sections  -mthumb
  c include: ../source;../source/audio;../source/model;..;../../../../../devices/MIMXRT595S/utilities/debug_console_lite;../../../../../components/i2c;../../../../../components/codec/i2c;../../../../../components/codec/port/wm8904;../../../../../components/codec/port;../../../../../components/codec;../../../../../devices/MIMXRT595S/drivers;../../../../../components/codec/wm8904;../../../../../CMSIS/DSP/Include;../../../../../CMSIS/DSP/PrivateInclude;../../../../../CMSIS/DSP/Source/DistanceFunctions;../../../../../middleware/eiq/tensorflow-lite;../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include;../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp;../../../../../components/lists;../../../../../components/uart;../../../../../devices/MIMXRT595S;../../../flash_config;../../../../../devices/MIMXRT595S/utilities/str;../../../../../middleware/eiq/tensorflow-lite/third_party/ruy;../../../../../CMSIS/Core/Include
  asm define: DEBUG
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_flash.scf
  link misc: ../../../../../middleware/eiq/tensorflow-lite/lib/cm33/mdk/tflm.lib --remove --entry=Reset_Handler --diag_suppress 6314 --predefine="-D__heap_size__=0x8000" --predefine="-D__stack_size__=0x2000"
  group source
    ../source/: demo_info.h audio_data.h demo_config.h demo_info.cpp labels.h main.cpp timer.h timer.c
  group source/model
    ../source/model/: get_top_n.cpp get_top_n.h model.h output_postproc.h model.cpp output_postproc.cpp model_data.h model_ds_cnn_ops_micro.cpp
  group source/audio
    ../source/audio/: audio.h kws_mfcc.cpp kws_mfcc.hpp mfcc.cpp mfcc.hpp audio_stream.h audio_stream.c audio_capture.cpp
  group doc
    ../doc/: off.wav right.wav train.py ds_cnn_s.tflite
    ../: readme.md
  group board
    ../: clock_config.c clock_config.h pin_mux.c pin_mux.h board.c board.h board_init.c board_init.h
    ./: retarget.c
  group utilities
    ../../../../../devices/MIMXRT595S/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c fsl_assert.h
    ../../../../../devices/MIMXRT595S/utilities/str/: fsl_str.c fsl_str.h
  group component/i2c
    ../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_i3c.c
  group codec
    ../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
    ../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../components/codec/wm8904/: fsl_wm8904.h fsl_wm8904.c
  group codec/port/wm8904
    ../../../../../components/codec/port/wm8904/: fsl_codec_wm8904_adapter.c fsl_codec_wm8904_adapter.h
  group codec/port
    ../../../../../components/codec/port/: fsl_codec_adapter.h
  group drivers
    ../../../../../devices/MIMXRT595S/drivers/: fsl_dmic.c fsl_dmic.h fsl_dmic_dma.c fsl_dmic_dma.h fsl_i2c.h fsl_i2c.c fsl_i2s.h fsl_i2s.c fsl_i2s_dma.h fsl_i2s_dma.c fsl_usart.h fsl_usart.c fsl_i3c.h fsl_i3c.c fsl_inputmux.h fsl_inputmux.c fsl_inputmux_connections.h fsl_dma.c fsl_dma.h fsl_cache.c fsl_cache.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_flexcomm.h fsl_flexcomm.c fsl_flexspi.c fsl_flexspi.h fsl_gpio.h fsl_gpio.c fsl_iopctl.h fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_iap.h fsl_iap.c
  group CMSIS/DSP/Include
    ../../../../../CMSIS/DSP/Include/: arm_common_tables.h arm_common_tables_f16.h arm_const_structs.h arm_const_structs_f16.h arm_helium_utils.h arm_math.h arm_math_f16.h arm_math_memory.h arm_math_types.h arm_math_types_f16.h arm_mve_tables.h arm_mve_tables_f16.h arm_vec_math.h arm_vec_math_f16.h
  group CMSIS/DSP/Include/dsp
    ../../../../../CMSIS/DSP/Include/dsp/: basic_math_functions.h basic_math_functions_f16.h bayes_functions.h bayes_functions_f16.h complex_math_functions.h complex_math_functions_f16.h controller_functions.h controller_functions_f16.h debug.h distance_functions.h distance_functions_f16.h fast_math_functions.h fast_math_functions_f16.h filtering_functions.h filtering_functions_f16.h interpolation_functions.h interpolation_functions_f16.h matrix_functions.h matrix_functions_f16.h matrix_utils.h none.h quaternion_math_functions.h statistics_functions.h statistics_functions_f16.h support_functions.h support_functions_f16.h svm_defines.h svm_functions.h svm_functions_f16.h transform_functions.h transform_functions_f16.h utils.h window_functions.h
  group CMSIS/DSP/PrivateInclude
    ../../../../../CMSIS/DSP/PrivateInclude/: arm_sorting.h arm_vec_fft.h arm_vec_filtering.h
  group CMSIS/DSP/Source/BasicMathFunctions
    ../../../../../CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
  group CMSIS/DSP/Source/BayesFunctions
    ../../../../../CMSIS/DSP/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
  group CMSIS/DSP/Source/CommonTables
    ../../../../../CMSIS/DSP/Source/CommonTables/: CommonTables.c CommonTablesF16.c
  group CMSIS/DSP/Source/ComplexMathFunctions
    ../../../../../CMSIS/DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
  group CMSIS/DSP/Source/ControllerFunctions
    ../../../../../CMSIS/DSP/Source/ControllerFunctions/: ControllerFunctions.c
  group CMSIS/DSP/Source/DistanceFunctions
    ../../../../../CMSIS/DSP/Source/DistanceFunctions/: DistanceFunctions.c arm_boolean_distance_template.h DistanceFunctionsF16.c
  group CMSIS/DSP/Source/FastMathFunctions
    ../../../../../CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
  group CMSIS/DSP/Source/FilteringFunctions
    ../../../../../CMSIS/DSP/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
  group CMSIS/DSP/Source/InterpolationFunctions
    ../../../../../CMSIS/DSP/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
  group CMSIS/DSP/Source/MatrixFunctions
    ../../../../../CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
  group CMSIS/DSP/Source/QuaternionMathFunctions
    ../../../../../CMSIS/DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
  group CMSIS/DSP/Source/SVMFunctions
    ../../../../../CMSIS/DSP/Source/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
  group CMSIS/DSP/Source/StatisticsFunctions
    ../../../../../CMSIS/DSP/Source/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
  group CMSIS/DSP/Source/SupportFunctions
    ../../../../../CMSIS/DSP/Source/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
  group CMSIS/DSP/Source/TransformFunctions
    ../../../../../CMSIS/DSP/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
  group CMSIS/DSP/Source/WindowFunctions
    ../../../../../CMSIS/DSP/Source/WindowFunctions/: WindowFunctions.c
  group eiq/tensorflow-lite/tensorflow/lite/micro
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/: debug_log.cpp compatibility.h debug_log.h fake_micro_context.h flatbuffer_utils.h memory_helpers.h micro_allocation_info.h micro_allocator.h micro_arena_constants.h micro_common.h micro_context.h micro_graph.h micro_interpreter.h micro_interpreter_context.h micro_interpreter_graph.h micro_log.h micro_mutable_op_resolver.h micro_op_resolver.h micro_profiler.h micro_profiler_interface.h micro_resource_variable.h micro_time.h micro_utils.h mock_micro_graph.h recording_micro_allocator.h recording_micro_interpreter.h system_setup.h test_helper_custom_ops.h test_helpers.h
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group device
    ../../../../../devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group startup
    ../../../../../devices/MIMXRT595S/arm/: startup_MIMXRT595S_cm33.S
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group eiq/tensorflow-lite
    ../../../../../middleware/eiq/tensorflow-lite/: AUTHORS LICENSE NOTICE ChangeLogKSDK.txt readme.txt
  group eiq/tensorflow-lite/signal/micro/kernels
    ../../../../../middleware/eiq/tensorflow-lite/signal/micro/kernels/: delay_flexbuffers_generated_data.h energy_flexbuffers_generated_data.h fft_flexbuffers_generated_data.h filter_bank_flexbuffers_generated_data.h filter_bank_log_flexbuffers_generated_data.h filter_bank_spectral_subtraction_flexbuffers_generated_data.h framer_flexbuffers_generated_data.h irfft.h overlap_add_flexbuffers_generated_data.h pcan_flexbuffers_generated_data.h rfft.h stacker_flexbuffers_generated_data.h window_flexbuffers_generated_data.h
  group eiq/tensorflow-lite/signal/src
    ../../../../../middleware/eiq/tensorflow-lite/signal/src/: circular_buffer.h complex.h energy.h fft_auto_scale.h filter_bank.h filter_bank_log.h filter_bank_spectral_subtraction.h filter_bank_square_root.h irfft.h log.h max_abs.h msb.h overlap_add.h pcan_argc_fixed.h rfft.h square_root.h window.h
  group eiq/tensorflow-lite/signal/src/kiss_fft_wrappers
    ../../../../../middleware/eiq/tensorflow-lite/signal/src/kiss_fft_wrappers/: kiss_fft_common.h kiss_fft_float.h kiss_fft_int16.h kiss_fft_int32.h
  group eiq/tensorflow-lite/tensorflow/lite
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/: builtin_op_data.h builtin_ops.h context_util.h portable_type_to_tflitetype.h
  group eiq/tensorflow-lite/tensorflow/lite/c
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/c/: builtin_op_data.h c_api_types.h common.h
  group eiq/tensorflow-lite/tensorflow/lite/core
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/: macros.h
  group eiq/tensorflow-lite/tensorflow/lite/core/api
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/api/: error_reporter.h flatbuffer_conversions.h tensor_utils.h
  group eiq/tensorflow-lite/tensorflow/lite/core/c
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/c/: builtin_op_data.h c_api_types.h common.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/: kernel_util.h op_macros.h padding.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/: common.h compatibility.h cppmath.h max.h min.h portable_tensor.h portable_tensor_utils.h quantization_util.h runtime_shape.h strided_slice_logic.h tensor_ctypes.h types.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized/: neon_check.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/: add.h add_n.h arg_min_max.h batch_matmul.h batch_to_space_nd.h binary_function.h broadcast_args.h broadcast_to.h ceil.h comparisons.h concatenation.h conv.h cumsum.h depth_to_space.h depthwiseconv_float.h depthwiseconv_uint8.h dequantize.h div.h elu.h exp.h fill.h floor.h floor_div.h floor_mod.h fully_connected.h hard_swish.h l2normalization.h leaky_relu.h log_softmax.h logistic.h lstm_cell.h maximum_minimum.h mul.h neg.h pad.h pooling.h portable_tensor_utils.h portable_tensor_utils_impl.h prelu.h process_broadcast_shapes.h quantize.h reduce.h requantize.h resize_bilinear.h resize_nearest_neighbor.h round.h select.h slice.h softmax.h space_to_batch_nd.h space_to_depth.h strided_slice.h sub.h tanh.h transpose.h transpose_conv.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops/: add.h conv.h depthwise_conv.h fully_connected.h l2normalization.h logistic.h mean.h mul.h pooling.h tanh.h transpose_conv.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/: activation_utils.h activations.h add.h circular_buffer.h circular_buffer_flexbuffers_generated_data.h conv.h conv_test.h depthwise_conv.h dequantize.h detection_postprocess_flexbuffers_generated_data.h ethosu.h fully_connected.h hard_swish.h kernel_runner.h kernel_util.h leaky_relu.h logical.h logistic.h lstm_eval.h lstm_eval_test.h lstm_shared.h micro_ops.h micro_tensor_utils.h mul.h pad.h pooling.h prelu.h quantize.h reduce.h reshape.h softmax.h strided_slice.h sub.h svdf.h unidirectional_sequence_lstm.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/arena_allocator
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/arena_allocator/: ibuffer_allocator.h non_persistent_arena_buffer_allocator.h persistent_arena_buffer_allocator.h recording_single_arena_buffer_allocator.h single_arena_buffer_allocator.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/memory_planner
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.h linear_memory_planner.h memory_plan_struct.h micro_memory_planner.h non_persistent_buffer_planner_shim.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/tflite_bridge
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/tflite_bridge/: flatbuffer_conversions_bridge.h micro_error_reporter.h
  group eiq/tensorflow-lite/tensorflow/lite/schema
    ../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/schema/: schema_generated.h schema_utils.h
  group eiq/tensorflow-lite/third_party/flatbuffers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/: readme.md LICENSE.txt
  group eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers
    ../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/: allocator.h array.h base.h buffer.h buffer_ref.h default_allocator.h detached_buffer.h flatbuffer_builder.h flatbuffers.h flexbuffers.h stl_emulation.h strings.h struct.h table.h util.h vector.h vector_downward.h verifier.h
  group eiq/tensorflow-lite/third_party/gemmlowp
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/: LICENSE README.md
  group eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint/: fixedpoint.h fixedpoint_neon.h fixedpoint_sse.h
  group eiq/tensorflow-lite/third_party/gemmlowp/internal
    ../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/internal/: detect_platform.h
  group eiq/tensorflow-lite/third_party/ruy
    ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/: LICENSE README.md
  group eiq/tensorflow-lite/third_party/ruy/ruy/profiler
    ../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/ruy/profiler/: instrumentation.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target tflm_kws_cm33 flash_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tflm_kws_cm33.out
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: NDEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, __STDC_CONSTANT_MACROS, __CLK_TCK=1000000, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, SDK_DEBUGCONSOLE_UART, ARM_MATH_CM33, __FPU_PRESENT=1, TF_LITE_STATIC_MEMORY, MCUXPRESSO_SDK, SDK_I3C_BASED_COMPONENT_USED=1, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8904_ENABLE, DISABLEFLOAT16
  c misc: as above
  c include: as above
  asm define: NDEBUG
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_flash.scf
  link misc: as above
