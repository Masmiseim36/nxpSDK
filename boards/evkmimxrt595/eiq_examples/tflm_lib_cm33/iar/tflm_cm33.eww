<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/tflm_cm33.ewp</path>
  </project>
</workspace>
