# Keil uVision project fmstr_example_uart.uvprojx, settings and files
target fmstr_example_uart debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: fmstr_example_uart.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, SDK_DEBUGCONSOLE=1, CPU_MIMXRT595SEVKA=1, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../source;../source/board;../source/example_data;../../../../../devices/MIMXRT595S/drivers;../../../../../middleware/freemaster/src/common;../../../../../devices/MIMXRT595S/utilities/str;../../../../../devices/MIMXRT595S/utilities/debug_console_lite;../../../../../devices/MIMXRT595S;../../../../../components/uart;../../../../../components/lists;../../../flash_config;../../../../../middleware/freemaster/src/platforms/gen32le;../../../../../middleware/freemaster/src/drivers/mcuxsdk/can;../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial;../../../../../CMSIS/Core/Include
  asm define: DEBUG
  asm include: ../source/board
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_ram.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314
  group source
    ../source/: main.c freemaster_cfg.h freemaster_example.c freemaster_example.h
  group board
    ../source/board/: clock_config.c clock_config.h pin_mux.c pin_mux.h board.c board.h
  group doc
    ../: readme.txt
  group example_data
    ../source/example_data/: data_example_pmp.h data_img_logo.h data_img_file.h data_img_fmstrlogo.h data_html_index.h example_data.h
  group drivers
    ../../../../../devices/MIMXRT595S/drivers/: fsl_usart.h fsl_usart.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_power.h fsl_power.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c fsl_iap.h fsl_iap.c
  group freemaster
    ../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_defcfg.h freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h freemaster_can.c freemaster_can.h freemaster_sha.c freemaster_pdbdm.c freemaster_serial.c freemaster_serial.h freemaster_net.c freemaster_net.h
  group utilities
    ../../../../../devices/MIMXRT595S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT595S/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c fsl_assert.h
  group device
    ../../../../../devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group startup
    ../../../../../devices/MIMXRT595S/arm/: startup_MIMXRT595S_cm33.S
  group freemaster/platforms
    ../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group freemaster/drivers
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mscan.c freemaster_mscan.h freemaster_mcan.c freemaster_mcan.h
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_usb.c freemaster_serial_usb.h
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/network/: freemaster_net_segger_rtt.c freemaster_net_segger_rtt.h freemaster_net_lwip_udp.c freemaster_net_lwip_udp.h freemaster_net_lwip_tcp.c freemaster_net_lwip_tcp.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target fmstr_example_uart flash_debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: fmstr_example_uart.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, SDK_DEBUGCONSOLE=1, CPU_MIMXRT595SEVKA=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: DEBUG
  asm include: ../source/board
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314
target fmstr_example_uart release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: fmstr_example_uart.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, SDK_DEBUGCONSOLE=1, CPU_MIMXRT595SEVKA=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG
  asm include: ../source/board
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_ram.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314
target fmstr_example_uart flash_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: fmstr_example_uart.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, SDK_DEBUGCONSOLE=1, CPU_MIMXRT595SEVKA=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG
  asm include: ../source/board
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314
