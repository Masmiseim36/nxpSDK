# Keil uVision project fmstr_example_usb_cdc_cm33.uvprojx, settings and files
target fmstr_example_usb_cdc_cm33 debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: fmstr_example_usb_cdc_cm33.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, USB_STACK_USE_DEDICATED_RAM=1, USB_STACK_BM=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT595SFFOC_cm33, MIMXRT595S_cm33_SERIES, OSA_USED, BOOT_HEADER_ENABLE=1, USE_RTOS=0
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../flash_config;../../../../../CMSIS/Core/Include;../../../../../CMSIS/Core/Include/m-profile;../../../../../devices/MIMXRT595S;../../../../../devices/MIMXRT595S/periph;../../../../../devices/MIMXRT595S/drivers;../../../../../devices/MIMXRT595S/utilities/debug_console_lite;../../../../../components/lists;../../../../../devices/MIMXRT595S/utilities/str;../../../../../components/uart;../../../../../components/osa;../../../../../middleware/usb/include;../../../../../middleware/usb/device;../../../../../middleware/usb/config/device/ip3511hs;../../../../../middleware/usb/device/class;../../../../../middleware/usb/phy;../../../../../middleware/freemaster/src/common;../../../../../middleware/freemaster/src/platforms/gen32le;../../../../../middleware/freemaster/src/drivers/mcuxsdk/can;../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT595SFFOC_cm33, MIMXRT595S_cm33_SERIES, OSA_USED
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_ram.scf
  link misc: --remove --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: main.c freemaster_cfg.h freemaster_example.h data_example_pmp.h data_html_index.h data_img_file.h data_img_fmstrlogo.h data_img_logo.h example_data.h freemaster_example.c freemaster_usb.h freemaster_usb.c freemaster_usb_device_descriptor.h freemaster_usb_device_descriptor.c usb_device_descriptor.h fsl_os_abstraction_config.h mcux_config.h usb_device_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv8m_mpu.h
  group device
    ../../../../../devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_COMMON.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group device/periph
    ../../../../../devices/MIMXRT595S/periph/: PERI_ADC.h PERI_AHB_SECURE_CTRL.h PERI_AXI_SWITCH_AMIB.h PERI_AXI_SWITCH_ASIB.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CASPER.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CMP.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUGGER_MAILBOX.h PERI_DMA.h PERI_DMIC.h PERI_FLEXCOMM.h PERI_FLEXIO.h PERI_FLEXSPI.h PERI_FREQME.h PERI_GPIO.h PERI_HASHCRYPT.h PERI_I2C.h PERI_I2S.h PERI_I3C.h PERI_INPUTMUX.h PERI_IOPCTL.h PERI_LCDIF.h PERI_MIPI_DSI_HOST.h PERI_MRT.h PERI_MU.h PERI_OCOTP.h PERI_OSTIMER.h PERI_OTFAD.h PERI_PINT.h PERI_PMC.h PERI_POWERQUAD.h PERI_PUF.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RTC.h PERI_SCT.h PERI_SEMA42.h PERI_SPI.h PERI_SYSCTL0.h PERI_SYSCTL1.h PERI_TRNG.h PERI_USART.h PERI_USBHSD.h PERI_USBHSDCD.h PERI_USBHSH.h PERI_USBPHY.h PERI_USDHC.h PERI_UTICK.h PERI_WWDT.h
  group startup/arm
    ../../../../../devices/MIMXRT595S/arm/: startup_MIMXRT595S_cm33.S
  group drivers
    ../../../../../devices/MIMXRT595S/drivers/: fsl_clock.c fsl_clock.h fsl_dsp.c fsl_dsp.h fsl_i2s_bridge.c fsl_i2s_bridge.h fsl_inputmux_connections.h fsl_memory.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_soc_mipi_dsi.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_flexcomm.h fsl_flexcomm.c fsl_usart.h fsl_usart.c fsl_flexspi.c fsl_flexspi.h fsl_iap.h fsl_iap.c fsl_gpio.h fsl_gpio.c fsl_iopctl.h
  group utilities
    ../../../../../devices/MIMXRT595S/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
    ../../../../../devices/MIMXRT595S/utilities/: fsl_memcpy.S
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group utilities/str
    ../../../../../devices/MIMXRT595S/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../devices/MIMXRT595S/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c fsl_os_abstraction.h
  group usb/include
    ../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group usb/device
    ../../../../../middleware/usb/device/: usb_device.h usb_device_lpcip3511.c usb_device_lpcip3511.h usb_device_dci.c usb_device_dci.h usb_device_ch9.c usb_device_ch9.h
  group usb/device/class
    ../../../../../middleware/usb/device/class/: usb_device_class.c usb_device_class.h usb_device_cdc_acm.c usb_device_cdc_acm.h
  group usb/phy
    ../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group freemaster/src/common
    ../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_defcfg.h freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h freemaster_can.c freemaster_can.h freemaster_sha.c freemaster_pdbdm.c freemaster_serial.c freemaster_serial.h freemaster_net.c freemaster_net.h
  group freemaster/src/platforms/gen32le
    ../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group freemaster/src/drivers/mcuxsdk/can
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcanfd.h freemaster_flexcanfd.c freemaster_flexcan.h freemaster_mscan.c freemaster_mscan.h freemaster_mcan.c freemaster_mcan.h
  group freemaster/src/drivers/mcuxsdk/serial
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_usb.c freemaster_serial_usb.h
  group freemaster/src/drivers/mcuxsdk/network
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/network/: freemaster_net_segger_rtt.c freemaster_net_segger_rtt.h freemaster_net_lwip_udp.c freemaster_net_lwip_udp.h freemaster_net_lwip_tcp.c freemaster_net_lwip_tcp.h
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
target fmstr_example_usb_cdc_cm33 flash_debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: fmstr_example_usb_cdc_cm33.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: as above
  c include: as above
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_flash.scf
  link misc: as above
target fmstr_example_usb_cdc_cm33 release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: fmstr_example_usb_cdc_cm33.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, USB_STACK_USE_DEDICATED_RAM=1, USB_STACK_BM=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT595SFFOC_cm33, MIMXRT595S_cm33_SERIES, OSA_USED, BOOT_HEADER_ENABLE=1, USE_RTOS=0
  c misc: as above
  c include: as above
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_ram.scf
  link misc: as above
target fmstr_example_usb_cdc_cm33 flash_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: fmstr_example_usb_cdc_cm33.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: as above
  c include: as above
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_flash.scf
  link misc: as above
