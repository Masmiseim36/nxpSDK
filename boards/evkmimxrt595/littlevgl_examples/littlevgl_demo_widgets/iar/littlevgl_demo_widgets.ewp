# IAR project littlevgl_demo_widgets.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT595S_M33 NXP MIMXRT595S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; SDK_I2C_BASED_COMPONENT_USED=1; LV_CONF_INCLUDE_SIMPLE=1; LV_EX_CONF_INCLUDE_SIMPLE=1; SDK_I2C_BASED_COMPONENT_USED=1; VG_RESOLVE_ENGINE=0; VG_PE_COLOR_KEY=0; VG_IM_INDEX_FORMAT=0; VG_AYUV_INPUT_OUTPUT=0; VG_DOUBLE_IMAGE=0; VG_RECTANGLE_STRIP_MODE=0; VG_MMU=0; VG_IM_FILTER=0; VG_IM_YUV_PACKET=1; VG_IM_YUV_PLANAR=0; VG_PE_YUV_PACKET=1; VG_TARGET_TILED=1; VG_COMMAND_CALL=1; VG_SHARE_BUFFER_IM_16K=0; VG_OFFLINE_MODE=0; VG_RESOLUTION_2880=0; VG_PE_PREMULTIPLY=0; VG_POST_CONVERTER=0; VG_PRE_CONVERTER=0; VG_RENDER_BY_MESH=0; VG_TARGET_FAST_CLEAR=0; VG_BUFFER_NUMBER_OF_TARGET=0; VG_VIDEO_CLEAR_CONTROL=0; VG_VIDEO_CONTROL=0; VGLITE_TST_FIRMWARE=0; VG_LITE_SYS_GPU_CTRL=0; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../middleware/littlevgl/lv_examples/src/lv_demo_widgets; ../../../../../middleware/littlevgl/lv_examples; ../..; ../../../../../devices/MIMXRT595S/drivers; ../../../../../components/ssd1963; ../../../../../components/video/display/dbi; ../../../../../components/video/display/dbi/flexio; ../../../../../components/video/display/dc/ssd1963; ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../components/video/display/dc/lcdif; ../../../../../components/video; ../../../../../components/video/display; ../../../../../components/video/display/rm68191; ../../../../../components/video/display/mipi_dsi_cmd; ../../../../../components/video/display/rm68200; ../../../../../components/video/display/rm67162; ../../../../../components/video/display/dc/dsi_cmd; ../../../../../components/ft3267; ../../../../../components/gt911; ../../../../../components/ft5406; ../../../../../middleware/vglite/inc; ../../../../../middleware/vglite/font; ../../../../../middleware/vglite/font/mcufont/decoder; ../../../../../middleware/vglite/VGLite/rtos; ../../../../../middleware/vglite/VGLiteKernel; ../../../../../middleware/vglite/VGLiteKernel/rtos; ../../../../../middleware/littlevgl/lvgl; ../../../../../middleware/littlevgl/lvgl/src; ../../../../../middleware/littlevgl; ../../../../../devices/MIMXRT595S; ../../../../../devices/MIMXRT595S/utilities/str; ../../../../../devices/MIMXRT595S/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../flash_config; ../../../../../CMSIS/Include; ../../../../../components/video/display/dc; ../../../../../rtos/freertos/freertos_kernel/include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: littlevgl_demo_widgets.out
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT595SFFOC_cm33; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; SDK_I2C_BASED_COMPONENT_USED=1; LV_CONF_INCLUDE_SIMPLE=1; LV_EX_CONF_INCLUDE_SIMPLE=1; SDK_I2C_BASED_COMPONENT_USED=1; VG_RESOLVE_ENGINE=0; VG_PE_COLOR_KEY=0; VG_IM_INDEX_FORMAT=0; VG_AYUV_INPUT_OUTPUT=0; VG_DOUBLE_IMAGE=0; VG_RECTANGLE_STRIP_MODE=0; VG_MMU=0; VG_IM_FILTER=0; VG_IM_YUV_PACKET=1; VG_IM_YUV_PLANAR=0; VG_PE_YUV_PACKET=1; VG_TARGET_TILED=1; VG_COMMAND_CALL=1; VG_SHARE_BUFFER_IM_16K=0; VG_OFFLINE_MODE=0; VG_RESOLUTION_2880=0; VG_PE_PREMULTIPLY=0; VG_POST_CONVERTER=0; VG_PRE_CONVERTER=0; VG_RENDER_BY_MESH=0; VG_TARGET_FAST_CLEAR=0; VG_BUFFER_NUMBER_OF_TARGET=0; VG_VIDEO_CLEAR_CONTROL=0; VG_VIDEO_CONTROL=0; VGLITE_TST_FIRMWARE=0; VG_LITE_SYS_GPU_CTRL=0; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; SDK_I2C_BASED_COMPONENT_USED=1; LV_CONF_INCLUDE_SIMPLE=1; LV_EX_CONF_INCLUDE_SIMPLE=1; SDK_I2C_BASED_COMPONENT_USED=1; VG_RESOLVE_ENGINE=0; VG_PE_COLOR_KEY=0; VG_IM_INDEX_FORMAT=0; VG_AYUV_INPUT_OUTPUT=0; VG_DOUBLE_IMAGE=0; VG_RECTANGLE_STRIP_MODE=0; VG_MMU=0; VG_IM_FILTER=0; VG_IM_YUV_PACKET=1; VG_IM_YUV_PLANAR=0; VG_PE_YUV_PACKET=1; VG_TARGET_TILED=1; VG_COMMAND_CALL=1; VG_SHARE_BUFFER_IM_16K=0; VG_OFFLINE_MODE=0; VG_RESOLUTION_2880=0; VG_PE_PREMULTIPLY=0; VG_POST_CONVERTER=0; VG_PRE_CONVERTER=0; VG_RENDER_BY_MESH=0; VG_TARGET_FAST_CLEAR=0; VG_BUFFER_NUMBER_OF_TARGET=0; VG_VIDEO_CLEAR_CONTROL=0; VG_VIDEO_CONTROL=0; VGLITE_TST_FIRMWARE=0; VG_LITE_SYS_GPU_CTRL=0; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; SDK_I2C_BASED_COMPONENT_USED=1; LV_CONF_INCLUDE_SIMPLE=1; LV_EX_CONF_INCLUDE_SIMPLE=1; SDK_I2C_BASED_COMPONENT_USED=1; VG_RESOLVE_ENGINE=0; VG_PE_COLOR_KEY=0; VG_IM_INDEX_FORMAT=0; VG_AYUV_INPUT_OUTPUT=0; VG_DOUBLE_IMAGE=0; VG_RECTANGLE_STRIP_MODE=0; VG_MMU=0; VG_IM_FILTER=0; VG_IM_YUV_PACKET=1; VG_IM_YUV_PLANAR=0; VG_PE_YUV_PACKET=1; VG_TARGET_TILED=1; VG_COMMAND_CALL=1; VG_SHARE_BUFFER_IM_16K=0; VG_OFFLINE_MODE=0; VG_RESOLUTION_2880=0; VG_PE_PREMULTIPLY=0; VG_POST_CONVERTER=0; VG_PRE_CONVERTER=0; VG_RENDER_BY_MESH=0; VG_TARGET_FAST_CLEAR=0; VG_BUFFER_NUMBER_OF_TARGET=0; VG_VIDEO_CLEAR_CONTROL=0; VG_VIDEO_CONTROL=0; VGLITE_TST_FIRMWARE=0; VG_LITE_SYS_GPU_CTRL=0; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_flash.icf
  group board
    ../: display_support.h display_support.c pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
    ../../: littlevgl_support.h littlevgl_support.c
  group source
    ../: littlevgl_demo_widgets.c FreeRTOSConfig.h lv_conf.h lv_ex_conf.h
  group littlevgl/lv_examples
    ../../../../../middleware/littlevgl/lv_examples/: lv_examples.h
  group littlevgl/lv_examples/src/lv_demo_widgets
    ../../../../../middleware/littlevgl/lv_examples/src/lv_demo_widgets/: lv_demo_widgets.c lv_demo_widgets.h
  group littlevgl/lvgl
    ../../../../../middleware/littlevgl/lvgl/: lvgl.h
  group littlevgl/lvgl/src
    ../../../../../middleware/littlevgl/lvgl/src/: lv_api_map.h lv_conf_internal.h
  group littlevgl/lvgl/src/lv_core
    ../../../../../middleware/littlevgl/lvgl/src/lv_core/: lv_disp.c lv_disp.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_obj.c lv_obj.h lv_obj_style_dec.h lv_refr.c lv_refr.h lv_style.c lv_style.h
  group littlevgl/lvgl/src/lv_draw
    ../../../../../middleware/littlevgl/lvgl/src/lv_draw/: lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_blend.c lv_draw_blend.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
  group littlevgl/lvgl/src/lv_font
    ../../../../../middleware/littlevgl/lvgl/src/lv_font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_loader.c lv_font_loader.h lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_symbol_def.h
  group littlevgl/lvgl/src/lv_gpu
    ../../../../../middleware/littlevgl/lvgl/src/lv_gpu/: lv_gpu_stm32_dma2d.h lv_gpu_nxp_pxp.h lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.h lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_vglite.h lv_gpu_nxp_vglite.c
  group littlevgl/lvgl/src/lv_hal
    ../../../../../middleware/littlevgl/lvgl/src/lv_hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group littlevgl/lvgl/src/lv_misc
    ../../../../../middleware/littlevgl/lvgl/src/lv_misc/: lv_anim.c lv_anim.h lv_area.c lv_area.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_debug.c lv_debug.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_task.c lv_task.h lv_templ.c lv_templ.h lv_txt.c lv_txt.h lv_txt_ap.c lv_txt_ap.h lv_types.h lv_utils.c lv_utils.h
  group littlevgl/lvgl/src/lv_themes
    ../../../../../middleware/littlevgl/lvgl/src/lv_themes/: lv_theme.c lv_theme.h lv_theme_empty.c lv_theme_empty.h lv_theme_material.c lv_theme_material.h lv_theme_mono.c lv_theme_mono.h lv_theme_template.c lv_theme_template.h
  group littlevgl/lvgl/src/lv_widgets
    ../../../../../middleware/littlevgl/lvgl/src/lv_widgets/: lv_anim_img.c lv_anim_img.h lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnmatrix.c lv_btnmatrix.h lv_calendar.c lv_calendar.h lv_canvas.c lv_canvas.h lv_chart.c lv_chart.h lv_checkbox.c lv_checkbox.h lv_cont.c lv_cont.h lv_cpicker.c lv_cpicker.h lv_dropdown.c lv_dropdown.h lv_gauge.c lv_gauge.h lv_img.c lv_img.h lv_imgbtn.c lv_imgbtn.h lv_keyboard.c lv_keyboard.h lv_label.c lv_label.h lv_led.c lv_led.h lv_line.c lv_line.h lv_linemeter.c lv_linemeter.h lv_list.c lv_list.h lv_msgbox.c lv_msgbox.h lv_objmask.c lv_objmask.h lv_objx_templ.c lv_objx_templ.h lv_page.c lv_page.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_spinbox.c lv_spinbox.h lv_spinner.c lv_spinner.h lv_switch.c lv_switch.h lv_table.c lv_table.h lv_tabview.c lv_tabview.h lv_textarea.c lv_textarea.h lv_tileview.c lv_tileview.h lv_win.c lv_win.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT595S/drivers/: fsl_flexio.c fsl_flexio.h fsl_flexio_mculcd.c fsl_flexio_mculcd.h fsl_dma.c fsl_dma.h fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_power.h fsl_power.c fsl_inputmux.h fsl_inputmux.c fsl_flexio_mculcd_smartdma.c fsl_flexio_mculcd_smartdma.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_lcdif.h fsl_lcdif.c fsl_i2c.h fsl_i2c.c fsl_mipi_dsi_smartdma.c fsl_mipi_dsi_smartdma.h fsl_common.h fsl_common.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_reset.h fsl_reset.c fsl_smartdma.h fsl_smartdma.c fsl_smartdma_prv.h fsl_inputmux_connections.h fsl_iap.h fsl_iap.c
  group lcdc
    ../../../../../components/ssd1963/: fsl_ssd1963.h fsl_ssd1963.c
  group video
    ../../../../../components/video/display/dbi/: fsl_dbi.h
    ../../../../../components/video/display/dbi/flexio/: fsl_dbi_flexio_smartdma.h fsl_dbi_flexio_smartdma.c
    ../../../../../components/video/display/dc/ssd1963/: fsl_dc_fb_ssd1963.h fsl_dc_fb_ssd1963.c
    ../../../../../components/video/display/dc/lcdif/: fsl_dc_fb_lcdif.h fsl_dc_fb_lcdif.c
    ../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../components/video/display/: fsl_display.h
    ../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
    ../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../components/video/display/rm67162/: fsl_rm67162.h fsl_rm67162.c
    ../../../../../components/video/display/dc/dsi_cmd/: fsl_dc_fb_dsi_cmd.h fsl_dc_fb_dsi_cmd.c
    ../../../../../components/video/display/dc/: fsl_dc_fb.h
  group freertos/freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s portmacro.h portasm.h
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos_kernel/include
    ../../../../../rtos/freertos/freertos_kernel/include/: croutine.h StackMacros.h atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group touchpanel
    ../../../../../components/ft3267/: fsl_ft3267.h fsl_ft3267.c
    ../../../../../components/gt911/: fsl_gt911.h fsl_gt911.c
    ../../../../../components/ft5406/: fsl_ft5406.h fsl_ft5406.c
  group vglite/inc
    ../../../../../middleware/vglite/inc/: vg_lite.h vg_lite_hal.h vg_lite_text.h
  group vglite/VGLite
    ../../../../../middleware/vglite/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c
  group vglite/VGLite/rtos
    ../../../../../middleware/vglite/VGLite/rtos/: vg_lite_os.h vg_lite_os.c
  group vglite/font
    ../../../../../middleware/vglite/font/: buf_reader.c buf_reader.h fonts.h rle_font_read.c vft_debug.c vft_debug.h vft_draw.c vft_draw.h vg_lite_text.c
  group vglite/font/mcufont/decoder
    ../../../../../middleware/vglite/font/mcufont/decoder/: mcufont.h mf_bwfont.c mf_bwfont.h mf_config.h mf_encoding.c mf_encoding.h mf_font.c mf_font.h mf_justify.c mf_justify.h mf_kerning.c mf_kerning.h mf_rlefont.c mf_rlefont.h mf_scaledfont.c mf_scaledfont.h mf_wordwrap.c mf_wordwrap.h
  group vglite/VGLiteKernel
    ../../../../../middleware/vglite/VGLiteKernel/: vg_lite_hw.h vg_lite_kernel.h vg_lite_kernel.c
  group vglite/VGLiteKernel/rtos
    ../../../../../middleware/vglite/VGLiteKernel/rtos/: vg_lite_hal.c vg_lite_platform.h
  group device
    ../../../../../devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group utilities
    ../../../../../devices/MIMXRT595S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT595S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT595S/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group startup
    ../../../../../devices/MIMXRT595S/iar/: startup_MIMXRT595S_cm33.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm33.h tz_context.h mpu_armv8.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
