# IAR project lvgl_demo_benchmark_bm.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT595S_M33 NXP MIMXRT595S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; SDK_I2C_BASED_COMPONENT_USED=1; LV_CONF_INCLUDE_SIMPLE=1; MCUXPRESSO_SDK; LV_CONF_INCLUDE_SIMPLE
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pa089,Go029,Pe188,Pe111,Pe236,Pe546
  ICCARM.CCIncludePath2: ..; ../..; ../../../../../devices/MIMXRT595S/drivers; ../../../../../components/ssd1963; ../../../../../components/video/display/dbi; ../../../../../components/video/display/dbi/flexio; ../../../../../components/video/display/dc/ssd1963; ../../../../../components/video/display/dc/lcdif; ../../../../../components/video; ../../../../../components/video/display; ../../../../../components/video/display/rm68191; ../../../../../components/video/display/mipi_dsi_cmd; ../../../../../components/video/display/rm68200; ../../../../../components/video/display/rm67162; ../../../../../components/video/display/dc/dsi_cmd; ../../../../../components/ft3267; ../../../../../components/gt911; ../../../../../components/ft5406; ../../../../../devices/MIMXRT595S/utilities/debug_console_lite; ../../../../../components/gpio; ../../../../../components/video/display/hx8394; ../../../../../middleware/lvgl/lvgl/demos; ../../../../../middleware/lvgl/lvgl/demos/benchmark; ../../../../../middleware/lvgl/lvgl; ../../../../../middleware/lvgl/lvgl/src; ../../../../../middleware/lvgl; ../../../../../devices/MIMXRT595S; ../../../../../components/uart; ../../../../../components/lists; ../../../flash_config; ../../../../../components/video/display/dc; ../../../../../devices/MIMXRT595S/utilities/str; ../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: lvgl_demo_benchmark_bm.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT595SFFOC_cm33; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; SDK_I2C_BASED_COMPONENT_USED=1; LV_CONF_INCLUDE_SIMPLE=1; MCUXPRESSO_SDK; LV_CONF_INCLUDE_SIMPLE
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; SDK_I2C_BASED_COMPONENT_USED=1; LV_CONF_INCLUDE_SIMPLE=1; MCUXPRESSO_SDK; LV_CONF_INCLUDE_SIMPLE
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; SDK_I2C_BASED_COMPONENT_USED=1; LV_CONF_INCLUDE_SIMPLE=1; MCUXPRESSO_SDK; LV_CONF_INCLUDE_SIMPLE
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_flash.icf
  group board
    ../: display_support.h display_support.c pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h lvgl_support.h lvgl_support.c
  group source
    ../: lvgl_demo_benchmark_bm.c lv_conf.h
    ../../: lvgl_demo_utils.h lvgl_demo_utils.c
  group doc
    ../: readme.md
  group drivers
    ../../../../../devices/MIMXRT595S/drivers/: fsl_flexio.c fsl_flexio.h fsl_flexio_mculcd.c fsl_flexio_mculcd.h fsl_dma.c fsl_dma.h fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_power.h fsl_power.c fsl_inputmux.h fsl_inputmux.c fsl_flexio_mculcd_smartdma.c fsl_flexio_mculcd_smartdma.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_lcdif.h fsl_lcdif.c fsl_i2c.h fsl_i2c.c fsl_mipi_dsi_smartdma.c fsl_mipi_dsi_smartdma.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_reset.h fsl_reset.c fsl_inputmux_connections.h fsl_smartdma.h fsl_smartdma.c fsl_smartdma_prv.h fsl_smartdma_rt500.c fsl_smartdma_rt500.h fsl_smartdma_mcxn.c fsl_smartdma_mcxn.h fsl_soc_mipi_dsi.h fsl_iap.h fsl_iap.c
  group lcdc
    ../../../../../components/ssd1963/: fsl_ssd1963.h fsl_ssd1963.c
  group video
    ../../../../../components/video/display/dbi/: fsl_dbi.h fsl_dbi.c
    ../../../../../components/video/display/dbi/flexio/: fsl_dbi_flexio_smartdma.h fsl_dbi_flexio_smartdma.c
    ../../../../../components/video/display/dc/ssd1963/: fsl_dc_fb_ssd1963.h fsl_dc_fb_ssd1963.c
    ../../../../../components/video/display/dc/lcdif/: fsl_dc_fb_lcdif.h fsl_dc_fb_lcdif.c
    ../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../components/video/display/: fsl_display.h
    ../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
    ../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../components/video/display/rm67162/: fsl_rm67162.h fsl_rm67162.c
    ../../../../../components/video/display/dc/dsi_cmd/: fsl_dc_fb_dsi_cmd.h fsl_dc_fb_dsi_cmd.c
    ../../../../../components/video/display/hx8394/: fsl_hx8394.h fsl_hx8394.c
    ../../../../../components/video/display/dc/: fsl_dc_fb.h
  group touchpanel
    ../../../../../components/ft3267/: fsl_ft3267.h fsl_ft3267.c
    ../../../../../components/gt911/: fsl_gt911.h fsl_gt911.c
    ../../../../../components/ft5406/: fsl_ft5406.h fsl_ft5406.c
  group utilities
    ../../../../../devices/MIMXRT595S/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c fsl_assert.h
    ../../../../../devices/MIMXRT595S/utilities/str/: fsl_str.c fsl_str.h
  group component/gpio
    ../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_rt_gpio.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group lvgl/lvgl
    ../../../../../middleware/lvgl/lvgl/: lvgl.h
  group lvgl/lvgl/demos
    ../../../../../middleware/lvgl/lvgl/demos/: lv_demos.h
  group lvgl/lvgl/demos/benchmark
    ../../../../../middleware/lvgl/lvgl/demos/benchmark/: lv_demo_benchmark.c lv_demo_benchmark.h
  group lvgl/lvgl/demos/benchmark/assets
    ../../../../../middleware/lvgl/lvgl/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
  group lvgl/lvgl/src
    ../../../../../middleware/lvgl/lvgl/src/: lvgl.h lv_conf_kconfig.h lv_api_map.h lv_conf_internal.h
  group lvgl/lvgl/src/core
    ../../../../../middleware/lvgl/lvgl/src/core/: lv_disp.c lv_disp.h lv_event.c lv_event.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_indev_scroll.c lv_indev_scroll.h lv_obj.c lv_obj_class.c lv_obj_class.h lv_obj_draw.c lv_obj_draw.h lv_obj.h lv_obj_pos.c lv_obj_pos.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_style.c lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_style.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_theme.c lv_theme.h
  group lvgl/lvgl/src/draw
    ../../../../../middleware/lvgl/lvgl/src/draw/: lv_draw.c lv_draw_layer.c lv_draw_layer.h lv_draw_transform.c lv_draw_transform.h lv_draw_arc.c lv_draw_arc.h lv_draw.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
  group lvgl/lvgl/src/draw/arm2d
    ../../../../../middleware/lvgl/lvgl/src/draw/arm2d/: lv_gpu_arm2d.h
  group lvgl/lvgl/src/draw/swm341_dma2d
    ../../../../../middleware/lvgl/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.h
  group lvgl/lvgl/src/draw/nxp/pxp
    ../../../../../middleware/lvgl/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp.h lv_draw_pxp_blend.c lv_draw_pxp_blend.h lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp.h lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp_osa.h
  group lvgl/lvgl/src/draw/nxp/vglite
    ../../../../../middleware/lvgl/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite.h lv_draw_vglite_blend.c lv_draw_vglite_blend.h lv_draw_vglite_rect.c lv_draw_vglite_rect.h lv_draw_vglite_line.c lv_draw_vglite_line.h lv_draw_vglite_arc.c lv_draw_vglite_arc.h lv_vglite_buf.c lv_vglite_buf.h lv_vglite_utils.c lv_vglite_utils.h
  group lvgl/lvgl/src/draw/sdl
    ../../../../../middleware/lvgl/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl.h lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_composite.h lv_draw_sdl_img.c lv_draw_sdl_img.h lv_draw_sdl_label.c lv_draw_sdl_mask.c lv_draw_sdl_mask.h lv_draw_sdl_polygon.c lv_draw_sdl_priv.h lv_draw_sdl_rect.c lv_draw_sdl_rect.h lv_draw_sdl_stack_blur.c lv_draw_sdl_stack_blur.h lv_draw_sdl_texture_cache.c lv_draw_sdl_texture_cache.h lv_draw_sdl_utils.c lv_draw_sdl_utils.h lv_draw_sdl_line.c lv_draw_sdl_layer.c lv_draw_sdl_layer.h
  group lvgl/lvgl/src/draw/stm32_dma2d
    ../../../../../middleware/lvgl/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c lv_gpu_stm32_dma2d.h
  group lvgl/lvgl/src/draw/renesas
    ../../../../../middleware/lvgl/lvgl/src/draw/renesas/: lv_gpu_d2_ra6m3.h lv_gpu_d2_ra6m3.c lv_gpu_d2_draw_label.c
  group lvgl/lvgl/src/draw/sw
    ../../../../../middleware/lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw.h lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_blend.h lv_draw_sw_dither.c lv_draw_sw_dither.h lv_draw_sw_gradient.c lv_draw_sw_gradient.h lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c lv_draw_sw_layer.c
  group lvgl/lvgl/src/font
    ../../../../../middleware/lvgl/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font.h lv_font_loader.c lv_font_loader.h lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_symbol_def.h
  group lvgl/lvgl/src/hal
    ../../../../../middleware/lvgl/lvgl/src/hal/: lv_hal_disp.c lv_hal_disp.h lv_hal.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group lvgl/lvgl/src/misc
    ../../../../../middleware/lvgl/lvgl/src/misc/: lv_anim.c lv_anim.h lv_anim_timeline.c lv_anim_timeline.h lv_area.c lv_area.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_style.c lv_style_gen.c lv_style_gen.h lv_style.h lv_templ.c lv_templ.h lv_timer.c lv_timer.h lv_tlsf.c lv_tlsf.h lv_txt_ap.c lv_txt_ap.h lv_txt.c lv_txt.h lv_types.h lv_utils.c lv_utils.h lv_lru.c lv_lru.h
  group lvgl/lvgl/src/widgets
    ../../../../../middleware/lvgl/lvgl/src/widgets/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnmatrix.c lv_btnmatrix.h lv_canvas.c lv_canvas.h lv_checkbox.c lv_checkbox.h lv_dropdown.c lv_dropdown.h lv_img.c lv_img.h lv_label.c lv_label.h lv_line.c lv_line.h lv_objx_templ.c lv_objx_templ.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_switch.c lv_switch.h lv_table.c lv_table.h lv_textarea.c lv_textarea.h
  group lvgl/lvgl/src/extra
    ../../../../../middleware/lvgl/lvgl/src/extra/: lv_extra.c lv_extra.h
  group lvgl/lvgl/src/extra/layouts
    ../../../../../middleware/lvgl/lvgl/src/extra/layouts/: lv_layouts.h
  group lvgl/lvgl/src/extra/layouts/flex
    ../../../../../middleware/lvgl/lvgl/src/extra/layouts/flex/: lv_flex.c lv_flex.h
  group lvgl/lvgl/src/extra/layouts/grid
    ../../../../../middleware/lvgl/lvgl/src/extra/layouts/grid/: lv_grid.c lv_grid.h
  group lvgl/lvgl/src/extra/libs
    ../../../../../middleware/lvgl/lvgl/src/extra/libs/: lv_libs.h
  group lvgl/lvgl/src/extra/libs/bmp
    ../../../../../middleware/lvgl/lvgl/src/extra/libs/bmp/: lv_bmp.c lv_bmp.h
  group lvgl/lvgl/src/extra/libs/freetype
    ../../../../../middleware/lvgl/lvgl/src/extra/libs/freetype/: lv_freetype.c lv_freetype.h
  group lvgl/lvgl/src/extra/libs/fsdrv
    ../../../../../middleware/lvgl/lvgl/src/extra/libs/fsdrv/: lv_fsdrv.h lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
  group lvgl/lvgl/src/extra/libs/gif
    ../../../../../middleware/lvgl/lvgl/src/extra/libs/gif/: gifdec.c gifdec.h lv_gif.c lv_gif.h
  group lvgl/lvgl/src/extra/libs/png
    ../../../../../middleware/lvgl/lvgl/src/extra/libs/png/: lodepng.c lodepng.h lv_png.c lv_png.h
  group lvgl/lvgl/src/extra/libs/qrcode
    ../../../../../middleware/lvgl/lvgl/src/extra/libs/qrcode/: lv_qrcode.c lv_qrcode.h qrcodegen.h qrcodegen.c
  group lvgl/lvgl/src/extra/libs/rlottie
    ../../../../../middleware/lvgl/lvgl/src/extra/libs/rlottie/: lv_rlottie.c lv_rlottie.h
  group lvgl/lvgl/src/extra/libs/sjpg
    ../../../../../middleware/lvgl/lvgl/src/extra/libs/sjpg/: lv_sjpg.c lv_sjpg.h tjpgd.c tjpgdcnf.h tjpgd.h
  group lvgl/lvgl/src/extra/libs/ffmpeg
    ../../../../../middleware/lvgl/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c lv_ffmpeg.h
  group lvgl/lvgl/src/extra/others
    ../../../../../middleware/lvgl/lvgl/src/extra/others/: lv_others.h
  group lvgl/lvgl/src/extra/others/snapshot
    ../../../../../middleware/lvgl/lvgl/src/extra/others/snapshot/: lv_snapshot.c lv_snapshot.h
  group lvgl/lvgl/src/extra/others/gridnav
    ../../../../../middleware/lvgl/lvgl/src/extra/others/gridnav/: lv_gridnav.c lv_gridnav.h
  group lvgl/lvgl/src/extra/others/monkey
    ../../../../../middleware/lvgl/lvgl/src/extra/others/monkey/: lv_monkey.c lv_monkey.h
  group lvgl/lvgl/src/extra/others/fragment
    ../../../../../middleware/lvgl/lvgl/src/extra/others/fragment/: lv_fragment.h lv_fragment.c lv_fragment_manager.c
  group lvgl/lvgl/src/extra/others/ime
    ../../../../../middleware/lvgl/lvgl/src/extra/others/ime/: lv_ime_pinyin.h lv_ime_pinyin.c
  group lvgl/lvgl/src/extra/others/imgfont
    ../../../../../middleware/lvgl/lvgl/src/extra/others/imgfont/: lv_imgfont.h lv_imgfont.c
  group lvgl/lvgl/src/extra/others/msg
    ../../../../../middleware/lvgl/lvgl/src/extra/others/msg/: lv_msg.h lv_msg.c
  group lvgl/lvgl/src/extra/themes
    ../../../../../middleware/lvgl/lvgl/src/extra/themes/: lv_themes.h
  group lvgl/lvgl/src/extra/themes/basic
    ../../../../../middleware/lvgl/lvgl/src/extra/themes/basic/: lv_theme_basic.c lv_theme_basic.h
  group lvgl/lvgl/src/extra/themes/default
    ../../../../../middleware/lvgl/lvgl/src/extra/themes/default/: lv_theme_default.c lv_theme_default.h
  group lvgl/lvgl/src/extra/themes/mono
    ../../../../../middleware/lvgl/lvgl/src/extra/themes/mono/: lv_theme_mono.c lv_theme_mono.h
  group lvgl/lvgl/src/extra/widgets
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/: lv_widgets.h
  group lvgl/lvgl/src/extra/widgets/animimg
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/animimg/: lv_animimg.c lv_animimg.h
  group lvgl/lvgl/src/extra/widgets/calendar
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h
  group lvgl/lvgl/src/extra/widgets/chart
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/chart/: lv_chart.c lv_chart.h
  group lvgl/lvgl/src/extra/widgets/colorwheel
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c lv_colorwheel.h
  group lvgl/lvgl/src/extra/widgets/imgbtn
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c lv_imgbtn.h
  group lvgl/lvgl/src/extra/widgets/keyboard
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c lv_keyboard.h
  group lvgl/lvgl/src/extra/widgets/led
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/led/: lv_led.c lv_led.h
  group lvgl/lvgl/src/extra/widgets/list
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/list/: lv_list.c lv_list.h
  group lvgl/lvgl/src/extra/widgets/meter
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/meter/: lv_meter.c lv_meter.h
  group lvgl/lvgl/src/extra/widgets/msgbox
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c lv_msgbox.h
  group lvgl/lvgl/src/extra/widgets/span
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/span/: lv_span.c lv_span.h
  group lvgl/lvgl/src/extra/widgets/spinbox
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c lv_spinbox.h
  group lvgl/lvgl/src/extra/widgets/spinner
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/spinner/: lv_spinner.c lv_spinner.h
  group lvgl/lvgl/src/extra/widgets/tabview
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/tabview/: lv_tabview.c lv_tabview.h
  group lvgl/lvgl/src/extra/widgets/tileview
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/tileview/: lv_tileview.c lv_tileview.h
  group lvgl/lvgl/src/extra/widgets/win
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/win/: lv_win.c lv_win.h
  group lvgl/lvgl/src/extra/widgets/menu
    ../../../../../middleware/lvgl/lvgl/src/extra/widgets/menu/: lv_menu.c lv_menu.h
  group device
    ../../../../../devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group startup
    ../../../../../devices/MIMXRT595S/iar/: startup_MIMXRT595S_cm33.s
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
