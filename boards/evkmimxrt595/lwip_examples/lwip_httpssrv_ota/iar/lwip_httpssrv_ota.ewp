# IAR project lwip_httpssrv_ota.ewp, settings and files
configuration flash_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT595S_M33 NXP MIMXRT595S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT595SFFOC_cm33; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; HTTPSRV_CFG_WEBSOCKET_ENABLED=0; HTTPSRV_CFG_MBEDTLS_ENABLE=1; MBEDTLS_CONFIG_FILE="mbedtls_config.h"; OTA_DEVEL_MODE=1; HIGH_SPEED_SDIO_CLOCK; SDIO_ENABLED; MFLASH_FILE_BASEADDR=3145728; SDK_I2C_BASED_COMPONENT_USED=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS; WIFI_WICED; SDK_DEBUGCONSOLE_UART
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.IExtraOptions: --diag_suppress Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../..; ../../../../../middleware/lwip/src/apps/httpsrv; ../../../../../middleware/mbedtls/include; ../../../../../middleware/mbedtls/library; ../../../../../devices/MIMXRT595S/utilities/str; ../../../../../devices/MIMXRT595S/utilities/debug_console; ../../../../../middleware/mbedtls/port/ksdk; ../../../../../middleware/wiced/43xxx_Wi-Fi/platforms/MURATA_TYPE1DX; ../../../../../middleware/lwip/port; ../../../../../middleware/lwip/src; ../../../../../middleware/lwip/src/include; ../../../../../devices/MIMXRT595S/drivers; ../../../../../middleware/sdmmc/sdio; ../../../../../middleware/sdmmc/common; ../../../../../middleware/sdmmc/host/usdhc; ../../../../../middleware/wiced/43xxx_Wi-Fi/app; ../../../../../components/flash/mflash/mimxrt595; ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../components/pca9420; ../../../../../devices/MIMXRT595S; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../rtos/freertos/freertos_kernel/include; ../../../../../CMSIS/Include; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/chips/4343W; ../../../../../middleware/wiced/43xxx_Wi-Fi/include; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/network/LwIP/WWD; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/include; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/RTOS/FreeRTOS/WWD; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/network; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/platform; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/RTOS; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/SDIO; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/WWD; ../../../../../middleware/sdmmc/osa; ../../../../../components/osa; ../../../../../components/flash/mflash
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..; ../../..
  ILINK.IlinkOutputFile: lwip_httpssrv_ota.out
  ILINK.IlinkConfigDefines: __stack_size__=1000; __heap_size__=100000
  ILINK.IlinkIcfFile: linker/MIMXRT595Sxxxx_cm33_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; HTTPSRV_CFG_WEBSOCKET_ENABLED=0; HTTPSRV_CFG_MBEDTLS_ENABLE=1; MBEDTLS_CONFIG_FILE="mbedtls_config.h"; OTA_DEVEL_MODE=1; HIGH_SPEED_SDIO_CLOCK; SDIO_ENABLED; MFLASH_FILE_BASEADDR=3145728; SDK_I2C_BASED_COMPONENT_USED=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS; WIFI_WICED; SDK_DEBUGCONSOLE_UART
  ICCARM.CCOptLevel: 3
  group source
    ../: lwip_httpssrv_ota.c lwipopts.h ota_bootloader_supp.c ota_bootloader_supp.h ota_bootloader_hdr.c ota_bootloader_board.h httpsrv_fs_data.c mbedtls_config.h FreeRTOSConfig.h
  group network
    ../: network_cfg.h init_wifi.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
    ../../../: sdmmc_config.c sdmmc_config.h
  group doc
    ../: readme.txt
  group mbedtls/include/mbedtls
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/library
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c chacha20.c chachapoly.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/port/ksdk
    ../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c ecp_alt.h ecp_alt.c ecp_curves_alt.c ecp_alt_ksdk.c
  group utilities
    ../../../../../devices/MIMXRT595S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT595S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT595S/utilities/: fsl_assert.c
  group wiced/43xxx_Wi-Fi
    ../../../../../middleware/wiced/43xxx_Wi-Fi/: generated_mac_address.txt
  group wiced/43xxx_Wi-Fi/platforms/MURATA_TYPE1DX
    ../../../../../middleware/wiced/43xxx_Wi-Fi/platforms/MURATA_TYPE1DX/: wifi_nvram_image.h
  group wiced/43xxx_Wi-Fi/app
    ../../../../../middleware/wiced/43xxx_Wi-Fi/app/: dhcp_server.c dhcp_server.h test_apsta.c test_scan.c wlanif_add.c
  group wiced/43xxx_Wi-Fi/WICED/WWD
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/: wwd.h wwd_wiced.h
  group wiced/43xxx_Wi-Fi/WICED/WWD/internal
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/: tlv.c tlv.h wwd_ap.h wwd_ap_common.c wwd_ap_common.h wwd_bcmendian.h wwd_clm.c wwd_clm.h wwd_debug.c wwd_eapol.c wwd_internal.c wwd_internal.h wwd_logging.h wwd_management.c wwd_rtos_interface.c wwd_sdpcm.c wwd_sdpcm.h wwd_thread.c wwd_thread.h wwd_thread_internal.c wwd_thread_internal.h wwd_wifi.c wwd_wifi_chip_common.c wwd_wifi_chip_common.h wwd_wifi_sleep.c
  group wiced/43xxx_Wi-Fi/WICED/WWD/internal/chips/4343W
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/chips/4343W/: 4343WA1.h 4343WA1_clm.h 4343WA1_mfg.h 4343WA1_clm_mfg.h chip_constants.h resources.c resources.h wwd_ap.c wwd_chip_specific_functions.c
  group wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/: wwd_bus_common.c wwd_bus_protocol_interface.h
  group wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/SDIO
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/SDIO/: wwd_bus_protocol.c wwd_bus_protocol.h
  group wiced/43xxx_Wi-Fi/WICED/WWD/include
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/: wwd_assert.h wwd_constants.h wwd_debug.h wwd_eapol.h wwd_events.h wwd_management.h wwd_poll.h wwd_structures.h wwd_wifi.h wwd_wifi_sleep.h wwd_wlioctl.h
  group wiced/43xxx_Wi-Fi/WICED/WWD/include/network
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/network/: wwd_buffer_interface.h wwd_network_constants.h wwd_network_interface.h
  group wiced/43xxx_Wi-Fi/WICED/WWD/include/platform
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/platform/: wwd_bus_interface.h wwd_platform_interface.h wwd_resource_interface.h wwd_sdio_interface.h wwd_spi_interface.h
  group wiced/43xxx_Wi-Fi/WICED/WWD/include/RTOS
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/RTOS/: wwd_rtos_interface.h
  group wiced/43xxx_Wi-Fi/WICED/internal
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/internal/: wifi.c
  group wiced/43xxx_Wi-Fi/WICED/network/LwIP/WWD
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/network/LwIP/WWD/: wwd_buffer.c wwd_buffer.h wwd_network.c wwd_network.h
  group wiced/43xxx_Wi-Fi/WICED/platform
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/: platform_toolchain.h
  group wiced/43xxx_Wi-Fi/WICED/platform/include
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/include/: platform_cache_def.h platform_peripheral.h
  group wiced/43xxx_Wi-Fi/WICED/platform/MCU
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/: wwd_platform_common.h wwd_platform_separate_mcu.c wwd_resources.c
  group wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/: platform_mcu_peripheral.h
  group wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/WWD
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/WWD/: wwd_platform.c wwd_SDIO.c
  group wiced/43xxx_Wi-Fi/WICED/RTOS/FreeRTOS/WWD
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/RTOS/FreeRTOS/WWD/: wwd_FreeRTOS_systick.h wwd_rtos.c wwd_rtos.h
  group wiced/43xxx_Wi-Fi/include
    ../../../../../middleware/wiced/43xxx_Wi-Fi/include/: wiced_resource.h
  group lwip/port
    ../../../../../middleware/lwip/port/: sys_arch.c
  group lwip/port/arch
    ../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src/api
    ../../../../../middleware/lwip/src/api/: sockets.c netifapi.c netdb.c netbuf.c tcpip.c api_msg.c err.c if_api.c api_lib.c
  group lwip/src/core
    ../../../../../middleware/lwip/src/core/: memp.c def.c ip.c pbuf.c altcp.c tcp_out.c raw.c altcp_tcp.c sys.c init.c inet_chksum.c timeouts.c tcp_in.c netif.c mem.c udp.c tcp.c stats.c dns.c altcp_alloc.c
  group lwip/src/core/ipv6
    ../../../../../middleware/lwip/src/core/ipv6/: ethip6.c dhcp6.c ip6_addr.c nd6.c mld6.c icmp6.c ip6_frag.c ip6.c inet6.c
  group lwip/src/core/ipv4
    ../../../../../middleware/lwip/src/core/ipv4/: dhcp.c ip4.c autoip.c icmp.c acd.c etharp.c ip4_addr.c igmp.c ip4_frag.c
  group lwip/src/include/compat/stdc
    ../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/compat/posix
    ../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/sys
    ../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/posix/net
    ../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/lwip
    ../../../../../middleware/lwip/src/include/lwip/: inet_chksum.h ip6.h udp.h def.h mld6.h err.h ip4.h opt.h errno.h debug.h icmp.h netif.h sio.h ip6_zone.h igmp.h netdb.h dhcp.h altcp_tls.h altcp_tcp.h ip_addr.h inet.h tcp.h api.h arch.h autoip.h ip4_addr.h altcp.h mem.h sys.h init.h dns.h tcpbase.h stats.h icmp6.h netifapi.h ethip6.h snmp.h raw.h if_api.h tcpip.h ip6_frag.h nd6.h ip.h pbuf.h acd.h ip4_frag.h timeouts.h dhcp6.h sockets.h netbuf.h etharp.h ip6_addr.h memp.h
  group lwip/src/include/lwip/priv
    ../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h mem_priv.h memp_priv.h memp_std.h api_msg.h nd6_priv.h tcpip_priv.h tcp_priv.h raw_priv.h sockets_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../middleware/lwip/src/include/lwip/prot/: ip6.h udp.h mld6.h ip4.h icmp.h igmp.h dhcp.h tcp.h autoip.h iana.h ieee.h dns.h icmp6.h ethernet.h nd6.h ip.h acd.h dhcp6.h etharp.h
  group lwip/src/include/netif
    ../../../../../middleware/lwip/src/include/netif/: bridgeif.h zepif.h lowpan6.h ieee802154.h ethernet.h lowpan6_common.h lowpan6_opts.h bridgeif_opts.h slipif.h lowpan6_ble.h etharp.h
  group lwip/src/include/netif/ppp
    ../../../../../middleware/lwip/src/include/netif/ppp/: ipv6cp.h pppapi.h magic.h ppp.h upap.h mppe.h pppol2tp.h pppoe.h ipcp.h pppdebug.h eap.h pppos.h ppp_opts.h pppcrypt.h vj.h chap-new.h eui64.h chap_ms.h ccp.h ecp.h lcp.h fsm.h ppp_impl.h chap-md5.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: sha1.h des.h md5.h md4.h arc4.h
  group lwip/src/netif
    ../../../../../middleware/lwip/src/netif/: lowpan6.c ethernet.c bridgeif.c bridgeif_fdb.c zepif.c lowpan6_common.c lowpan6_ble.c slipif.c
  group lwip/src/netif/ppp
    ../../../../../middleware/lwip/src/netif/ppp/: pppol2tp.c mppe.c vj.c pppcrypt.c ppp.c eap.c chap-md5.c lcp.c pppos.c ipcp.c fsm.c ccp.c utils.c chap-new.c demand.c pppoe.c ipv6cp.c lwip_ecp.c multilink.c eui64.c magic.c upap.c pppapi.c chap_ms.c auth.c
  group lwip/src/apps/httpsrv
    ../../../../../middleware/lwip/src/apps/httpsrv/: httpsrv.c httpsrv.h httpsrv_base64.c httpsrv_base64.h httpsrv_config.h httpsrv_fs.c httpsrv_fs.h httpsrv_port.h httpsrv_prv.h httpsrv_script.c httpsrv_script.h httpsrv_sha1.c httpsrv_sha1.h httpsrv_supp.c httpsrv_supp.h httpsrv_task.c httpsrv_tls.c httpsrv_tls.h httpsrv_utf8.c httpsrv_utf8.h httpsrv_ws.c httpsrv_ws.h httpsrv_ws_api.c httpsrv_ws_prv.h
  group drivers
    ../../../../../devices/MIMXRT595S/drivers/: fsl_clock.h fsl_clock.c fsl_casper.h fsl_casper.c fsl_hashcrypt.h fsl_hashcrypt.c fsl_trng.c fsl_trng.h fsl_i2c.h fsl_i2c.c fsl_common.h fsl_common.c fsl_power.h fsl_power.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c fsl_usdhc.c fsl_usdhc.h fsl_iap.h fsl_iap.c
  group freertos/freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_3.c ReadMe.url
  group freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s portmacro.h portasm.h
  group freertos/freertos_kernel/include
    ../../../../../rtos/freertos/freertos_kernel/include/: croutine.h StackMacros.h atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group sdmmc/src
    ../../../../../middleware/sdmmc/sdio/: fsl_sdio.c
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc/sdio/: fsl_sdio.h
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sdio
    ../../../../../middleware/sdmmc/sdio/: ChangeLogKSDK.txt
  group sdmmc/host
    ../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt
    ../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group sdmmc/osa
    ../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group flash/mflash
    ../../../../../components/flash/mflash/: mflash_common.h
  group flash/mflash/mimxrt595
    ../../../../../components/flash/mflash/mimxrt595/: mflash_drv.h mflash_drv.c
  group pmic_driver
    ../../../../../components/pca9420/: fsl_pca9420.h fsl_pca9420.c
  group device
    ../../../../../devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c
  group startup
    ../../../../../devices/MIMXRT595S/iar/: startup_MIMXRT595S_cm33.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm33.h tz_context.h mpu_armv8.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
