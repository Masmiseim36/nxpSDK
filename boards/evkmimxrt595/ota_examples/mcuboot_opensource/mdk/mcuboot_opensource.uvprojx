# Keil uVision project mcuboot_opensource.uvprojx, settings and files
target mcuboot_opensource flash_debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: mcuboot_opensource.out
  AfterMake: fromelf.exe --output "$Lsdk20-app.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, MBEDTLS_CONFIG_FILE='\"mbedtls_config.h\"', MCUXPRESSO_SDK, MFLASH_FILE_BASEADDR=7340032, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../include;../include/mcuboot_config;../include/sysflash;../keys;../flash;../../../../../middleware/mbedtls/port/ksdk;../../../../../components/flash/mflash/mimxrt595;../../../../../middleware/mcuboot_opensource/boot/bootutil/src;../../../../../middleware/mcuboot_opensource/boot/bootutil/include;../../../../../middleware/mbedtls/include;../../../../../middleware/mbedtls/library;../../../../../devices/MIMXRT595S/drivers;../../../../../devices/MIMXRT595S;../../../../../devices/MIMXRT595S/utilities/str;../../../../../devices/MIMXRT595S/utilities/debug_console;../../../../../devices/MIMXRT595S/utilities;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../flash_config;../../../../../components/flash/mflash;../../../../../CMSIS/Core/Include
  asm define: DEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314 --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x8000"
  group source
    ../: boot.c boot.h bootutil_hooks.c keys.c os.c sbl_boot.c main.c
  group include
    ../include/: mbedtls_config.h sbl.h sbldef.h flash_map.h
  group include/mcuboot_config
    ../include/mcuboot_config/: mcuboot_config.h mcuboot_logging.h
  group include/flash_map_backend
    ../include/flash_map_backend/: flash_map_backend.h
  group include/os
    ../include/os/: os_malloc.h
  group include/sysflash
    ../include/sysflash/: sysflash.h
  group flash
    ../flash/: flash_api.c
  group board
    ../: sblconfig.h pin_mux.c pin_mux.h flash_partitioning.h flash_partitioning.c board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.md
  group mbedtls/port/ksdk
    ../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c ccm_alt.h ecp_alt.h ecp_alt.c ecp_curves_alt.c ecp_alt_ksdk.c threading_alt.h ksdk_mbedtls_config.h
  group flash/mflash/mimxrt595
    ../../../../../components/flash/mflash/mimxrt595/: mflash_drv.h mflash_drv.c
  group bootutil/include/bootutil
    ../../../../../middleware/mcuboot_opensource/boot/bootutil/include/bootutil/: bench.h bootutil.h bootutil_log.h bootutil_test.h bootutil_public.h boot_record.h boot_status.h boot_hooks.h boot_public_hooks.h caps.h enc_key.h enc_key_public.h fault_injection_hardening.h fault_injection_hardening_delay_rng.h ignore.h image.h security_cnt.h sign_key.h ramload.h mcuboot_status.h
  group bootutil/include/bootutil/crypto
    ../../../../../middleware/mcuboot_opensource/boot/bootutil/include/bootutil/crypto/: aes_ctr.h aes_kw.h common.h ecdh_p256.h ecdh_x25519.h ecdsa_p256.h hmac_sha256.h sha256.h
  group bootutil/src
    ../../../../../middleware/mcuboot_opensource/boot/bootutil/src/: boot_record.c bootutil_misc.c bootutil_misc.h bootutil_public.c caps.c encrypted.c fault_injection_hardening.c fault_injection_hardening_delay_rng_mbedtls.c image_ec.c image_ec256.c image_ed25519.c image_rsa.c image_validate.c loader.c swap_misc.c swap_move.c swap_scratch.c tlv.c swap_priv.h bootutil_priv.h
  group mbedtls/include/mbedtls
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h psa_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/include/psa
    ../../../../../middleware/mbedtls/include/psa/: crypto.h crypto_builtin_composites.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group mbedtls/library
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cmac.c common.h constant_time.c constant_time_internal.h constant_time_invasive.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_invasive.h entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c mps_common.h mps_error.h mps_reader.c mps_reader.h mps_trace.c mps_trace.h net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c ssl_tls13_keys.h threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group drivers
    ../../../../../devices/MIMXRT595S/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_power.h fsl_power.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c fsl_trng.c fsl_trng.h fsl_casper.h fsl_casper.c fsl_hashcrypt.h fsl_hashcrypt.c fsl_iap.h fsl_iap.c
  group device
    ../../../../../devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group utilities
    ../../../../../devices/MIMXRT595S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT595S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT595S/utilities/: fsl_assert.c fsl_assert.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group startup
    ../../../../../devices/MIMXRT595S/arm/: startup_MIMXRT595S_cm33.S
  group flash/mflash
    ../../../../../components/flash/mflash/: mflash_common.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target mcuboot_opensource flash_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: mcuboot_opensource.out
  AfterMake: fromelf.exe --output "$Lsdk20-app.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, MBEDTLS_CONFIG_FILE='\"mbedtls_config.h\"', MCUXPRESSO_SDK, MFLASH_FILE_BASEADDR=7340032, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_flash.scf
  link misc: as above
target mcuboot_opensource flexspi_nor_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: mcuboot_opensource.out
  AfterMake: fromelf.exe --output "$Lsdk20-app.bin" --bincombined "#L"
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, MBEDTLS_CONFIG_FILE='\"mbedtls_config.h\"', MCUXPRESSO_SDK, MFLASH_FILE_BASEADDR=7340032, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_flash.scf
  link misc: as above
