# Keil uVision project ota_mcuboot_server_wifi.uvprojx, settings and files
target ota_mcuboot_server_wifi flash_debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: ota_mcuboot_server_wifi.out
  AfterMake: fromelf.exe --output "$Lota_mcuboot_server.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, HIGH_SPEED_SDIO_CLOCK, MCUBOOT_APPLICATION=1, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, HTTPSRV_CFG_WEBSOCKET_ENABLED=0, MCUXPRESSO_SDK, MFLASH_FILE_BASEADDR=7340032, SDK_I2C_BASED_COMPONENT_USED=1, SDIO_ENABLED, SDK_OS_FREE_RTOS, SERIAL_PORT_TYPE_UART=1, OSA_USED, FSL_OSA_TASK_ENABLE=1, LWIP_DNS=1, LWIP_NETIF_HOSTNAME=1, LWIP_IGMP=1, _XOPEN_SOURCE=500, SO_REUSE=1
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../..;../bootutil_port;../bootutil_port/mcuboot_config;../bootutil_port/sysflash;../bootutil_port/board_specific;../../../../../../devices/MIMXRT595S/drivers;../../../../../../components/flash/mflash/mimxrt595;../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure;../../../../../../components/pca9420;../../../../../../middleware/wifi_nxp/incl;../../../../../../middleware/wifi_nxp/incl/wlcmgr;../../../../../../middleware/wifi_nxp/wifidriver;../../../../../../middleware/wifi_nxp/wifidriver/incl;../../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if;../../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if/incl;../../../../../../middleware/wifi_nxp/certs;../../../../../../middleware/wifi_nxp/firmware_dnld;../../../../../../middleware/wifi_nxp/sdio_nxp_abs;../../../../../../middleware/wifi_nxp/sdio_nxp_abs/incl;../../../../../../middleware/sdmmc/host/usdhc;../../../../../../middleware/sdmmc/sdio;../../../../../../components/gpio;../../../../../../middleware/lwip/src/apps/httpsrv;../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../middleware/wifi_nxp/incl/wifidriver;../../../../../../middleware/wifi_nxp/incl/port/net;../../../../../../middleware/wifi_nxp/port/net;../../../../../../middleware/wifi_nxp/incl/port/net/hooks;../../../../../../middleware/lwip/port;../../../../../../middleware/lwip/src;../../../../../../middleware/lwip/src/include;../../../../../../components/edgefast_wifi/include;../../../../../../devices/MIMXRT595S;../../../../../../devices/MIMXRT595S/utilities/debug_console;../../../../../../devices/MIMXRT595S/utilities;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../components/flash/mflash;../../../../../../middleware/wifi_nxp/incl/port/osa;../../../../../../middleware/wifi_nxp/wifi_bt_firmware;../../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits;../../../../../../components/wifi_bt_module/Murata/tx_pwr_limits;../../../../../../components/wifi_bt_module/u-blox/tx_pwr_limits;../../../../../../components/wifi_bt_module/incl;../../../../../../middleware/wifi_nxp;../../../../../../middleware/wifi_nxp/port/osa;../../../../../../components/osa;../../../../../../middleware/wifi_nxp/wifi_bt_firmware/8801;../../../../../../middleware/wifi_nxp/wifi_bt_firmware/IW416;../../../../../../middleware/wifi_nxp/wifi_bt_firmware/8987;../../../../../../middleware/wifi_nxp/wifi_bt_firmware/nw61x;../../../../../../middleware/wifi_nxp/fwdnld_intf_abs;../../../../../../middleware/wifi_nxp/dhcpd;../../../../../../middleware/lwip/src/include/lwip/apps;../../../../../../middleware/sdmmc/common;../../../../../../middleware/sdmmc/osa;../../../../../../CMSIS/Core/Include;../../../../../../devices/MIMXRT595S/utilities/str
  asm define: DEBUG
  asm include: ..;../../../../../../rtos/freertos/freertos-kernel/include
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314 --predefine="-D__stack_size__=1000" --predefine="-D__heap_size__=60000"
  group source
    ../: ota_mcuboot_server.c httpsrv_multipart.c httpsrv_multipart.h network_cfg.h init_wifi.c lwipopts.h httpsrv_fs_data.c FreeRTOSConfig.h wifi_config.h app_config.h mcuboot_app_support.c mcuboot_app_support.h
  group board
    ../: pin_mux.c pin_mux.h sdmmc_config.c sdmmc_config.h wifi_bt_config.c wifi_bt_config.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme_modules.txt readme.md
  group bootutil_port/board_specific
    ../bootutil_port/board_specific/: flash_partitioning.h flash_partitioning.c sblconfig.h
  group bootutil_port/mcuboot_config
    ../bootutil_port/mcuboot_config/: mcuboot_config.h mcuboot_logging.h
  group bootutil_port
    ../bootutil_port/: flash_map.h
  group bootutil_port/sysflash
    ../bootutil_port/sysflash/: sysflash.h
  group drivers
    ../../../../../../devices/MIMXRT595S/drivers/: fsl_casper.h fsl_casper.c fsl_hashcrypt.h fsl_hashcrypt.c fsl_trng.c fsl_trng.h fsl_i2c.h fsl_i2c.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_power.h fsl_power.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c fsl_usdhc.c fsl_usdhc.h
  group flash/mflash/mimxrt595
    ../../../../../../components/flash/mflash/mimxrt595/: mflash_drv.h mflash_drv.c
  group freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure
    ../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.c port.c portasm.c portasm.h portmacro.h portmacrocommon.h
  group pmic_driver
    ../../../../../../components/pca9420/: fsl_pca9420.h fsl_pca9420.c
  group wifi/wifidriver
    ../../../../../../middleware/wifi_nxp/wifidriver/: wifi-sdio.c mlan_11ac.c mlan_11ax.c mlan_11d.c mlan_11h.c mlan_11n.c mlan_11n_aggr.c mlan_11n_rxreorder.c mlan_11v.c mlan_action.c mlan_11k.c mlan_mbo.c mlan_api.c mlan_cfp.c mlan_cmdevt.c mlan_glue.c mlan_init.c mlan_join.c mlan_misc.c mlan_scan.c mlan_shim.c mlan_sta_cmd.c mlan_sta_cmdresp.c mlan_sta_event.c mlan_sta_ioctl.c mlan_sta_rx.c mlan_txrx.c mlan_uap_cmdevent.c mlan_uap_ioctl.c mlan_wmm.c wifi-debug.c wifi-debug.h wifi-internal.h wifi-mem.c wifi-uap.c wifi.c wifi_common.h wifi_pwrmgr.c wifi-wps.c wifi-sdio.h sdio.c sdio.h
  group wifi/incl
    ../../../../../../middleware/wifi_nxp/incl/: dhcp-server.h nxp_wifi.h wmstats.h wifi_config_default.h wifi_cal_data_ext.h wm_utils.h wmerrno.h wmlog.h wmtypes.h WIFI_IW416_BOARD_AW_AM457_CAL_DATA_EXT.h
  group wifi/incl/wlcmgr
    ../../../../../../middleware/wifi_nxp/incl/wlcmgr/: wlan.h wlan_11d.h
  group wifi/incl/wifidriver
    ../../../../../../middleware/wifi_nxp/incl/wifidriver/: wifi_nxp.h wifi-decl.h wifi.h wifi_events.h
  group wifi/wifidriver/incl
    ../../../../../../middleware/wifi_nxp/wifidriver/incl/: mlan.h mlan_11ac.h mlan_11ax.h mlan_11h.h mlan_11n.h mlan_11n_aggr.h mlan_11n_rxreorder.h mlan_11v.h mlan_action.h mlan_11k.h mlan_mbo.h mlan_api.h mlan_fw.h mlan_ieee.h mlan_init.h mlan_join.h mlan_main.h mlan_meas.h mlan_remap_mem_operations.h mlan_uap.h mlan_util.h mlan_wmm.h mlan_decl.h mlan_ioctl.h type_decls.h mlan_main_defs.h
  group wifi/wifidriver/wpa_supp_if/incl
    ../../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if/incl/: rtos_wpa_supp_if.h wifi_nxp_internal.h
  group wifi/wifidriver/wpa_supp_if
    ../../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if/: wifi_nxp.c rtos_wpa_supp_if.c wifi_nxp_internal.c
  group wifi/certs
    ../../../../../../middleware/wifi_nxp/certs/: ca-cert.h client-cert.h client-key.h server-cert.h server-key.h dh-param.h
  group sdmmc/host
    ../../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt ChangeLogKSDK.txt
    ../../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group sdmmc/src
    ../../../../../../middleware/sdmmc/sdio/: fsl_sdio.c
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../../middleware/sdmmc/sdio/: fsl_sdio.h
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sdio
    ../../../../../../middleware/sdmmc/sdio/: ChangeLogKSDK.txt
  group component/gpio
    ../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_rt_gpio.c
  group lwip/src/apps/httpsrv
    ../../../../../../middleware/lwip/src/apps/httpsrv/: httpsrv.c httpsrv.h httpsrv_base64.c httpsrv_base64.h httpsrv_config.h httpsrv_fs.c httpsrv_fs.h httpsrv_port.h httpsrv_prv.h httpsrv_script.c httpsrv_script.h httpsrv_sha1.c httpsrv_sha1.h httpsrv_supp.c httpsrv_supp.h httpsrv_task.c httpsrv_tls.c httpsrv_tls.h httpsrv_utf8.c httpsrv_utf8.h httpsrv_ws.c httpsrv_ws.h httpsrv_ws_api.c httpsrv_ws_prv.h
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_3.c
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group wifi/dhcpd
    ../../../../../../middleware/wifi_nxp/dhcpd/: dhcp-bootp.h dhcp-priv.h dhcp-server-main.c dhcp-server.c dns-server.c dns.h dhcp-bootp.h dhcp-priv.h dhcp-server-main.c dhcp-server.c dns-server.c dns.h
  group wifi/incl/port/net
    ../../../../../../middleware/wifi_nxp/incl/port/net/: wm_net.h wm_net.h wm_net.h
  group wifi/port/net
    ../../../../../../middleware/wifi_nxp/port/net/: net.c netif_decl.h wifi_netif.c net.c netif_decl.h wifi_netif.c
  group wifi/wlcmgr
    ../../../../../../middleware/wifi_nxp/wlcmgr/: wlan.c wlan_txpwrlimit_cfg.c
  group wifi
    ../../../../../../middleware/wifi_nxp/: ChangeLogKSDK.txt CMakeLists.txt
  group lwip/port
    ../../../../../../middleware/lwip/port/: sys_arch.c
  group lwip/port/arch
    ../../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src/api
    ../../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/core
    ../../../../../../middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/src/core/ipv4
    ../../../../../../middleware/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/src/core/ipv6
    ../../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip/src/include/compat/posix/arpa
    ../../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/compat/posix/net
    ../../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix
    ../../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/sys
    ../../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/stdc
    ../../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/lwip
    ../../../../../../middleware/lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/priv
    ../../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../../middleware/lwip/src/include/lwip/prot/: acd.h autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip/src/include/netif
    ../../../../../../middleware/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lwip/src/include/netif/ppp
    ../../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip/src/netif
    ../../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group edgefast_wifi/source
    ../../../../../../components/edgefast_wifi/source/: wpl_nxp.c
  group edgefast_wifi/include
    ../../../../../../components/edgefast_wifi/include/: wpl.h
  group device
    ../../../../../../devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group utilities
    ../../../../../../devices/MIMXRT595S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT595S/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../../devices/MIMXRT595S/utilities/str/: fsl_str.c fsl_str.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMXRT595S/arm/: startup_MIMXRT595S_cm33.S
  group flash/mflash
    ../../../../../../components/flash/mflash/: mflash_common.h
  group wifi/sdio_nxp_abs
    ../../../../../../middleware/wifi_nxp/sdio_nxp_abs/: mlan_sdio.c fwdnld_sdio.c
  group wifi/sdio_nxp_abs/incl
    ../../../../../../middleware/wifi_nxp/sdio_nxp_abs/incl/: fwdnld_sdio.h mlan_sdio_defs.h mlan_sdio.h mlan_sdio_api.h
  group wifi/wifi_bt_firmware
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/: wlan_bt_fw.h
  group component/wifi_bt_module/AzureWave/tx_pwr_limits
    ../../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits/: wlan_txpwrlimit_cfg_WW.h wlan_txpwrlimit_cfg_WW_rw610.h
  group component/wifi_bt_module/Murata/tx_pwr_limits
    ../../../../../../components/wifi_bt_module/Murata/tx_pwr_limits/: wlan_txpwrlimit_cfg_murata_1XK_WW.h wlan_txpwrlimit_cfg_murata_1ZM_WW.h wlan_txpwrlimit_cfg_murata_2DS_WW.h wlan_txpwrlimit_cfg_murata_2EL_WW.h
  group component/wifi_bt_module/u-blox/tx_pwr_limits
    ../../../../../../components/wifi_bt_module/u-blox/tx_pwr_limits/: wlan_txpwrlimit_cfg_jody_w5_WW.h
  group component/wifi_bt_module/incl
    ../../../../../../components/wifi_bt_module/incl/: wifi_bt_module_config.h
  group wifi/incl/port/osa
    ../../../../../../middleware/wifi_nxp/incl/port/osa/: osa.h mem_pool.h mem_pool_config.h slist.h stack_simple.h
  group wifi/port/osa
    ../../../../../../middleware/wifi_nxp/port/osa/: osa.c mem_pool.c mem_pool_config.c slist.c stack_simple.c osa_freertos.h osa_freertos.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h fsl_os_abstraction_config.h
  group wifi/wifi_bt_firmware/8801
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/8801/: sd8801_wlan.bin.inc sd8801_wlan.h 8801_cpu1.c
  group wifi/wifi_bt_firmware/IW416
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/IW416/: sduartIW416_wlan_bt.bin.inc sdIW416_wlan.bin.inc uartIW416_bt.bin.inc sduartIW416_wlan_bt.h sdIW416_wlan.h uartIW416_bt.h IW416_cpu12.c IW416_cpu1.c IW416_cpu2.c
  group wifi/wifi_bt_firmware/8987
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/8987/: sduart8987_wlan_bt.bin.inc sd8987_wlan.bin.inc uart8987_bt.bin.inc sduart8987_wlan_bt.h sd8987_wlan.h uart8987_bt.h 8987_cpu12.c 8987_cpu1.c 8987_cpu2.c
  group wifi/wifi_bt_firmware/nw61x
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/nw61x/: sduart_nw61x.bin.se.inc sd_nw61x.bin.se.inc uart_nw61x.bin.se.inc sduart_nw61x_se.h sd_nw61x_se.h uart_nw61x_se.h nw61x_cpu12_se.c nw61x_cpu1_se.c nw61x_cpu2_se.c
  group wifi/firmware_dnld
    ../../../../../../middleware/wifi_nxp/firmware_dnld/: firmware_dnld.c firmware_dnld.h
  group wifi/fwdnld_intf_abs
    ../../../../../../middleware/wifi_nxp/fwdnld_intf_abs/: fwdnld_intf_abs.c fwdnld_intf_abs.h
  group wifi/incl/port/net/hooks
    ../../../../../../middleware/wifi_nxp/incl/port/net/hooks/: lwip_default_hooks.h
  group wifi/port/net/hooks
    ../../../../../../middleware/wifi_nxp/port/net/hooks/: lwip_default_hooks.c
  group lwip/src/apps/lwiperf
    ../../../../../../middleware/lwip/src/apps/lwiperf/: lwiperf.c
  group lwip/src/include/lwip/apps
    ../../../../../../middleware/lwip/src/include/lwip/apps/: lwiperf.h
  group sdmmc/osa
    ../../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target ota_mcuboot_server_wifi flash_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: ota_mcuboot_server_wifi.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, HIGH_SPEED_SDIO_CLOCK, MCUBOOT_APPLICATION=1, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, HTTPSRV_CFG_WEBSOCKET_ENABLED=0, MCUXPRESSO_SDK, MFLASH_FILE_BASEADDR=7340032, SDK_I2C_BASED_COMPONENT_USED=1, SDIO_ENABLED, SDK_OS_FREE_RTOS, SERIAL_PORT_TYPE_UART=1, OSA_USED, FSL_OSA_TASK_ENABLE=1, LWIP_DNS=1, LWIP_NETIF_HOSTNAME=1, LWIP_IGMP=1, _XOPEN_SOURCE=500, SO_REUSE=1
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: NDEBUG
  asm include: ..;../../../../../../rtos/freertos/freertos-kernel/include
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_flash.scf
  link misc: as above
target ota_mcuboot_server_wifi flexspi_nor_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: ota_mcuboot_server_wifi.out
  AfterMake: as above
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, HIGH_SPEED_SDIO_CLOCK, MCUBOOT_APPLICATION=1, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, HTTPSRV_CFG_WEBSOCKET_ENABLED=0, MCUXPRESSO_SDK, MFLASH_FILE_BASEADDR=7340032, SDK_I2C_BASED_COMPONENT_USED=1, SDIO_ENABLED, SDK_OS_FREE_RTOS, SERIAL_PORT_TYPE_UART=1, OSA_USED, FSL_OSA_TASK_ENABLE=1, LWIP_DNS=1, LWIP_NETIF_HOSTNAME=1, LWIP_IGMP=1, _XOPEN_SOURCE=500, SO_REUSE=1
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm include: ..;../../../../../../rtos/freertos/freertos-kernel/include
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_flash.scf
  link misc: as above
