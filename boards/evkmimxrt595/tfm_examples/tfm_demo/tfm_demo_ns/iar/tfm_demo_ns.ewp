# IAR project tfm_demo_ns.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT595S_M33 NXP MIMXRT595S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; TFM_LVL=2; ITS_MAX_ASSET_SIZE=512; PS_MAX_ASSET_SIZE=512; OS_DYNAMIC_MEM_SIZE=7168; TFM_PSA_API; SERIAL_PORT_TYPE_UART=1; CONFIG_TFM_FLOAT_ABI=2; CONFIG_TFM_ENABLE_CP10CP11; CONFIG_TFM_LAZY_STACKING; __DOMAIN_NS=1; DOMAIN_NS=1; CONFIG_TFM_USE_TRUSTZONE; ATTEST_TOKEN_PROFILE_PSA_IOT_1; PLATFORM_DEFAULT_CRYPTO_KEYS; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pa084,Pa205,Pe128,Pe186,Pe546,Pe940,Pe550,Pa167
  ICCARM.IExtraOptions: --diag_suppress Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../devices/MIMXRT595S; ..; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/partition; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Include; ../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest; ../../../../../../middleware/tfm/tf-m/interface/include; ../../../../../../devices/MIMXRT595S/drivers; ../../../../../../devices/MIMXRT595S/utilities/str; ../../../../../../devices/MIMXRT595S/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../flash_config; ../../../../../../middleware/tfm/tf-m/platform/include; ../../../../../../middleware/tfm/tf-m/platform/ext; ../../../../../../middleware/tfm/tf-m/platform/ext/common; ../../../../../../middleware/tfm/tf-m/platform/ext/driver; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Config; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Include; ../../../../../../middleware/tfm/tf-m/interface/include/crypto_keys; ../../../../../../middleware/tfm/tf-m/interface/include/psa; ../../../../../../middleware/tfm/tf-m/bl2/include; ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include; ../../../../../../middleware/tfm/tf-m/secure_fw/include/tfm; ../../../../../../middleware/tfm/tf-m-tests/app; ../../../../../../middleware/tfm/tf-m-tests/log; ../../../../../../middleware/tfm/tf-m-tests/ns_interface; ../../../../../../middleware/tfm/tf-m-tests/ns_interface/ns_client_ext; ../../../../../../CMSIS/RTOS2/RTX/Source; ../../../../../../CMSIS/RTOS2/RTX/Include; ../../../../../../CMSIS/RTOS2/RTX/Config; ../../../../../../CMSIS/RTOS2/Include; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  prebuild: "$TOOLKIT_DIR$/bin/iccarm.exe" -I../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/partition ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/iar/tfm_common_ns.icf --silent --preprocess=ns ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/iar/tfm_common_ns_pre.icf
  ILINK.IlinkOutputFile: tfm_demo_ns.out
  ILINK.IlinkIcfFile: ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/iar/tfm_common_ns_pre.icf
  ILINK.IlinkAdditionalLibs: ../../tfm_demo_s/iar/debug/tfm_demo_s_import_lib.o; ../../../../../../CMSIS/RTOS2/RTX/Library/IAR/RTX_V8MMFN.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; TFM_LVL=2; ITS_MAX_ASSET_SIZE=512; PS_MAX_ASSET_SIZE=512; OS_DYNAMIC_MEM_SIZE=7168; TFM_PSA_API; SERIAL_PORT_TYPE_UART=1; CONFIG_TFM_FLOAT_ABI=2; CONFIG_TFM_ENABLE_CP10CP11; CONFIG_TFM_LAZY_STACKING; __DOMAIN_NS=1; DOMAIN_NS=1; CONFIG_TFM_USE_TRUSTZONE; ATTEST_TOKEN_PROFILE_PSA_IOT_1; PLATFORM_DEFAULT_CRYPTO_KEYS; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  ILINK.IlinkAdditionalLibs: ../../tfm_demo_s/iar/release/tfm_demo_s_import_lib.o; ../../../../../../CMSIS/RTOS2/RTX/Library/IAR/RTX_V8MMFN.a
  group startup
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Source/iar/: startup_MIMXRT595S_cm33_ns.s
  group device
    ../../../../../../devices/MIMXRT595S/: system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group board
    ../: pin_mux.c pin_mux.h hardware_init.c app.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group tf-m/platform/ext/target/nxp/evkmimxrt595
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/: target_cfg.h tfm_peripherals_def.h
  group tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Include/: platform_base_address.h
  group tf-m/platform/ext/target/nxp/evkmimxrt595/partition
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/partition/: region_defs.h flash_layout.h
  group tf-m/platform/ext/target/nxp/common/CMSIS_Driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/CMSIS_Driver/: Driver_USART.c
  group tf-m/platform/ext/target/nxp/common/Device/Include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Include/: cmsis.h device_definition.h platform_irq.h platform_regs.h
  group tf-m/platform/ext/target/nxp/common/Device/Config
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Config/: device_cfg.h
  group tf-m/platform/ext/common
    ../../../../../../middleware/tfm/tf-m/platform/ext/common/: uart_stdout.h uart_stdout.c
  group tf-m/platform/ext/driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/driver/: Driver_USART.h Driver_Common.h
  group tf-m/platform/include
    ../../../../../../middleware/tfm/tf-m/platform/include/: tfm_plat_crypto_keys.h tfm_hal_device_header.h tfm_plat_boot_seed.h tfm_plat_device_id.h tfm_plat_defs.h tfm_plat_ns.h region.h tfm_plat_test.h
  group tf-m/interface/include
    ../../../../../../middleware/tfm/tf-m/interface/include/: tfm_attest_defs.h config_impl.h tfm_veneers.h tfm_crypto_defs.h tfm_its_defs.h tfm_ps_defs.h tfm_api.h tfm_ns_interface.h psa_config.h tfm_psa_call_pack.h tfm_ns_client_ext.h tfm_platform_api.h
  group tf-m/interface/include/psa_manifest
    ../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest/: sid.h
  group tf-m/interface/include/crypto_keys
    ../../../../../../middleware/tfm/tf-m/interface/include/crypto_keys/: tfm_builtin_key_ids.h
  group tf-m/interface/include/psa
    ../../../../../../middleware/tfm/tf-m/interface/include/psa/: client.h crypto.h crypto_client_struct.h crypto_extra.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h error.h framework_feature.h initial_attestation.h internal_trusted_storage.h lifecycle.h protected_storage.h service.h storage_common.h crypto_compat.h
  group tf-m/interface/src
    ../../../../../../middleware/tfm/tf-m/interface/src/: tfm_crypto_ipc_api.c tfm_initial_attestation_ipc_api.c tfm_its_ipc_api.c tfm_ps_ipc_api.c tfm_platform_ipc_api.c tfm_psa_ns_api.c
  group tf-m/secure_fw/spm/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/: tfm_arch.h tfm_arch_v8m.h utilities.h
  group drivers
    ../../../../../../devices/MIMXRT595S/drivers/: fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c fsl_iap.h fsl_iap.c
  group utilities
    ../../../../../../devices/MIMXRT595S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT595S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT595S/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group tf-m-tests/app
    ../../../../../../middleware/tfm/tf-m-tests/app/: os_wrapper_cmsis_rtos_v2.c main_ns.c test_app.c test_app.h tfm_log.h tfm_ns_interface.c
  group tf-m-tests/log
    ../../../../../../middleware/tfm/tf-m-tests/log/: tfm_log_raw.c tfm_log_raw.h
  group tf-m-tests/ns_interface/os_wrapper
    ../../../../../../middleware/tfm/tf-m-tests/ns_interface/os_wrapper/: common.h delay.h msg_queue.h mutex.h semaphore.h thread.h
  group tf-m-tests/ns_interface/ns_client_ext
    ../../../../../../middleware/tfm/tf-m-tests/ns_interface/ns_client_ext/: tfm_nsid_manager.h tz_shim_layer.c
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group CMSIS/RTOS2/RTX/Source
    ../../../../../../CMSIS/RTOS2/RTX/Source/: rtx_core_c.h rtx_core_ca.h rtx_core_cm.h rtx_lib.h rtx_lib.c
  group CMSIS/RTOS2/RTX/Include
    ../../../../../../CMSIS/RTOS2/RTX/Include/: rtx_evr.h rtx_os.h rtx_def.h
  group CMSIS/RTOS2/RTX/Config
    ../../../../../../CMSIS/RTOS2/RTX/Config/: RTX_Config.c RTX_Config.h
  group CMSIS/RTOS2/Include
    ../../../../../../CMSIS/RTOS2/Include/: os_tick.h cmsis_os2.h
