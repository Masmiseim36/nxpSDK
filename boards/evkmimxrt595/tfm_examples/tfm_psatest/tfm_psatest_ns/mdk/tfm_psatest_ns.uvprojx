# Keil uVision project tfm_psatest_ns.uvprojx, settings and files
target tfm_psatest_ns debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tfm_psatest_ns.out
  BeforeMake: $KARM/ARMCLANG/bin/armclang --target=arm-arm-none-eabi -march=armv8-m.main -E -P -xc -I"$P../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/partition" "$P../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/armclang/tfm_common_ns.sct" -o "$P../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/armclang/tfm_common_ns_pre.sct"
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, TFM_LVL=2, ITS_MAX_ASSET_SIZE=512, PS_MAX_ASSET_SIZE=512, OS_DYNAMIC_MEM_SIZE=7168, PSA_API_TEST_NS=1, TF_M_PROFILE_MEDIUM, TFM_PSA_API, INITIAL_ATTESTATION, CRYPTO, INTERNAL_TRUSTED_STORAGE, ITS_TEST, PROTECTED_STORAGE, PS_TEST, SERIAL_PORT_TYPE_UART=1, CONFIG_TFM_FLOAT_ABI=2, CONFIG_TFM_ENABLE_CP10CP11, CONFIG_TFM_LAZY_STACKING, __DOMAIN_NS=1, DOMAIN_NS=1, CONFIG_TFM_USE_TRUSTZONE, ATTEST_TOKEN_PROFILE_PSA_IOT_1, PLATFORM_DEFAULT_CRYPTO_KEYS, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../../devices/MIMXRT595S;..;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/partition;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Include;../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest;../../../../../../middleware/tfm/tf-m/interface/include;../../../../../../middleware/tfm/psa-arch-tests/api-tests/val/nspe;../../../../../../middleware/tfm/psa-arch-tests/api-tests/val/common;../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/drivers/nvmem;../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/tgt_dev_apis_tfm_nxp/nspe;../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/common/nspe/crypto;../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/common/nspe;../../../../../../middleware/tfm/psa-arch-tests/api-tests/val;../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/common/nspe/initial_attestation;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/initial_attestation/test_a001;../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/inc;../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/src;../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/inc;../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/util;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/common;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c001;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c002;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c003;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c004;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c005;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c006;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c007;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c008;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c009;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c010;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c011;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c012;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c013;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c014;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c015;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c016;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c017;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c018;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c019;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c020;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c021;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c022;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c023;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c024;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c025;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c026;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c027;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c028;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c029;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c030;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c031;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c032;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c033;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c034;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c035;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c036;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c037;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c038;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c039;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c040;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c041;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c042;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c043;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c044;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c045;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c046;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c047;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c048;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c049;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c050;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c051;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c052;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c053;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c054;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c055;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c056;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c057;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c058;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c059;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c060;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c061;../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/common/nspe/internal_trusted_storage;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s001;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s002;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s003;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s004;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s005;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s006;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s007;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s008;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s009;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s010;../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/common/nspe/protected_storage;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s011;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s012;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s013;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s014;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s015;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s016;../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s017;../../../../../../devices/MIMXRT595S/drivers;../../../../../../devices/MIMXRT595S/utilities/str;../../../../../../devices/MIMXRT595S/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../flash_config;../../../../../../middleware/tfm/tf-m/platform/include;../../../../../../middleware/tfm/tf-m/platform/ext;../../../../../../middleware/tfm/tf-m/platform/ext/common;../../../../../../middleware/tfm/tf-m/platform/ext/driver;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Config;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Include;../../../../../../middleware/tfm/tf-m/interface/include/crypto_keys;../../../../../../middleware/tfm/tf-m/interface/include/psa;../../../../../../middleware/tfm/tf-m/bl2/include;../../../../../../middleware/tfm/tf-m/secure_fw/spm/include;../../../../../../middleware/tfm/tf-m/secure_fw/include/tfm;../../../../../../middleware/tfm/tf-m-tests/app;../../../../../../middleware/tfm/tf-m-tests/log;../../../../../../middleware/tfm/tf-m-tests/ns_interface;../../../../../../middleware/tfm/tf-m-tests/ns_interface/ns_client_ext;../../../../../../CMSIS/RTOS2/RTX/Source;../../../../../../CMSIS/RTOS2/RTX/Include;../../../../../../CMSIS/RTOS2/RTX/Config;../../../../../../CMSIS/RTOS2/Include;../../../../../../CMSIS/Core/Include
  asm define: DEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/armclang/tfm_common_ns_pre.sct
  link misc: ../../tfm_psatest_s/mdk/debug/tfm_psatest_s_CMSE_lib.o ../../../../../../CMSIS/RTOS2/RTX/Library/ARM/RTX_V8MMFN.lib --remove --entry=Reset_Handler
  group startup
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Source/armclang/: startup_MIMXRT595S_cm33_ns.S
  group device
    ../../../../../../devices/MIMXRT595S/: system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group board
    ../: pin_mux.c pin_mux.h hardware_init.c app.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group tf-m/platform/ext/target/nxp/evkmimxrt595
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/: target_cfg.h tfm_peripherals_def.h
  group tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Include/: platform_base_address.h
  group tf-m/platform/ext/target/nxp/evkmimxrt595/partition
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/partition/: region_defs.h flash_layout.h
  group tf-m/interface/include
    ../../../../../../middleware/tfm/tf-m/interface/include/: tfm_attest_defs.h config_impl.h tfm_veneers.h tfm_crypto_defs.h tfm_its_defs.h tfm_ps_defs.h tfm_api.h tfm_ns_interface.h psa_config.h tfm_psa_call_pack.h tfm_ns_client_ext.h tfm_platform_api.h
  group tf-m/interface/include/psa_manifest
    ../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest/: sid.h
  group tf-m/interface/src
    ../../../../../../middleware/tfm/tf-m/interface/src/: tfm_crypto_ipc_api.c tfm_initial_attestation_ipc_api.c tfm_its_ipc_api.c tfm_ps_ipc_api.c tfm_platform_ipc_api.c tfm_psa_ns_api.c
  group api-tests/val
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/val/: test_entry_list.inc test_entry_fn_declare_list.inc
  group api-tests/val/nspe
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/val/nspe/: pal_interfaces_ns.h val_attestation.c val_attestation.h val_crypto.c val_crypto.h val_entry.c val_entry.h val_framework.c val_framework.h val_dispatcher.c val_dispatcher.h val_interfaces.c val_interfaces.h val_peripherals.c val_peripherals.h val_storage.c val_storage.h
  group api-tests/val/common
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/val/common/: val.h val_client_defs.h val_target.c val_target.h
  group api-tests/platform/drivers/nvmem
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/drivers/nvmem/: pal_nvmem.c pal_nvmem.h
  group api-tests/platform/targets/tgt_dev_apis_tfm_nxp/nspe
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/tgt_dev_apis_tfm_nxp/nspe/: pal_attestation_config.h pal_config.h pal_crypto_config.h pal_driver_intf.c pal_storage_config.h target_database.h target_database.c
  group api-tests/platform/targets/common/nspe/crypto
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/common/nspe/crypto/: pal_crypto_config_check.h pal_crypto_intf.c pal_crypto_intf.h
  group api-tests/platform/targets/common/nspe
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/common/nspe/: pal_common.h
  group api-tests/platform/targets/common/nspe/initial_attestation
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/common/nspe/initial_attestation/: pal_attestation_crypto.c pal_attestation_crypto.h pal_attestation_eat.h pal_attestation_intf.c pal_attestation_intf.h
  group api-tests/dev_apis/initial_attestation/test_a001
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/initial_attestation/test_a001/: test_a001.c test_a001.h test_data.h test_entry_a001.c
  group tf-m/lib/ext/t_cose/inc
    ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/inc/: t_cose_sign1_sign.h t_cose_common.h
  group tf-m/lib/ext/qcbor/src
    ../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/src/: ieee754.c ieee754.h qcbor_decode.c qcbor_encode.c UsefulBuf.c
  group tf-m/lib/ext/qcbor/inc
    ../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/inc/: qcbor.h q_useful_buf.h UsefulBuf.h
  group api-tests/dev_apis/crypto/common
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/common/: test_crypto_common.c test_crypto_common.h
  group api-tests/dev_apis/crypto/test_c001
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c001/: test_c001.c test_c001.h test_entry_c001.c
  group api-tests/dev_apis/crypto/test_c002
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c002/: test_c002.c test_c002.h test_data.h test_entry_c002.c
  group api-tests/dev_apis/crypto/test_c003
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c003/: test_c003.c test_c003.h test_data.h test_entry_c003.c
  group api-tests/dev_apis/crypto/test_c004
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c004/: test_c004.c test_c004.h test_data.h test_entry_c004.c
  group api-tests/dev_apis/crypto/test_c005
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c005/: test_c005.c test_c005.h test_data.h test_entry_c005.c
  group api-tests/dev_apis/crypto/test_c006
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c006/: test_c006.c test_c006.h test_data.h test_entry_c006.c
  group api-tests/dev_apis/crypto/test_c007
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c007/: test_c007.c test_c007.h test_data.h test_entry_c007.c
  group api-tests/dev_apis/crypto/test_c008
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c008/: test_c008.c test_c008.h test_data.h test_entry_c008.c
  group api-tests/dev_apis/crypto/test_c009
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c009/: test_c009.c test_c009.h test_data.h test_entry_c009.c
  group api-tests/dev_apis/crypto/test_c010
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c010/: test_c010.c test_c010.h test_data.h test_entry_c010.c
  group api-tests/dev_apis/crypto/test_c011
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c011/: test_c011.c test_c011.h test_data.h test_entry_c011.c
  group api-tests/dev_apis/crypto/test_c012
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c012/: test_c012.c test_c012.h test_data.h test_entry_c012.c
  group api-tests/dev_apis/crypto/test_c013
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c013/: test_c013.c test_c013.h test_data.h test_entry_c013.c
  group api-tests/dev_apis/crypto/test_c014
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c014/: test_c014.c test_c014.h test_data.h test_entry_c014.c
  group api-tests/dev_apis/crypto/test_c015
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c015/: test_c015.c test_c015.h test_data.h test_entry_c015.c
  group api-tests/dev_apis/crypto/test_c016
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c016/: test_c016.c test_c016.h test_data.h test_entry_c016.c
  group api-tests/dev_apis/crypto/test_c017
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c017/: test_c017.c test_c017.h test_data.h test_entry_c017.c
  group api-tests/dev_apis/crypto/test_c018
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c018/: test_c018.c test_c018.h test_data.h test_entry_c018.c
  group api-tests/dev_apis/crypto/test_c019
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c019/: test_c019.c test_c019.h test_data.h test_entry_c019.c
  group api-tests/dev_apis/crypto/test_c020
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c020/: test_c020.c test_c020.h test_data.h test_entry_c020.c
  group api-tests/dev_apis/crypto/test_c021
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c021/: test_c021.c test_c021.h test_data.h test_entry_c021.c
  group api-tests/dev_apis/crypto/test_c022
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c022/: test_c022.c test_c022.h test_data.h test_entry_c022.c
  group api-tests/dev_apis/crypto/test_c023
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c023/: test_c023.c test_c023.h test_data.h test_entry_c023.c
  group api-tests/dev_apis/crypto/test_c024
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c024/: test_c024.c test_c024.h test_data.h test_entry_c024.c
  group api-tests/dev_apis/crypto/test_c025
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c025/: test_c025.c test_c025.h test_data.h test_entry_c025.c
  group api-tests/dev_apis/crypto/test_c031
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c031/: test_c031.c test_c031.h test_data.h test_entry_c031.c
  group api-tests/dev_apis/crypto/test_c032
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c032/: test_c032.c test_c032.h test_data.h test_entry_c032.c
  group api-tests/dev_apis/crypto/test_c033
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c033/: test_c033.c test_c033.h test_data.h test_entry_c033.c
  group api-tests/dev_apis/crypto/test_c039
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c039/: test_c039.c test_c039.h test_data.h test_entry_c039.c
  group api-tests/dev_apis/crypto/test_c040
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c040/: test_c040.c test_c040.h test_data.h test_entry_c040.c
  group api-tests/dev_apis/crypto/test_c041
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c041/: test_c041.c test_c041.h test_data.h test_entry_c041.c
  group api-tests/dev_apis/crypto/test_c042
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c042/: test_c042.c test_c042.h test_data.h test_entry_c042.c
  group api-tests/dev_apis/crypto/test_c043
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c043/: test_c043.c test_c043.h test_data.h test_entry_c043.c
  group api-tests/dev_apis/crypto/test_c044
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c044/: test_c044.c test_c044.h test_data.h test_entry_c044.c
  group api-tests/dev_apis/crypto/test_c045
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c045/: test_c045.c test_c045.h test_data.h test_entry_c045.c
  group api-tests/dev_apis/crypto/test_c046
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c046/: test_c046.c test_c046.h test_data.h test_entry_c046.c
  group api-tests/dev_apis/crypto/test_c047
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c047/: test_c047.c test_c047.h test_data.h test_entry_c047.c
  group api-tests/dev_apis/crypto/test_c052
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c052/: test_c052.c test_c052.h test_data.h test_entry_c052.c
  group api-tests/dev_apis/crypto/test_c053
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c053/: test_c053.c test_c053.h test_data.h test_entry_c053.c
  group api-tests/dev_apis/crypto/test_c054
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c054/: test_c054.c test_c054.h test_data.h test_entry_c054.c
  group api-tests/dev_apis/crypto/test_c055
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c055/: test_c055.c test_c055.h test_data.h test_entry_c055.c
  group api-tests/dev_apis/crypto/test_c056
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c056/: test_c056.c test_c056.h test_data.h test_entry_c056.c
  group api-tests/dev_apis/crypto/test_c057
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c057/: test_c057.c test_c057.h test_data.h test_entry_c057.c
  group api-tests/dev_apis/crypto/test_c058
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c058/: test_c058.c test_c058.h test_data.h test_entry_c058.c
  group api-tests/dev_apis/crypto/test_c059
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c059/: test_c059.c test_c059.h test_data.h test_entry_c059.c
  group api-tests/dev_apis/crypto/test_c060
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c060/: test_c060.c test_c060.h test_data.h test_entry_c060.c
  group api-tests/dev_apis/crypto/test_c061
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c061/: test_c061.c test_c061.h test_data.h test_entry_c061.c
  group api-tests/platform/targets/common/nspe/internal_trusted_storage
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/common/nspe/internal_trusted_storage/: pal_internal_trusted_storage_intf.c pal_internal_trusted_storage_intf.h
  group api-tests/dev_apis/storage
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/: test_storage_common.h test_storage_common.h
  group api-tests/dev_apis/storage/test_s001
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s001/: test_s001.c test_s001.h test_data.h test_entry_s001.c test_s001.c test_s001.h test_data.h test_entry_s001.c
  group api-tests/dev_apis/storage/test_s002
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s002/: test_s002.c test_s002.h test_data.h test_entry_s002.c test_s002.c test_s002.h test_data.h test_entry_s002.c
  group api-tests/dev_apis/storage/test_s003
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s003/: test_s003.c test_s003.h test_data.h test_entry_s003.c test_s003.c test_s003.h test_data.h test_entry_s003.c
  group api-tests/dev_apis/storage/test_s004
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s004/: test_s004.c test_s004.h test_data.h test_entry_s004.c test_s004.c test_s004.h test_data.h test_entry_s004.c
  group api-tests/dev_apis/storage/test_s005
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s005/: test_s005.c test_s005.h test_data.h test_entry_s005.c test_s005.c test_s005.h test_data.h test_entry_s005.c
  group api-tests/dev_apis/storage/test_s006
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s006/: test_s006.c test_s006.h test_data.h test_entry_s006.c test_s006.c test_s006.h test_data.h test_entry_s006.c
  group api-tests/dev_apis/storage/test_s007
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s007/: test_s007.c test_s007.h test_data.h test_entry_s007.c test_s007.c test_s007.h test_data.h test_entry_s007.c
  group api-tests/dev_apis/storage/test_s008
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s008/: test_s008.c test_s008.h test_data.h test_entry_s008.c test_s008.c test_s008.h test_data.h test_entry_s008.c
  group api-tests/dev_apis/storage/test_s009
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s009/: test_s009.c test_s009.h test_data.h test_entry_s009.c test_s009.c test_s009.h test_data.h test_entry_s009.c
  group api-tests/dev_apis/storage/test_s010
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s010/: test_s010.c test_s010.h test_data.h test_entry_s010.c test_s010.c test_s010.h test_data.h test_entry_s010.c
  group api-tests/platform/targets/common/nspe/protected_storage
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/common/nspe/protected_storage/: pal_protected_storage_intf.c pal_protected_storage_intf.h
  group api-tests/dev_apis/storage/test_s011
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s011/: test_s011.c test_s011.h test_data.h test_entry_s011.c
  group api-tests/dev_apis/storage/test_s012
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s012/: test_s012.c test_s012.h test_data.h test_entry_s012.c
  group api-tests/dev_apis/storage/test_s013
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s013/: test_s013.c test_s013.h test_data.h test_entry_s013.c
  group api-tests/dev_apis/storage/test_s014
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s014/: test_s014.c test_s014.h test_data.h test_entry_s014.c
  group api-tests/dev_apis/storage/test_s015
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s015/: test_s015.c test_s015.h test_data.h test_entry_s015.c
  group api-tests/dev_apis/storage/test_s016
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s016/: test_s016.c test_s016.h test_data.h test_entry_s016.c
  group api-tests/dev_apis/storage/test_s017
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s017/: test_s017.c test_s017.h test_data.h test_entry_s017.c
  group drivers
    ../../../../../../devices/MIMXRT595S/drivers/: fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c fsl_iap.h fsl_iap.c
  group utilities
    ../../../../../../devices/MIMXRT595S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT595S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT595S/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group tf-m/platform/include
    ../../../../../../middleware/tfm/tf-m/platform/include/: tfm_plat_crypto_keys.h tfm_hal_device_header.h tfm_plat_boot_seed.h tfm_plat_device_id.h tfm_plat_defs.h tfm_plat_ns.h region.h tfm_plat_test.h
  group tf-m/platform/ext/common
    ../../../../../../middleware/tfm/tf-m/platform/ext/common/: uart_stdout.h uart_stdout.c
  group tf-m/platform/ext/driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/driver/: Driver_USART.h Driver_Common.h
  group tf-m/platform/ext/target/nxp/common/CMSIS_Driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/CMSIS_Driver/: Driver_USART.c
  group tf-m/platform/ext/target/nxp/common/Device/Include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Include/: cmsis.h device_definition.h platform_irq.h platform_regs.h
  group tf-m/platform/ext/target/nxp/common/Device/Config
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Config/: device_cfg.h
  group tf-m/interface/include/crypto_keys
    ../../../../../../middleware/tfm/tf-m/interface/include/crypto_keys/: tfm_builtin_key_ids.h
  group tf-m/interface/include/psa
    ../../../../../../middleware/tfm/tf-m/interface/include/psa/: client.h crypto.h crypto_client_struct.h crypto_extra.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h error.h framework_feature.h initial_attestation.h internal_trusted_storage.h lifecycle.h protected_storage.h service.h storage_common.h crypto_compat.h
  group tf-m/secure_fw/spm/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/: tfm_arch.h tfm_arch_v8m.h utilities.h
  group tf-m-tests/app
    ../../../../../../middleware/tfm/tf-m-tests/app/: os_wrapper_cmsis_rtos_v2.c main_ns.c test_app.c test_app.h tfm_log.h tfm_ns_interface.c
  group tf-m-tests/log
    ../../../../../../middleware/tfm/tf-m-tests/log/: tfm_log_raw.c tfm_log_raw.h
  group tf-m-tests/ns_interface/os_wrapper
    ../../../../../../middleware/tfm/tf-m-tests/ns_interface/os_wrapper/: common.h delay.h msg_queue.h mutex.h semaphore.h thread.h
  group tf-m-tests/ns_interface/ns_client_ext
    ../../../../../../middleware/tfm/tf-m-tests/ns_interface/ns_client_ext/: tfm_nsid_manager.h tz_shim_layer.c
  group CMSIS/RTOS2/RTX/Source
    ../../../../../../CMSIS/RTOS2/RTX/Source/: rtx_core_c.h rtx_core_ca.h rtx_core_cm.h rtx_lib.h rtx_lib.c
  group CMSIS/RTOS2/RTX/Include
    ../../../../../../CMSIS/RTOS2/RTX/Include/: rtx_evr.h rtx_os.h rtx_def.h
  group CMSIS/RTOS2/RTX/Config
    ../../../../../../CMSIS/RTOS2/RTX/Config/: RTX_Config.c RTX_Config.h
  group CMSIS/RTOS2/Include
    ../../../../../../CMSIS/RTOS2/Include/: os_tick.h cmsis_os2.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target tfm_psatest_ns release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tfm_psatest_ns.out
  BeforeMake: as above
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, TFM_LVL=2, ITS_MAX_ASSET_SIZE=512, PS_MAX_ASSET_SIZE=512, OS_DYNAMIC_MEM_SIZE=7168, PSA_API_TEST_NS=1, TF_M_PROFILE_MEDIUM, TFM_PSA_API, INITIAL_ATTESTATION, CRYPTO, INTERNAL_TRUSTED_STORAGE, ITS_TEST, PROTECTED_STORAGE, PS_TEST, SERIAL_PORT_TYPE_UART=1, CONFIG_TFM_FLOAT_ABI=2, CONFIG_TFM_ENABLE_CP10CP11, CONFIG_TFM_LAZY_STACKING, __DOMAIN_NS=1, DOMAIN_NS=1, CONFIG_TFM_USE_TRUSTZONE, ATTEST_TOKEN_PROFILE_PSA_IOT_1, PLATFORM_DEFAULT_CRYPTO_KEYS, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: as above
  link misc: ../../tfm_psatest_s/mdk/release/tfm_psatest_s_CMSE_lib.o ../../../../../../CMSIS/RTOS2/RTX/Library/ARM/RTX_V8MMFN.lib --remove --entry=Reset_Handler
