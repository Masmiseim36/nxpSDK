# Keil uVision project tfm_psatest_s.uvprojx, settings and files
target tfm_psatest_s debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tfm_psatest_s.out
  BeforeMake: $KARM/ARMCLANG/bin/armclang -DCONFIG_TFM_PARTITION_META -DENABLE_HEAP -D__ARM_ARCH_8M_MAIN__ -DCONFIG_TFM_USE_TRUSTZONE --target=arm-arm-none-eabi -march=armv8-m.main -E -P -xc -I"$P/../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/partition" -I"$P/../../../../../../middleware/tfm/tf-m/platform/ext/common" "$P/../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/armclang/tfm_common_s.sct" -o "$P/../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/armclang/tfm_common_s_pre.sct"
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, TFM_SPM_LOG_LEVEL=TFM_SPM_LOG_LEVEL_INFO, TFM_SP_LOG_RAW_ENABLED, TFM_PARTITION_LOG_LEVEL=TFM_PARTITION_LOG_LEVEL_INFO, PS_WIPE_ALL, ITS_WIPE_ALL, PLATFORM_NO_FLASH, OTP_NV_COUNTERS_RAM_EMULATION, DAUTH_CHIP_DEFAULT, __SEMIHOST_HARDFAULT_DISABLE, MCUXPRESSO_SDK, TFM_LVL=2, PROJECT_CONFIG_HEADER_FILE='\"config_profile_large.h\"', MBEDTLS_CONFIG_FILE='\"tfm_mbedcrypto_config_profile_large.h\"', MBEDTLS_PSA_CRYPTO_CONFIG_FILE='\"crypto_config_profile_large.h\"', PS_CRYPTO_AEAD_ALG=PSA_ALG_CCM, CONFIG_TFM_BUILDING_SPE=1, CONFIG_TFM_ENABLE_MEMORY_PROTECT, TFM_PARTITION_NS_AGENT_TZ, TFM_PARTITION_IDLE, PLATFORM_DEFAULT_NV_COUNTERS, PLATFORM_DEFAULT_OTP, PLATFORM_DEFAULT_PROVISIONING, OTP_WRITEABLE, TFM_DUMMY_PROVISIONING, CONFIG_TFM_PARTITION_META, CONFIG_TFM_FLOAT_ABI=2, CONFIG_TFM_ENABLE_CP10CP11, CONFIG_TFM_LAZY_STACKING, CONFIG_TFM_HALT_ON_CORE_PANIC, CONFIG_TFM_USE_TRUSTZONE, ATTEST_TOKEN_PROFILE_PSA_IOT_1, TEST_NS_ATTESTATION, TEST_S_ATTESTATION, PS_ENCRYPTION, PS_ROLLBACK_PROTECTION, TFM_PARTITION_PROTECTED_STORAGE, SERIAL_PORT_TYPE_UART=1, TFM_PARTITION_CRYPTO, PLATFORM_DEFAULT_CRYPTO_KEYS, MBEDTLS_PSA_CRYPTO_DRIVERS, MBEDTLS_PSA_CRYPTO_BUILTIN_KEYS, PSA_CRYPTO_DRIVER_TFM_BUILTIN_KEY, PSA_CRYPTO_DRIVER_TFM_BUILTIN_KEY_LOADER, ATTEST_KEY_BITS=256, T_COSE_DISABLE_MAC0, T_COSE_DISABLE_ES384, T_COSE_DISABLE_ES512, TFM_PARTITION_INTERNAL_TRUSTED_STORAGE, TFM_PARTITION_PLATFORM, CRYPTO_HW_ACCELERATOR, TFM_PARTITION_INITIAL_ATTESTATION, T_COSE_USE_PSA_CRYPTO, QCBOR_DISABLE_FLOAT_HW_USE, USEFULBUF_DISABLE_ALL_FLOAT, QCBOR_DISABLE_PREFERRED_FLOAT, TARGET_CONFIG_HEADER_FILE='\"config_tfm_target.h\"'
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -Wno-gnu-variable-sized-type-not-at-end
  c include: ../../../../../../devices/MIMXRT595S;..;../../../../../../devices/MIMXRT595S/drivers;../../../../../../middleware/tfm/tf-m/lib/ext/mbedcrypto/mbedcrypto_config;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common;../../../../../../middleware/tfm/tf-m/config/profile;../../../../../../middleware/tfm/tf-m;../../../../../../middleware/tfm/tf-m/bl2/include;../../../../../../middleware/tfm/tf-m/bl2/ext/mcuboot/bootutil/include/bootutil;../../../../../../middleware/tfm/tf-m/platform/ext;../../../../../../middleware/tfm/tf-m/platform/ext/common;../../../../../../middleware/tfm/tf-m/platform/ext/common/template;../../../../../../middleware/tfm/tf-m/platform/ext/driver;../../../../../../middleware/tfm/tf-m/platform/ext/target/arm/drivers/mpu/armv8m;../../../../../../middleware/tfm/tf-m/platform/ext/accelerator/interface;../../../../../../middleware/tfm/tf-m/platform/include;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Config;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Include;../../../../../../middleware/tfm/tf-m/interface/include/psa;../../../../../../middleware/tfm/tf-m/interface/include;../../../../../../middleware/tfm/tf-m/interface/include/crypto_keys;../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest;../../../../../../middleware/tfm/tf-m/secure_fw/include;../../../../../../middleware/tfm/tf-m/secure_fw/include/tfm;../../../../../../middleware/tfm/tf-m/secure_fw/spm;../../../../../../middleware/tfm/tf-m/secure_fw/spm/include;../../../../../../middleware/tfm/tf-m/secure_fw/spm/cmsis_psa;../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/boot;../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/ffm;../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/interface;../../../../../../middleware/tfm/tf-m/secure_fw/partitions;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/psa_manifest;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/psa_manifest;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform/psa_manifest;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation/psa_manifest;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/psa_manifest;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/lib/runtime/include;../../../../../../middleware/tfm/tf-m/lib/fih/inc;../../../../../../middleware/tfm/tf-m/config;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/crypto;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/nv_counters;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform;../../../../../../devices/MIMXRT595S/utilities/str;../../../../../../devices/MIMXRT595S/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../flash_config;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/psa_driver_api;../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/src;../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/inc;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/flash;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/flash_fs;../../../../../../middleware/tfm/mbed-crypto/include/psa;../../../../../../middleware/tfm/mbed-crypto/library;../../../../../../middleware/tfm/mbed-crypto/include/mbedtls;../../../../../../middleware/tfm/mbed-crypto/port;../../../../../../middleware/tfm/mbed-crypto/include;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation;../../../../../../middleware/tfm/qcbor/src;../../../../../../middleware/tfm/qcbor/inc;../../../../../../middleware/tfm/qcbor/inc/qcbor;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Include;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/partition;../../../../../../CMSIS/Core/Include
  asm define: DEBUG
  asm include: ../../../../../../middleware/tfm/tf-m/platform/include
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/armclang/tfm_common_s_pre.sct
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314 --import-cmse-lib-out="./debug/tfm_psatest_s_CMSE_lib.o"
  group startup
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Source/: startup_evkmimxrt595.c
  group device
    ../../../../../../devices/MIMXRT595S/: system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group board
    ../: pin_mux.c pin_mux.h hardware_init.c app.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MIMXRT595S/drivers/: fsl_casper.h fsl_casper.c fsl_hashcrypt.h fsl_hashcrypt.c fsl_trng.c fsl_trng.h fsl_ctimer.h fsl_ctimer.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c fsl_iap.h fsl_iap.c
  group tf-m/platform/ext/target/nxp/common/CMSIS_Driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/CMSIS_Driver/: Driver_Flash_iap.c Driver_USART.c
  group tf-m/lib/ext/mbedcrypto/mbedcrypto_config
    ../../../../../../middleware/tfm/tf-m/lib/ext/mbedcrypto/mbedcrypto_config/: tfm_mbedcrypto_config_profile_large.h crypto_config_profile_large.h tfm_mbedcrypto_config_extra_nv_seed.h
  group tf-m/config/profile
    ../../../../../../middleware/tfm/tf-m/config/profile/: config_profile_large.h
  group tf-m/lib/fih/inc
    ../../../../../../middleware/tfm/tf-m/lib/fih/inc/: fih.h tfm_fih_rng.h
  group tf-m/lib/fih/src
    ../../../../../../middleware/tfm/tf-m/lib/fih/src/: fih.c
  group tf-m/platform/ext/common
    ../../../../../../middleware/tfm/tf-m/platform/ext/common/: common_target_cfg.h core_ext.h exception_info.c faults.c provisioning.c tfm_hal_its.c tfm_hal_nvic.c tfm_hal_ps.c tfm_hal_sp_logdev.h tfm_hal_sp_logdev_periph.c tfm_hal_spm_logdev.h tfm_hal_spm_logdev_peripheral.c tfm_hal_reset_halt.c tfm_s_linker_alignments.h uart_stdout.c uart_stdout.h
  group tf-m/platform/ext/driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/driver/: Driver_Common.h Driver_Flash.h Driver_MPC.h Driver_PPC.h Driver_USART.h
  group tf-m/platform/ext/common/template
    ../../../../../../middleware/tfm/tf-m/platform/ext/common/template/: attest_hal.c crypto_keys.c flash_otp_nv_counters_backend.c flash_otp_nv_counters_backend.h nv_counters.c otp_flash.c tfm_initial_attest_pub_key.c
  group tf-m/platform/ext/accelerator/interface
    ../../../../../../middleware/tfm/tf-m/platform/ext/accelerator/interface/: crypto_hw.h
  group tf-m/platform/ext/target/arm/drivers/mpu/armv8m
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/arm/drivers/mpu/armv8m/: mpu_armv8m_drv.c mpu_armv8m_drv.h
  group tf-m/platform/ext/target/nxp/common
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/: libc_dummy.c crypto_hw.c faults.c tfm_hal_isolation.c mmio_defs.h plat_huk.c tfm_hal_platform.c tfm_interrupts.c
  group tf-m/platform/ext/target/nxp/common/services/src
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/services/src/: tfm_platform_system.c
  group tf-m/platform/ext/target/nxp/common/Device/Config
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Config/: device_cfg.h
  group tf-m/platform/ext/target/nxp/common/Device/Include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Include/: cmsis.h device_definition.h platform_description.h platform_irq.h platform_regs.h
  group tf-m/platform/include
    ../../../../../../middleware/tfm/tf-m/platform/include/: cmsis_override.h exception_info.h mbedtls_entropy_nv_seed_config.h region.h tfm_attest_hal.h tfm_hal_defs.h tfm_hal_device_header.h tfm_hal_interrupt.h tfm_hal_isolation.h tfm_hal_its.h tfm_hal_platform.h tfm_hal_ps.h tfm_plat_boot_seed.h tfm_plat_config.h tfm_plat_crypto_keys.h tfm_plat_defs.h tfm_plat_device_id.h tfm_plat_ns.h tfm_plat_nv_counters.h tfm_plat_otp.h tfm_plat_provisioning.h tfm_plat_test.h tfm_platform_system.h
  group tf-m/interface/include/crypto_keys
    ../../../../../../middleware/tfm/tf-m/interface/include/crypto_keys/: tfm_builtin_key_ids.h
  group tf-m/interface/include/psa
    ../../../../../../middleware/tfm/tf-m/interface/include/psa/: client.h crypto_client_struct.h error.h framework_feature.h initial_attestation.h internal_trusted_storage.h lifecycle.h protected_storage.h service.h storage_common.h
  group tf-m/interface/include/psa/tfm
    ../../../../../../middleware/tfm/tf-m/interface/include/psa/tfm/: crypto.h crypto_compat.h crypto_extra.h crypto_platform.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group tf-m/interface/include
    ../../../../../../middleware/tfm/tf-m/interface/include/: config_impl.h tfm_api.h tfm_crypto_defs.h tfm_ns_client_ext.h tfm_platform_api.h tfm_psa_call_pack.h tfm_ps_defs.h tfm_its_defs.h tfm_attest_defs.h tfm_attest_iat_defs.h
  group tf-m/interface/include/psa_manifest
    ../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest/: pid.h sid.h
  group tf-m/secure_fw/spm/include/boot
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/boot/: tfm_boot_status.h
  group tf-m/secure_fw/spm/include/interface
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/interface/: runtime_defs.h svc_num.h
  group tf-m/secure_fw/spm/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/: aapcs_local.h bitops.h critical_section.h config_spm.h current.h lists.h tfm_core_trustzone.h tfm_nspm.h tfm_spm_log.h tfm_version.h utilities.h tfm_arch.h tfm_arch_v8m.h
  group tf-m/secure_fw/spm/include/ffm
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/ffm/: backend.h backend_ipc.h backend_sfn.h psa_api.h
  group tf-m/secure_fw/spm/include/load
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/load/: asset_defs.h interrupt_defs.h partition_defs.h service_defs.h spm_load_api.h
  group tf-m/secure_fw/spm/ffm
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/ffm/: backend_ipc.c psa_api.c psa_call_api.c psa_connection_api.c psa_irq_api.c psa_mmiovec_api.c psa_read_write_skip_api.c psa_version_api.c interrupt.c interrupt.h spm_log.c stack_watermark.c stack_watermark.h tfm_boot_data.c tfm_boot_data.h utilities.c
  group tf-m/secure_fw/spm/ns_client_ext
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/ns_client_ext/: tfm_ns_ctx.h tfm_spm_ns_ctx.c
  group tf-m/secure_fw/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/include/: array.h build_config_check.h compiler_ext_defs.h config_tfm.h security_defs.h
  group tf-m/config
    ../../../../../../middleware/tfm/tf-m/config/: config_base.h
  group tf-m/secure_fw/partitions/lib/runtime/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/lib/runtime/include/: service_api.h tfm_sp_log.h tfm_strnlen.h
  group tf-m/secure_fw/partitions/lib/runtime
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/lib/runtime/: service_api.c sfn_common_thread.c sprt_partition_metadata_indicator.c sprt_partition_metadata_indicator.h tfm_sp_log_raw.c crt_strnlen.c psa_api_ipc.c
  group tf-m/interface/src
    ../../../../../../middleware/tfm/tf-m/interface/src/: tfm_psa_call_pack.c tfm_ps_api.c tfm_crypto_api.c tfm_its_api.c tfm_platform_api.c tfm_attest_api.c
  group tf-m/secure_fw/partitions/ns_agent_tz
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/ns_agent_tz/: load_info_ns_agent_tz.c ns_agent_tz_v80m.c psa_api_veneers_v80m.c
  group tf-m/secure_fw/partitions/idle_partition
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/idle_partition/: idle_partition.c load_info_idle_sp.c
  group tf-m/secure_fw/spm/cmsis_psa
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/cmsis_psa/: internal_status_code.h main.c memory_symbols.h tfm_pools.h tfm_rpc.h tfm_svcalls.h psa_interface_svc.c rom_loader.c spm_ipc.c spm.h tfm_core_svcalls_ipc.c tfm_pools.c thread.c thread.h
  group tf-m/secure_fw/spm/cmsis_psa/arch
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/cmsis_psa/arch/: tfm_arch.c tfm_arch_v8m_main.c
  group tf-m/secure_fw/partitions/protected_storage/auto_generated
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/auto_generated/: intermedia_tfm_protected_storage.c load_info_tfm_protected_storage.c
  group tf-m/secure_fw/partitions/protected_storage/crypto
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/crypto/: ps_crypto_interface.c ps_crypto_interface.h
  group tf-m/secure_fw/partitions/protected_storage
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/: config_ps_check.h ps_encrypted_object.c ps_encrypted_object.h ps_object_defs.h ps_object_system.c ps_object_system.h ps_object_table.c ps_object_table.h ps_utils.c ps_utils.h tfm_protected_storage.c tfm_protected_storage.h tfm_ps_req_mngr.h tfm_ps_req_mngr.c ps_object_defs.h config_ps_check.h
  group tf-m/secure_fw/partitions/protected_storage/psa_manifest
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/psa_manifest/: tfm_protected_storage.h
  group tf-m/secure_fw/partitions/protected_storage/nv_counters
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/nv_counters/: ps_nv_counters.h ps_nv_counters.c
  group utilities
    ../../../../../../devices/MIMXRT595S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT595S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT595S/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group tf-m/secure_fw/partitions/crypto/auto_generated
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/auto_generated/: intermedia_tfm_crypto.c load_info_tfm_crypto.c
  group tf-m/secure_fw/partitions/crypto/psa_driver_api
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/psa_driver_api/: tfm_builtin_key_loader.c tfm_builtin_key_loader.h
  group tf-m/secure_fw/partitions/crypto
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/: config_engine_buf.h config_crypto_check.h crypto_aead.c crypto_alloc.c crypto_asymmetric.c crypto_check_config.h crypto_cipher.c crypto_hash.c crypto_init.c crypto_key_derivation.c crypto_key_management.c crypto_library.c crypto_library.h crypto_mac.c crypto_rng.c crypto_spe.h tfm_crypto_api.h tfm_crypto_key.h tfm_mbedcrypto_include.h
  group tf-m/secure_fw/partitions/crypto/psa_manifest
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/psa_manifest/: tfm_crypto.h
  group tf-m/secure_fw/partitions/initial_attestation
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation/: attest_asymmetric_key.c attest.h attest_boot_data.c attest_boot_data.h attest_core.c attest_key.h attest_token.h attest_token_encode.c tfm_attest.c tfm_attest_req_mngr.c
  group tf-m/lib/ext/t_cose/src
    ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/src/: t_cose_sign1_sign.c t_cose_crypto.h t_cose_parameters.c t_cose_parameters.h t_cose_standard_constants.h t_cose_util.c t_cose_util.h
  group tf-m/lib/ext/t_cose/inc
    ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/inc/: t_cose_sign1_sign.h t_cose_common.h q_useful_buf.h
  group tf-m/secure_fw/partitions/internal_trusted_storage/auto_generated
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/auto_generated/: intermedia_tfm_internal_trusted_storage.c load_info_tfm_internal_trusted_storage.c
  group tf-m/secure_fw/partitions/internal_trusted_storage
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/: its_utils.c its_utils.h tfm_internal_trusted_storage.c tfm_internal_trusted_storage.h tfm_its_req_mngr.c tfm_its_req_mngr.h
  group tf-m/secure_fw/partitions/internal_trusted_storage/psa_manifest
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/psa_manifest/: tfm_internal_trusted_storage.h
  group tf-m/secure_fw/partitions/internal_trusted_storage/flash
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/flash/: its_flash.c its_flash.h its_flash_nand.c its_flash_nand.h its_flash_nor.c its_flash_nor.h its_flash_ram.c its_flash_ram.h
  group tf-m/secure_fw/partitions/internal_trusted_storage/flash_fs
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/flash_fs/: its_flash_fs.c its_flash_fs.h its_flash_fs_dblock.c its_flash_fs_dblock.h its_flash_fs_mblock.c its_flash_fs_mblock.h
  group tf-m/secure_fw/partitions/platform/auto_generated
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform/auto_generated/: intermedia_tfm_platform.c load_info_tfm_platform.c
  group tf-m/secure_fw/partitions/platform
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform/: platform_sp.c platform_sp.h
  group tf-m/secure_fw/partitions/platform/psa_manifest
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform/psa_manifest/: tfm_platform.h
  group mbed-crypto/include/psa
    ../../../../../../middleware/tfm/mbed-crypto/include/psa/: crypto_driver_contexts_composites.h crypto_driver_contexts_primitives.h crypto.h crypto_builtin_composites.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_extra.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group mbed-crypto/library
    ../../../../../../middleware/tfm/mbed-crypto/library/: psa_crypto_driver_wrappers.c aes.c aesni.c aesni.h asn1parse.c asn1write.c base64.c bignum.c bignum_core.c bignum_core.h bignum_mod.c bignum_mod.h bignum_mod_raw.c bignum_mod_raw.h bn_mul.h camellia.c ccm.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cipher_wrap.h cmac.c common.h constant_time.c constant_time_internal.h constant_time_invasive.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_internal_alt.h ecp_invasive.h entropy.c entropy_poll.c entropy_poll.h error.c gcm.c hash_info.c hash_info.h hkdf.c hmac_drbg.c lmots.c lmots.h lms.c md.c md_wrap.h md5.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c padlock.h pem.c pk.c pk_wrap.c pk_wrap.h pkcs5.c pkcs12.c pkparse.c pkwrite.c pkwrite.h platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_driver_wrappers.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_pake.c psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_alt_helpers.c rsa_alt_helpers.h sha1.c sha256.c sha512.c threading.c timing.c version.c version_features.c
  group mbed-crypto/include/mbedtls
    ../../../../../../middleware/tfm/mbed-crypto/include/mbedtls/: aes.h aria.h asn1.h asn1write.h base64.h bignum.h build_info.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cipher.h compat-2.x.h cmac.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h error.h gcm.h hkdf.h hmac_drbg.h legacy_or_psa.h lms.h md.h md5.h memory_buffer_alloc.h nist_kw.h oid.h pem.h pk.h pkcs5.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h private_access.h psa_util.h ripemd160.h rsa.h sha1.h sha256.h sha512.h threading.h timing.h version.h
  group mbed-crypto/port
    ../../../../../../middleware/tfm/mbed-crypto/port/: aes_alt.h mbedcrypto_mcux_casper.c mbedcrypto_mcux_css.c mbedcrypto_mcux_els.c mbedcrypto_mcux_hashcrypt.c mbedcrypto_mcux_config.h mbedcrypto_mcux_entropy.c mbedcrypto_mcux_pkc.c mbedcrypto_mcux_sss.c mbedtls_accelerator_config.h sha1_alt.h sha256_alt.h sha512_alt.h ecdsa_alt.h ecdh_alt.h ccm_alt.h
  group tf-m/secure_fw/partitions/initial_attestation/auto_generated
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation/auto_generated/: intermedia_tfm_initial_attestation.c load_info_tfm_initial_attestation.c
  group tf-m/secure_fw/partitions/initial_attestation/psa_manifest
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation/psa_manifest/: tfm_initial_attestation.h
  group tf-m/lib/ext/t_cose/crypto_adapters
    ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/crypto_adapters/: t_cose_psa_crypto.c
  group qcbor/src
    ../../../../../../middleware/tfm/qcbor/src/: ieee754.c ieee754.h qcbor_decode.c qcbor_encode.c UsefulBuf.c
  group qcbor/inc/qcbor
    ../../../../../../middleware/tfm/qcbor/inc/qcbor/: qcbor.h qcbor_common.h qcbor_decode.h qcbor_encode.h qcbor_private.h qcbor_spiffy_decode.h UsefulBuf.h
  group tf-m/platform/ext/target/nxp/evkmimxrt595
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/: config_tfm_target.h target_cfg.c target_cfg.h tfm_peripherals_def.h
  group tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Include/: platform_base_address.h
  group tf-m/platform/ext/target/nxp/evkmimxrt595/partition
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/partition/: flash_layout.h region_defs.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target tfm_psatest_s release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tfm_psatest_s.out
  BeforeMake: as above
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, TFM_SPM_LOG_LEVEL=TFM_SPM_LOG_LEVEL_INFO, TFM_SP_LOG_RAW_ENABLED, TFM_PARTITION_LOG_LEVEL=TFM_PARTITION_LOG_LEVEL_INFO, PS_WIPE_ALL, ITS_WIPE_ALL, PLATFORM_NO_FLASH, OTP_NV_COUNTERS_RAM_EMULATION, DAUTH_CHIP_DEFAULT, __SEMIHOST_HARDFAULT_DISABLE, MCUXPRESSO_SDK, TFM_LVL=2, PROJECT_CONFIG_HEADER_FILE='\"config_profile_large.h\"', MBEDTLS_CONFIG_FILE='\"tfm_mbedcrypto_config_profile_large.h\"', MBEDTLS_PSA_CRYPTO_CONFIG_FILE='\"crypto_config_profile_large.h\"', PS_CRYPTO_AEAD_ALG=PSA_ALG_CCM, CONFIG_TFM_BUILDING_SPE=1, CONFIG_TFM_ENABLE_MEMORY_PROTECT, TFM_PARTITION_NS_AGENT_TZ, TFM_PARTITION_IDLE, PLATFORM_DEFAULT_NV_COUNTERS, PLATFORM_DEFAULT_OTP, PLATFORM_DEFAULT_PROVISIONING, OTP_WRITEABLE, TFM_DUMMY_PROVISIONING, CONFIG_TFM_PARTITION_META, CONFIG_TFM_FLOAT_ABI=2, CONFIG_TFM_ENABLE_CP10CP11, CONFIG_TFM_LAZY_STACKING, CONFIG_TFM_HALT_ON_CORE_PANIC, CONFIG_TFM_USE_TRUSTZONE, ATTEST_TOKEN_PROFILE_PSA_IOT_1, TEST_NS_ATTESTATION, TEST_S_ATTESTATION, PS_ENCRYPTION, PS_ROLLBACK_PROTECTION, TFM_PARTITION_PROTECTED_STORAGE, SERIAL_PORT_TYPE_UART=1, TFM_PARTITION_CRYPTO, PLATFORM_DEFAULT_CRYPTO_KEYS, MBEDTLS_PSA_CRYPTO_DRIVERS, MBEDTLS_PSA_CRYPTO_BUILTIN_KEYS, PSA_CRYPTO_DRIVER_TFM_BUILTIN_KEY, PSA_CRYPTO_DRIVER_TFM_BUILTIN_KEY_LOADER, ATTEST_KEY_BITS=256, T_COSE_DISABLE_MAC0, T_COSE_DISABLE_ES384, T_COSE_DISABLE_ES512, TFM_PARTITION_INTERNAL_TRUSTED_STORAGE, TFM_PARTITION_PLATFORM, CRYPTO_HW_ACCELERATOR, TFM_PARTITION_INITIAL_ATTESTATION, T_COSE_USE_PSA_CRYPTO, QCBOR_DISABLE_FLOAT_HW_USE, USEFULBUF_DISABLE_ALL_FLOAT, QCBOR_DISABLE_PREFERRED_FLOAT, TARGET_CONFIG_HEADER_FILE='\"config_tfm_target.h\"'
  c misc: as above
  c include: as above
  asm define: NDEBUG
  asm include: ../../../../../../middleware/tfm/tf-m/platform/include
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: as above
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314 --import-cmse-lib-out="./release/tfm_psatest_s_CMSE_lib.o"
