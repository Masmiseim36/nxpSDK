# Keil uVision project tfm_regression_ns.uvprojx, settings and files
target tfm_regression_ns debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tfm_regression_ns.out
  BeforeMake: $KARM/ARMCLANG/bin/armclang --target=arm-arm-none-eabi -march=armv8-m.main -E -P -xc -I"$P../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/partition" "$P../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/armclang/tfm_common_ns.sct" -o "$P../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/armclang/tfm_common_ns_pre.sct"
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, TFM_LVL=2, ITS_MAX_ASSET_SIZE=512, PS_MAX_ASSET_SIZE=512, OS_DYNAMIC_MEM_SIZE=7168, TFM_CRYPTO_TEST_ALG_CCM, TFM_CRYPTO_TEST_HKDF, TEST_FRAMEWORK_NS, TEST_FRAMEWORK_S, TEST_NS_ITS, TEST_NS_PS, TEST_NS_PLATFORM, T_COSE_USE_PSA_CRYPTO, TEST_NS_CRYPTO, TFM_PARTITION_INTERNAL_TRUSTED_STORAGE, TEST_NS_QCBOR, TFM_PARTITION_IPC_TEST, TEST_NS_IPC, TFM_PSA_API, TEST_NS_CORE, TFM_ENABLE_PERIPH_ACCESS_TEST, TEST_NS_SLIH_IRQ, SERIAL_PORT_TYPE_UART=1, CONFIG_TFM_FLOAT_ABI=2, CONFIG_TFM_ENABLE_CP10CP11, CONFIG_TFM_LAZY_STACKING, __DOMAIN_NS=1, DOMAIN_NS=1, CONFIG_TFM_USE_TRUSTZONE, ATTEST_TOKEN_PROFILE_PSA_IOT_1, PLATFORM_DEFAULT_CRYPTO_KEYS, TEST_NS_ATTESTATION, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../../devices/MIMXRT595S;..;../../../../../../devices/MIMXRT595S/drivers;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/partition;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Include;../../../../../../middleware/tfm/tf-m-tests/test/framework;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/core/non_secure;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/ipc/non_secure;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/audit/non_secure;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/t_cose/non_secure;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/multi_core/non_secure;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/ps/non_secure;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/qcbor/non_secure;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/platform/non_secure;../../../../../../middleware/tfm/tf-m-tests;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/common_test_services/tfm_secure_client_service;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/its;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/its/non_secure;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/platform;../../../../../../middleware/tfm/tf-m/interface/include;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation;../../../../../../middleware/tfm/tf-m/secure_fw/spm/include;../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/boot;../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/inc;../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/src;../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/test;../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/src;../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/inc;../../../../../../middleware/tfm/tf-m/bl2/include;../../../../../../middleware/tfm/tf-m;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/crypto;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/crypto/non_secure;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/common/suites;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/common/service;../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/core/service/tfm_core_test;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/irq;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/common;../../../../../../devices/MIMXRT595S/utilities/str;../../../../../../devices/MIMXRT595S/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../flash_config;../../../../../../CMSIS/Core/Include;../../../../../../middleware/tfm/tf-m/platform/include;../../../../../../middleware/tfm/tf-m/platform/ext;../../../../../../middleware/tfm/tf-m/platform/ext/common;../../../../../../middleware/tfm/tf-m/platform/ext/driver;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Config;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Include;../../../../../../middleware/tfm/tf-m/interface/include/crypto_keys;../../../../../../middleware/tfm/tf-m/interface/include/psa;../../../../../../middleware/tfm/tf-m/secure_fw/include/tfm;../../../../../../middleware/tfm/tf-m-tests/app;../../../../../../middleware/tfm/tf-m-tests/log;../../../../../../middleware/tfm/tf-m-tests/ns_interface;../../../../../../middleware/tfm/tf-m-tests/ns_interface/ns_client_ext;../../../../../../CMSIS/RTOS2/RTX/Source;../../../../../../CMSIS/RTOS2/RTX/Include;../../../../../../CMSIS/RTOS2/RTX/Config;../../../../../../CMSIS/RTOS2/Include;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/attestation/ext/qcbor_util;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/attestation/non_secure;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/attestation
  asm define: DEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/armclang/tfm_common_ns_pre.sct
  link misc: ../../tfm_regression_s/mdk/debug/tfm_regression_s_CMSE_lib.o ../../../../../../CMSIS/RTOS2/RTX/Library/ARM/RTX_V8MMFN.lib --remove --entry=Reset_Handler
  group startup
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Source/armclang/: startup_MIMXRT595S_cm33_ns.S
  group device
    ../../../../../../devices/MIMXRT595S/: system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group board
    ../: pin_mux.c pin_mux.h hardware_init.c app.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MIMXRT595S/drivers/: fsl_ctimer.h fsl_ctimer.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c fsl_iap.h fsl_iap.c
  group tf-m/platform/ext/target/nxp/evkmimxrt595
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/: target_cfg.h tfm_peripherals_def.h
  group tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Include/: platform_base_address.h
  group tf-m/platform/ext/target/nxp/evkmimxrt595/partition
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/partition/: region_defs.h flash_layout.h
  group tf-m-tests/test/secure_fw
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/: non_secure_suites.c
  group tf-m-tests/test/framework
    ../../../../../../middleware/tfm/tf-m-tests/test/framework/: test_framework.c test_framework.h test_framework_error_codes.h test_framework_integ_test.h test_framework_integ_test_helper.c test_framework_integ_test_helper.h test_framework_helpers.c test_framework_helpers.h test_log.h
  group tf-m-tests/test/secure_fw/suites/core/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/core/non_secure/: core_ns_tests.h core_ns_positive_testsuite.c core_test_api.c core_test_api.h
  group tf-m-tests/test/secure_fw/suites/spm/ipc/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/ipc/non_secure/: ipc_ns_tests.h ipc_ns_interface_testsuite.c ipc_ns_tests.h
  group tf-m-tests/test/secure_fw/suites/audit/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/audit/non_secure/: audit_ns_tests.h
  group tf-m-tests/test/secure_fw/suites/t_cose/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/t_cose/non_secure/: t_cose_ns_tests.h
  group tf-m-tests/test/secure_fw/suites/multi_core/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/multi_core/non_secure/: multi_core_ns_test.h
  group tf-m-tests/test/secure_fw/suites/ps/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/ps/non_secure/: ps_ns_tests.h ns_test_helpers.c ns_test_helpers.h psa_ps_ns_interface_testsuite.c ps_ns_tests.h
  group tf-m-tests/test/secure_fw/suites/qcbor/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/qcbor/non_secure/: qcbor_ns_tests.h qcbor_ns_testsuite.c qcbor_ns_tests.h
  group tf-m-tests/test/secure_fw/suites/platform/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/platform/non_secure/: platform_ns_tests.h platform_ns_tests.h platform_ns_interface_testsuite.c
  group tf-m-tests/test/secure_fw/common_test_services/tfm_secure_client_service
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/common_test_services/tfm_secure_client_service/: tfm_secure_client_service_api.c tfm_secure_client_service_api.h
  group tf-m-tests/test/secure_fw/suites/its
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/its/: its_tests_common.c its_tests_common.h
  group tf-m-tests/test/secure_fw/suites/its/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/its/non_secure/: psa_its_ns_interface_testsuite.c its_ns_tests.h
  group tf-m-tests/test/secure_fw/suites/platform
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/platform/: platform_tests_common.c platform_tests_common.h
  group tf-m/interface/include
    ../../../../../../middleware/tfm/tf-m/interface/include/: tfm_attest_iat_defs.h tfm_attest_defs.h config_impl.h tfm_veneers.h tfm_crypto_defs.h tfm_its_defs.h tfm_ps_defs.h tfm_api.h tfm_ns_interface.h psa_config.h tfm_psa_call_pack.h tfm_ns_client_ext.h tfm_platform_api.h
  group tf-m/platform/ext/common/template
    ../../../../../../middleware/tfm/tf-m/platform/ext/common/template/: tfm_initial_attest_pub_key.c
  group tf-m/secure_fw/partitions/initial_attestation
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation/: attest.h attest_token.h attest_key.h
  group tf-m/secure_fw/spm/include/boot
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/boot/: tfm_boot_status.h
  group tf-m/lib/ext/qcbor/inc
    ../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/inc/: qcbor.h q_useful_buf.h UsefulBuf.h
  group tf-m/lib/ext/qcbor/src
    ../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/src/: ieee754.c ieee754.h qcbor_decode.c qcbor_encode.c UsefulBuf.c
  group tf-m/lib/ext/qcbor/test
    ../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/test/: half_to_double_from_rfc7049.c half_to_double_from_rfc7049.h qcbor_encode_tests.c qcbor_encode_tests.h not_well_formed_cbor.h qcbor_decode_tests.c qcbor_decode_tests.h float_tests.c float_tests.h run_tests.c run_tests.h UsefulBuf_Tests.c UsefulBuf_Tests.h
  group tf-m/lib/ext/t_cose/src
    ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/src/: t_cose_crypto.h t_cose_parameters.c t_cose_parameters.h t_cose_sign1_sign.c t_cose_standard_constants.h t_cose_util.c t_cose_util.h t_cose_sign1_verify.c
  group tf-m/lib/ext/t_cose/crypto_adapters
    ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/crypto_adapters/: t_cose_psa_crypto.c
  group tf-m/lib/ext/t_cose/inc
    ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/inc/: t_cose_common.h q_useful_buf.h t_cose_sign1_sign.h t_cose_sign1_verify.h
  group tf-m-tests/test/secure_fw/suites/crypto
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/crypto/: crypto_tests_common.c crypto_tests_common.h crypto_tests_check_config.h
  group tf-m-tests/test/secure_fw/suites/crypto/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/crypto/non_secure/: crypto_ns_interface_testsuite.c crypto_ns_tests.h
  group tf-m-tests/test/secure_fw/suites/spm/common/service
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/common/service/: client_api_test_defs.h client_api_test_defs.h
  group tf-m-tests/test/secure_fw/suites/spm/common/suites
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/common/suites/: client_api_tests.c client_api_tests.h irq_test.c irq_test.h
  group tf-m/interface/include/psa_manifest
    ../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest/: sid.h
  group tf-m/interface/src
    ../../../../../../middleware/tfm/tf-m/interface/src/: tfm_crypto_ipc_api.c tfm_initial_attestation_ipc_api.c tfm_its_ipc_api.c tfm_ps_ipc_api.c tfm_platform_ipc_api.c tfm_psa_ns_api.c
  group tf-m-tests/test/secure_fw/suites/core/service/tfm_core_test
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/core/service/tfm_core_test/: core_test_defs.h
  group tf-m-tests/test/secure_fw/suites/spm/common
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/common/: spm_test_defs.h
  group tf-m-tests/test/secure_fw/suites/spm/irq
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/irq/: irq_testsuite.c irq_testsuite.h
  group utilities
    ../../../../../../devices/MIMXRT595S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT595S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT595S/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group tf-m/platform/include
    ../../../../../../middleware/tfm/tf-m/platform/include/: tfm_plat_crypto_keys.h tfm_hal_device_header.h tfm_plat_boot_seed.h tfm_plat_device_id.h tfm_plat_defs.h tfm_plat_ns.h region.h tfm_plat_test.h
  group tf-m/platform/ext/common
    ../../../../../../middleware/tfm/tf-m/platform/ext/common/: uart_stdout.h uart_stdout.c
  group tf-m/platform/ext/driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/driver/: Driver_USART.h Driver_Common.h
  group tf-m/platform/ext/target/nxp/common/CMSIS_Driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/CMSIS_Driver/: Driver_USART.c
  group tf-m/platform/ext/target/nxp/common/Device/Include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Include/: cmsis.h device_definition.h platform_irq.h platform_regs.h
  group tf-m/platform/ext/target/nxp/common/Device/Config
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Config/: device_cfg.h
  group tf-m/interface/include/crypto_keys
    ../../../../../../middleware/tfm/tf-m/interface/include/crypto_keys/: tfm_builtin_key_ids.h
  group tf-m/interface/include/psa
    ../../../../../../middleware/tfm/tf-m/interface/include/psa/: client.h crypto.h crypto_client_struct.h crypto_extra.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h error.h framework_feature.h initial_attestation.h internal_trusted_storage.h lifecycle.h protected_storage.h service.h storage_common.h crypto_compat.h
  group tf-m/secure_fw/spm/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/: tfm_arch.h tfm_arch_v8m.h utilities.h
  group tf-m-tests/app
    ../../../../../../middleware/tfm/tf-m-tests/app/: os_wrapper_cmsis_rtos_v2.c main_ns.c test_app.c test_app.h tfm_log.h tfm_ns_interface.c
  group tf-m-tests/log
    ../../../../../../middleware/tfm/tf-m-tests/log/: tfm_log_raw.c tfm_log_raw.h
  group tf-m-tests/ns_interface/os_wrapper
    ../../../../../../middleware/tfm/tf-m-tests/ns_interface/os_wrapper/: common.h delay.h msg_queue.h mutex.h semaphore.h thread.h
  group tf-m-tests/ns_interface/ns_client_ext
    ../../../../../../middleware/tfm/tf-m-tests/ns_interface/ns_client_ext/: tfm_nsid_manager.h tz_shim_layer.c
  group CMSIS/RTOS2/RTX/Source
    ../../../../../../CMSIS/RTOS2/RTX/Source/: rtx_core_c.h rtx_core_ca.h rtx_core_cm.h rtx_lib.h rtx_lib.c
  group CMSIS/RTOS2/RTX/Include
    ../../../../../../CMSIS/RTOS2/RTX/Include/: rtx_evr.h rtx_os.h rtx_def.h
  group CMSIS/RTOS2/RTX/Config
    ../../../../../../CMSIS/RTOS2/RTX/Config/: RTX_Config.c RTX_Config.h
  group CMSIS/RTOS2/Include
    ../../../../../../CMSIS/RTOS2/Include/: os_tick.h cmsis_os2.h
  group tf-m-tests/test/secure_fw/suites/attestation/ext/qcbor_util
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/attestation/ext/qcbor_util/: qcbor_util.c qcbor_util.h
  group tf-m-tests/test/secure_fw/suites/attestation/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/attestation/non_secure/: attest_asymmetric_ns_interface_testsuite.c attest_ns_tests.h
  group tf-m-tests/test/secure_fw/suites/attestation
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/attestation/: attest_token_decode_asymmetric.c attest_token_decode.h attest_token_decode_common.c attest_token_test.c attest_token_test.h attest_token_test_values.h attest_tests_common.h
  group tf-m/platform/ext/target/nxp/common
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/: plat_test.c
target tfm_regression_ns release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tfm_regression_ns.out
  BeforeMake: as above
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, TFM_LVL=2, ITS_MAX_ASSET_SIZE=512, PS_MAX_ASSET_SIZE=512, OS_DYNAMIC_MEM_SIZE=7168, TFM_CRYPTO_TEST_ALG_CCM, TFM_CRYPTO_TEST_HKDF, TEST_FRAMEWORK_NS, TEST_FRAMEWORK_S, TEST_NS_ITS, TEST_NS_PS, TEST_NS_PLATFORM, T_COSE_USE_PSA_CRYPTO, TEST_NS_CRYPTO, TFM_PARTITION_INTERNAL_TRUSTED_STORAGE, TEST_NS_QCBOR, TFM_PARTITION_IPC_TEST, TEST_NS_IPC, TFM_PSA_API, TEST_NS_CORE, TFM_ENABLE_PERIPH_ACCESS_TEST, TEST_NS_SLIH_IRQ, SERIAL_PORT_TYPE_UART=1, CONFIG_TFM_FLOAT_ABI=2, CONFIG_TFM_ENABLE_CP10CP11, CONFIG_TFM_LAZY_STACKING, __DOMAIN_NS=1, DOMAIN_NS=1, CONFIG_TFM_USE_TRUSTZONE, ATTEST_TOKEN_PROFILE_PSA_IOT_1, PLATFORM_DEFAULT_CRYPTO_KEYS, TEST_NS_ATTESTATION, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: as above
  link misc: ../../tfm_regression_s/mdk/release/tfm_regression_s_CMSE_lib.o ../../../../../../CMSIS/RTOS2/RTX/Library/ARM/RTX_V8MMFN.lib --remove --entry=Reset_Handler
