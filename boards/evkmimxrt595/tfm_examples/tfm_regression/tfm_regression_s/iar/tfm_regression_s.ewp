# IAR project tfm_regression_s.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT595S_M33 NXP MIMXRT595S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; TFM_LVL=2; TFM_SPM_LOG_LEVEL=TFM_SPM_LOG_LEVEL_INFO; TFM_PARTITION_LOG_LEVEL=TFM_PARTITION_LOG_LEVEL_INFO; TFM_CRYPTO_IOVEC_BUFFER_SIZE=5120; TFM_CRYPTO_ENGINE_BUF_SIZE=9400; ITS_MAX_ASSET_SIZE=512; ITS_NUM_ASSETS=5; PS_MAX_ASSET_SIZE=512; PS_NUM_ASSETS=5; PS_RAM_FS; PS_CREATE_FLASH_LAYOUT; PS_WIPE_ALL; ITS_RAM_FS; ITS_CREATE_FLASH_LAYOUT; ITS_WIPE_ALL; DAUTH_CHIP_DEFAULT; MBEDTLS_CONFIG_FILE="evkmimxrt595_mbedcrypto_config.h"; INCLUDE_TEST_CODE_AND_KEY_ID; __SEMIHOST_HARDFAULT_DISABLE; TFM_CRYPTO_TEST_ALG_CBC; TFM_CRYPTO_TEST_ALG_CCM; TFM_CRYPTO_TEST_ALG_CFB; TFM_CRYPTO_TEST_ALG_CTR; TFM_CRYPTO_TEST_ALG_GCM; TFM_CRYPTO_TEST_ALG_SHA_512; TFM_CRYPTO_TEST_HKDF; TFM_PARTITION_INTERNAL_TRUSTED_STORAGE; TFM_PARTITION_CRYPTO; TFM_PARTITION_INITIAL_ATTESTATION; T_COSE_USE_PSA_CRYPTO; TFM_PARTITION_PLATFORM; TEST_FRAMEWORK_S; SERVICES_TEST_S; TFM_PARTITION_TEST_SECURE_SERVICES; ENABLE_INTERNAL_TRUSTED_STORAGE_SERVICE_TESTS; ENABLE_ATTESTATION_SERVICE_TESTS; ENABLE_CRYPTO_SERVICE_TESTS; ENABLE_PLATFORM_SERVICE_TESTS; TFM_PSA_API; CONFIG_TFM_ENABLE_MEMORY_PROTECT; TFM_PARTITION_TEST_CORE_IPC; ENABLE_IPC_TEST; TFM_PARTITION_TEST_CORE; CORE_TEST_POSITIVE; TFM_ENABLE_PERIPH_ACCESS_TEST; TFM_ENABLE_IRQ_TEST; TFM_PARTITION_PROTECTED_STORAGE; PS_ENCRYPTION; PS_ROLLBACK_PROTECTION; TFM_PARTITION_TEST_PS; ENABLE_PROTECTED_STORAGE_SERVICE_TESTS; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pa084,Pe128,Pe186,Pe546,Pe940,Pe188,Pe186,Pe177
  ICCARM.IExtraOptions: --cmse  --diag_suppress Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../devices/MIMXRT595S; ..; ../../../../../../devices/MIMXRT595S/drivers; ../../../../../../middleware/tfm/mbed-crypto/include/mbedtls; ../../../../../../middleware/tfm/mbed-crypto/include/mbed_psa; ../../../../../../middleware/tfm/mbed-crypto/library; ../../../../../../middleware/tfm/mbed-crypto/port; ../../../../../../middleware/tfm/mbed-crypto/include; ../../../../../../middleware/tfm/tf-m; ../../../../../../middleware/tfm/tf-m/bl2/include; ../../../../../../middleware/tfm/tf-m/bl2/ext/mcuboot/bootutil/include/bootutil; ../../../../../../middleware/tfm/tf-m/platform/ext; ../../../../../../middleware/tfm/tf-m/platform/ext/common; ../../../../../../middleware/tfm/tf-m/platform/ext/driver; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Native_Driver; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Config; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Include; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/partition; ../../../../../../middleware/tfm/tf-m/platform/include; ../../../../../../middleware/tfm/tf-m/interface/include/log; ../../../../../../middleware/tfm/tf-m/interface/include/psa; ../../../../../../middleware/tfm/tf-m/interface/include; ../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest; ../../../../../../middleware/tfm/tf-m/secure_fw/include; ../../../../../../middleware/tfm/tf-m/secure_fw/include/tfm; ../../../../../../middleware/tfm/tf-m/secure_fw/spm; ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include; ../../../../../../middleware/tfm/tf-m/secure_fw/spm/cmsis_func/include; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/psa_manifest; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/audit_logging/psa_manifest; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/psa_manifest; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform/psa_manifest; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation/psa_manifest; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/psa_manifest; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/lib/sprt/include; ../../../../../../middleware/tfm/tf-m/lib/fih/inc; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/flash; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/flash_fs; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation; ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/src; ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/inc; ../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/src; ../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/inc; ../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/util; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform; ../../../../../../middleware/tfm/tf-m-tests; ../../../../../../middleware/tfm/tf-m-tests/test; ../../../../../../middleware/tfm/tf-m-tests/test/suites/audit/secure; ../../../../../../middleware/tfm/tf-m-tests/test/framework; ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_secure_client_service; ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_secure_client_2; ../../../../../../middleware/tfm/tf-m-tests/test/suites/ipc/secure; ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_secure_client_service/psa_manifest; ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_secure_client_2/psa_manifest; ../../../../../../middleware/tfm/tf-m-tests/test/suites/its; ../../../../../../middleware/tfm/tf-m-tests/test/suites/its/secure; ../../../../../../middleware/tfm/tf-m-tests/test/suites/attestation/secure; ../../../../../../middleware/tfm/tf-m-tests/test/suites/attestation; ../../../../../../middleware/tfm/tf-m-tests/test/suites/crypto; ../../../../../../middleware/tfm/tf-m-tests/test/suites/crypto/secure; ../../../../../../middleware/tfm/tf-m-tests/test/suites/platform; ../../../../../../middleware/tfm/tf-m-tests/test/suites/platform/secure; ../../../../../../middleware/tfm/tf-m/interface/include/ext; ../../../../../../middleware/tfm/tf-m/secure_fw/spm/cmsis_psa; ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_ipc_service/psa_manifest; ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_ipc_client/psa_manifest; ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_ipc_client; ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_ipc_service; ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_core_test; ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_core_test_2; ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_core_test/psa_manifest; ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_core_test_2/psa_manifest; ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_irq_test_service_1/psa_manifest; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/crypto; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/nv_counters; ../../../../../../middleware/tfm/tf-m-tests/test/suites/ps/secure; ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_ps_test_service; ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_ps_test_service/psa_manifest; ../../../../../../devices/MIMXRT595S/utilities/str; ../../../../../../devices/MIMXRT595S/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../flash_config; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../../../middleware/tfm/tf-m/platform/include
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  prebuild: "$TOOLKIT_DIR$/bin/iccarm.exe" -DTFM_LVL=2 -DTFM_PSA_API -DTFM_PARTITION_TEST_CORE_IPC -DTFM_PARTITION_TEST_SECURE_SERVICES -DTFM_PARTITION_PLATFORM -DTFM_PARTITION_PROTECTED_STORAGE -DTFM_PARTITION_INTERNAL_TRUSTED_STORAGE -DTFM_PARTITION_CRYPTO -DTFM_PARTITION_INITIAL_ATTESTATION -DTFM_PARTITION_TEST_CORE -DTFM_ENABLE_IRQ_TEST -DTFM_PARTITION_TEST_PS -I../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/partition ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/iar/tfm_common_s.icf --silent --preprocess=ns ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/iar/tfm_common_s_pre.icf
  ILINK.IlinkOutputFile: tfm_regression_s.out
  ILINK.IlinkIcfFile: ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/iar/tfm_common_s_pre.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; TFM_LVL=2; TFM_SPM_LOG_LEVEL=TFM_SPM_LOG_LEVEL_INFO; TFM_PARTITION_LOG_LEVEL=TFM_PARTITION_LOG_LEVEL_INFO; TFM_CRYPTO_IOVEC_BUFFER_SIZE=5120; TFM_CRYPTO_ENGINE_BUF_SIZE=9400; ITS_MAX_ASSET_SIZE=512; ITS_NUM_ASSETS=5; PS_MAX_ASSET_SIZE=512; PS_NUM_ASSETS=5; PS_RAM_FS; PS_CREATE_FLASH_LAYOUT; PS_WIPE_ALL; ITS_RAM_FS; ITS_CREATE_FLASH_LAYOUT; ITS_WIPE_ALL; DAUTH_CHIP_DEFAULT; MBEDTLS_CONFIG_FILE="evkmimxrt595_mbedcrypto_config.h"; INCLUDE_TEST_CODE_AND_KEY_ID; __SEMIHOST_HARDFAULT_DISABLE; TFM_CRYPTO_TEST_ALG_CBC; TFM_CRYPTO_TEST_ALG_CCM; TFM_CRYPTO_TEST_ALG_CFB; TFM_CRYPTO_TEST_ALG_CTR; TFM_CRYPTO_TEST_ALG_GCM; TFM_CRYPTO_TEST_ALG_SHA_512; TFM_CRYPTO_TEST_HKDF; TFM_PARTITION_INTERNAL_TRUSTED_STORAGE; TFM_PARTITION_CRYPTO; TFM_PARTITION_INITIAL_ATTESTATION; T_COSE_USE_PSA_CRYPTO; TFM_PARTITION_PLATFORM; TEST_FRAMEWORK_S; SERVICES_TEST_S; TFM_PARTITION_TEST_SECURE_SERVICES; ENABLE_INTERNAL_TRUSTED_STORAGE_SERVICE_TESTS; ENABLE_ATTESTATION_SERVICE_TESTS; ENABLE_CRYPTO_SERVICE_TESTS; ENABLE_PLATFORM_SERVICE_TESTS; TFM_PSA_API; CONFIG_TFM_ENABLE_MEMORY_PROTECT; TFM_PARTITION_TEST_CORE_IPC; ENABLE_IPC_TEST; TFM_PARTITION_TEST_CORE; CORE_TEST_POSITIVE; TFM_ENABLE_PERIPH_ACCESS_TEST; TFM_ENABLE_IRQ_TEST; TFM_PARTITION_PROTECTED_STORAGE; PS_ENCRYPTION; PS_ROLLBACK_PROTECTION; TFM_PARTITION_TEST_PS; ENABLE_PROTECTED_STORAGE_SERVICE_TESTS; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group startup
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Source/iar/: startup_MIMXRT595S_cm33_s.s
  group device
    ../../../../../../devices/MIMXRT595S/: system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group board
    ../: pin_mux.c pin_mux.h hardware_init.c app.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MIMXRT595S/drivers/: fsl_casper.h fsl_casper.c fsl_hashcrypt.h fsl_hashcrypt.c fsl_trng.c fsl_trng.h fsl_ctimer.h fsl_ctimer.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c fsl_iap.h fsl_iap.c
  group tf-m/platform/ext/target/nxp/common
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/: plat_attest_hal.c mini_mbedcrypto_config.h maxi_mbedcrypto_config.h spm_hal.c tfm_hal_isolation.c plat_attestation_key.c plat_huk_key.c plat_test.c
  group tf-m/platform/ext/target/nxp/common/CMSIS_Driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/CMSIS_Driver/: Driver_Flash_iap.c Driver_USART.c
  group tf-m/platform/ext/target/nxp/common/Native_Driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Native_Driver/: mpu_armv8m_drv.c mpu_armv8m_drv.h
  group tf-m/platform/ext/target/nxp/common/services/src
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/services/src/: tfm_platform_system.c
  group tf-m/platform/ext/target/nxp/evkmimxrt595
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/: target_cfg.c target_cfg.h tfm_peripherals_def.h evkmimxrt595_mbedcrypto_config.h
  group tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Config
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Config/: device_cfg.h
  group tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Include/: cmsis.h device_definition.h platform_description.h platform_irq.h platform_regs.h platform_base_address.h
  group tf-m/platform/ext/target/nxp/evkmimxrt595/partition
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/partition/: flash_layout.h region_defs.h
  group tf-m/platform/ext/common
    ../../../../../../middleware/tfm/tf-m/platform/ext/common/: tfm_hal_isolation_mpu_v8m.c tfm_hal_its.c tfm_hal_memory_symbols.c tfm_hal_ps.c tfm_hal_sp_logdev.h tfm_hal_sp_logdev_periph.c tfm_hal_spm_logdev.h tfm_hal_spm_logdev_peripheral.c tfm_platform.c uart_stdout.c uart_stdout.h
  group tf-m/platform/ext/common/template
    ../../../../../../middleware/tfm/tf-m/platform/ext/common/template/: nv_counters.c
  group tf-m/platform/ext/driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/driver/: Driver_Common.h Driver_Flash.h Driver_MPC.h Driver_PPC.h Driver_USART.h
  group tf-m/platform/include
    ../../../../../../middleware/tfm/tf-m/platform/include/: region.h tfm_attest_hal.h tfm_hal_defs.h tfm_hal_device_header.h tfm_hal_isolation.h tfm_hal_its.h tfm_hal_memory_symbols.h tfm_hal_platform.h tfm_hal_ps.h tfm_plat_boot_seed.h tfm_plat_config.h tfm_plat_crypto_keys.h tfm_plat_defs.h tfm_plat_device_id.h tfm_plat_ns.h tfm_plat_nv_counters.h tfm_plat_test.h tfm_platform_system.h tfm_spm_hal.h
  group tf-m/lib/fih/inc
    ../../../../../../middleware/tfm/tf-m/lib/fih/inc/: fih.h
  group tf-m/lib/fih/src
    ../../../../../../middleware/tfm/tf-m/lib/fih/src/: fih.c
  group tf-m/lib/ext/t_cose/crypto_adapters
    ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/crypto_adapters/: t_cose_psa_crypto.c
  group tf-m/lib/ext/t_cose/src
    ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/src/: t_cose_crypto.h t_cose_parameters.c t_cose_parameters.h t_cose_sign1_sign.c t_cose_standard_constants.h t_cose_util.c t_cose_util.h t_cose_sign1_verify.c
  group tf-m/lib/ext/t_cose/inc
    ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/inc/: t_cose_common.h q_useful_buf.h t_cose_sign1_sign.h t_cose_sign1_verify.h
  group tf-m/lib/ext/qcbor/src
    ../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/src/: ieee754.c ieee754.h qcbor_decode.c qcbor_encode.c UsefulBuf.c
  group tf-m/lib/ext/qcbor/inc
    ../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/inc/: qcbor.h q_useful_buf.h UsefulBuf.h
  group tf-m/lib/ext/qcbor/util
    ../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/util/: qcbor_util.c qcbor_util.h
  group tf-m/interface/include
    ../../../../../../middleware/tfm/tf-m/interface/include/: psa_audit_defs.h tfm_api.h tfm_crypto_defs.h tfm_platform_api.h tfm_veneers.h tfm_its_defs.h tfm_ps_defs.h
  group tf-m/interface/include/log
    ../../../../../../middleware/tfm/tf-m/interface/include/log/: tfm_log.h tfm_log_raw.h
  group tf-m/interface/include/psa
    ../../../../../../middleware/tfm/tf-m/interface/include/psa/: client.h crypto.h crypto_client_struct.h crypto_compat.h crypto_extra.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h error.h initial_attestation.h internal_trusted_storage.h lifecycle.h protected_storage.h service.h storage_common.h
  group tf-m/interface/include/psa_manifest
    ../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest/: pid.h sid.h
  group tf-m/interface/include/ext
    ../../../../../../middleware/tfm/tf-m/interface/include/ext/: tz_context.h
  group tf-m/interface/src/log
    ../../../../../../middleware/tfm/tf-m/interface/src/log/: tfm_log_raw.c
  group tf-m/interface/src/psa
    ../../../../../../middleware/tfm/tf-m/interface/src/psa/: psa_client.c psa_service.c psa_lifecycle.c
  group tf-m/secure_fw/spm/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/: bitops.h exception_info.h lists.h spm_partition_defs.h tfm_assert.h tfm_boot_status.h tfm_core_mem_check.h tfm_core_trustzone.h tfm_core_utils.h tfm_irq_list.h tfm_nspm.h tfm_platform_core_api.h tfm_secure_api.h tfm_spm_log.h tfm_version.h utilities.h tfm_arch.h tfm_arch_v8m.h tfm_memory_utils.h
  group tf-m/secure_fw/spm/include/ffm
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/ffm/: spm_error_base.h
  group tf-m/secure_fw/spm/ffm
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/ffm/: psa_client_service_apis.c psa_client_service_apis.h spm_log.c spm_psa_client_call.c spm_psa_client_call.h tfm_boot_data.c tfm_boot_data.h tfm_core_mem_check.c tfm_core_utils.c utilities.c
  group tf-m/secure_fw/spm/cmsis_psa
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/cmsis_psa/: tfm_wait.h exception_info.c internal_errors.h main.c tfm_pools.h tfm_rpc.h tfm_svcalls.h tfm_thread.h tfm_wait.h spm_ipc.c spm_ipc.h tfm_core_svcalls_ipc.c tfm_nspm_ipc.c tfm_pools.c tfm_psa_api_veneers.c tfm_secure_irq_handlers_ipc.inc tfm_spm_db_ipc.inc tfm_thread.c tfm_wait.c
  group tf-m/secure_fw/spm/cmsis_psa/arch
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/cmsis_psa/arch/: tfm_arch.c tfm_arch_v8m_main.c
  group tf-m/secure_fw/spm/cmsis_func/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/cmsis_func/include/: spm_func.h
  group tf-m/secure_fw/include/tfm
    ../../../../../../middleware/tfm/tf-m/secure_fw/include/tfm/: tfm_core_svc.h tfm_spm_services.h
  group tf-m/secure_fw/partitions
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/: tfm_service_list.inc
  group tf-m/secure_fw/partitions/lib/sprt
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/lib/sprt/: service_api.c sprt_partition_metadata_indicator.c tfm_sp_log_raw.c
  group tf-m/secure_fw/partitions/lib/sprt/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/lib/sprt/include/: service_api.h tfm_sp_log.h
  group tf-m/secure_fw/partitions/internal_trusted_storage
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/: its_utils.c its_utils.h tfm_internal_trusted_storage.c tfm_internal_trusted_storage.h tfm_its_req_mngr.h tfm_its_req_mngr.c tfm_its_secure_api.c
  group tf-m/secure_fw/partitions/internal_trusted_storage/auto_generated
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/auto_generated/: intermedia_tfm_internal_trusted_storage.c
  group tf-m/secure_fw/partitions/internal_trusted_storage/psa_manifest
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/psa_manifest/: tfm_internal_trusted_storage.h
  group tf-m/secure_fw/partitions/internal_trusted_storage/flash
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/flash/: its_flash.c its_flash.h its_flash_nand.c its_flash_nand.h its_flash_nor.c its_flash_nor.h its_flash_ram.c its_flash_ram.h
  group tf-m/secure_fw/partitions/internal_trusted_storage/flash_fs
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/flash_fs/: its_flash_fs.c its_flash_fs.h its_flash_fs_dblock.c its_flash_fs_dblock.h its_flash_fs_mblock.c its_flash_fs_mblock.h
  group tf-m/secure_fw/partitions/protected_storage
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/: ps_object_defs.h ps_encrypted_object.c ps_encrypted_object.h ps_object_defs.h ps_object_system.c ps_object_system.h ps_object_table.c ps_object_table.h ps_utils.c ps_utils.h tfm_protected_storage.c tfm_protected_storage.h tfm_ps_req_mngr.h tfm_ps_req_mngr.c tfm_ps_secure_api.c
  group tf-m/secure_fw/partitions/protected_storage/auto_generated
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/auto_generated/: intermedia_tfm_protected_storage.c
  group tf-m/secure_fw/partitions/protected_storage/crypto
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/crypto/: ps_crypto_interface.c ps_crypto_interface.h
  group tf-m/secure_fw/partitions/protected_storage/psa_manifest
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/psa_manifest/: tfm_protected_storage.h
  group tf-m/secure_fw/partitions/protected_storage/nv_counters
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/nv_counters/: ps_nv_counters.h ps_nv_counters.c
  group tf-m/secure_fw/partitions/crypto
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/: crypto_aead.c crypto_alloc.c crypto_asymmetric.c crypto_cipher.c crypto_hash.c crypto_init.c crypto_key.c crypto_key_derivation.c crypto_mac.c crypto_spe.h tfm_crypto_api.h tfm_crypto_private.h tfm_crypto_secure_api.c tfm_mbedcrypto_include.h
  group tf-m/secure_fw/partitions/crypto/auto_generated
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/auto_generated/: intermedia_tfm_crypto.c
  group tf-m/secure_fw/partitions/crypto/psa_manifest
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/psa_manifest/: tfm_crypto.h
  group tf-m/secure_fw/partitions/initial_attestation
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation/: attest.h attest_asymmetric_key.c attest_core.c attest_eat_defines.h attest_key.h attest_token.h attest_token_encode.c tfm_attest.c tfm_attest_req_mngr.c tfm_attest_secure_api.c
  group tf-m/secure_fw/partitions/initial_attestation/auto_generated
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation/auto_generated/: intermedia_tfm_initial_attestation.c
  group tf-m/secure_fw/partitions/initial_attestation/psa_manifest
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation/psa_manifest/: tfm_initial_attestation.h
  group tf-m/secure_fw/partitions/platform
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform/: platform_sp.c platform_sp.h tfm_platform_secure_api.c
  group tf-m/secure_fw/partitions/platform/auto_generated
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform/auto_generated/: intermedia_tfm_platform.c
  group tf-m/secure_fw/partitions/platform/psa_manifest
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform/psa_manifest/: tfm_platform.h
  group mbed-crypto/include/mbedtls
    ../../../../../../middleware/tfm/mbed-crypto/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h config_psa.h ctr_drbg.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h psa_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h threading.h timing.h version.h xtea.h
  group mbed-crypto/include/mbed_psa
    ../../../../../../middleware/tfm/mbed-crypto/include/mbed_psa/: crypto.h crypto_accel_driver.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_entropy_driver.h crypto_extra.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group mbed-crypto/library
    ../../../../../../middleware/tfm/mbed-crypto/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cmac.c common.h ctr_drbg.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_se.c psa_crypto_se.h psa_crypto_service_integration.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c threading.c timing.c version.c version_features.c xtea.c
  group mbed-crypto/port
    ../../../../../../middleware/tfm/mbed-crypto/port/: aes_alt.h mbedcrypto_mcux_casper.c mbedcrypto_mcux_hashcrypt.c mbedcrypto_mcux_config.h mbedcrypto_mcux_entropy.c mbedcrypto_mcux_hw_config.h sha1_alt.h sha256_alt.h
  group tf-m-tests/test/suites/audit/secure
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/audit/secure/: audit_s_tests.h
  group tf-m-tests/test/suites/ipc/secure
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/ipc/secure/: ipc_s_tests.h ipc_s_tests.h ipc_s_interface_testsuite.c
  group tf-m-tests/test/suites/its
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/its/: its_tests_common.c its_tests_common.h
  group tf-m-tests/test/suites/its/secure
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/its/secure/: its_s_tests.h psa_its_s_interface_testsuite.c psa_its_s_reliability_testsuite.c
  group tf-m-tests/test/suites/attestation
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/attestation/: attest_public_key.c attest_public_key.h attest_token_decode_asymmetric.c attest_token_decode.h attest_token_decode_common.c attest_token_test.c attest_token_test.h attest_token_test_values.h attest_tests_common.h
  group tf-m-tests/test/suites/attestation/secure
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/attestation/secure/: attest_asymmetric_s_interface_testsuite.c attest_s_tests.h
  group tf-m-tests/test/suites/crypto
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/crypto/: crypto_tests_common.c crypto_tests_common.h
  group tf-m-tests/test/suites/crypto/secure
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/crypto/secure/: crypto_s_tests.h crypto_sec_interface_testsuite.c
  group tf-m-tests/test/suites/platform
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/platform/: platform_tests_common.c platform_tests_common.h
  group tf-m-tests/test/suites/platform/secure
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/platform/secure/: platform_s_tests.h platform_s_interface_testsuite.c
  group tf-m-tests/test/suites/ps/secure
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/ps/secure/: psa_ps_s_interface_testsuite.c psa_ps_s_reliability_testsuite.c s_test_helpers.h ps_tests.h
  group tf-m-tests/test/framework
    ../../../../../../middleware/tfm/tf-m-tests/test/framework/: secure_suites.c test_framework.c test_framework.h test_framework_error_codes.h test_framework_helpers.c test_framework_helpers.h test_framework_integ_test.h test_framework_integ_test_helper.c test_framework_integ_test_helper.h
  group tf-m-tests/test/test_services/tfm_secure_client_service
    ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_secure_client_service/: tfm_secure_client_service.c tfm_secure_client_service.h
  group tf-m-tests/test/test_services/tfm_secure_client_service/auto_generated
    ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_secure_client_service/auto_generated/: intermedia_tfm_secure_client_service.c
  group tf-m-tests/test/test_services/tfm_secure_client_service/psa_manifest
    ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_secure_client_service/psa_manifest/: tfm_secure_client_service.h
  group tf-m-tests/test/test_services/tfm_secure_client_2
    ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_secure_client_2/: tfm_secure_client_2.c tfm_secure_client_2_api.c tfm_secure_client_2_api.h
  group tf-m-tests/test/test_services/tfm_secure_client_2/auto_generated
    ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_secure_client_2/auto_generated/: intermedia_tfm_secure_client_2.c
  group tf-m-tests/test/test_services/tfm_secure_client_2/psa_manifest
    ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_secure_client_2/psa_manifest/: tfm_secure_client_2.h
  group tf-m-tests/test/test_services/tfm_ipc_service
    ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_ipc_service/: tfm_ipc_service_test.c
  group tf-m-tests/test/test_services/tfm_ipc_service/auto_generated
    ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_ipc_service/auto_generated/: intermedia_tfm_ipc_service_test.c
  group tf-m-tests/test/test_services/tfm_ipc_service/psa_manifest
    ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_ipc_service/psa_manifest/: tfm_ipc_service_test.h
  group tf-m-tests/test/test_services/tfm_ipc_client
    ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_ipc_client/: tfm_ipc_client_test.c
  group tf-m-tests/test/test_services/tfm_ipc_client/auto_generated
    ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_ipc_client/auto_generated/: intermedia_tfm_ipc_client_test.c
  group tf-m-tests/test/test_services/tfm_ipc_client/psa_manifest
    ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_ipc_client/psa_manifest/: tfm_ipc_client_test.h
  group tf-m-tests/test/test_services/tfm_core_test
    ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_core_test/: core_test_defs.h tfm_ss_core_test.c tfm_ss_core_test.h
  group tf-m-tests/test/test_services/tfm_core_test/auto_generated
    ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_core_test/auto_generated/: intermedia_tfm_ss_core_test.c
  group tf-m-tests/test/test_services/tfm_core_test/psa_manifest
    ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_core_test/psa_manifest/: tfm_ss_core_test.h
  group tf-m-tests/test/test_services/tfm_core_test_2
    ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_core_test_2/: tfm_ss_core_test_2.c tfm_ss_core_test_2.h
  group tf-m-tests/test/test_services/tfm_core_test_2/auto_generated
    ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_core_test_2/auto_generated/: intermedia_tfm_ss_core_test_2.c
  group tf-m-tests/test/test_services/tfm_core_test_2/psa_manifest
    ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_core_test_2/psa_manifest/: tfm_ss_core_test_2.h
  group tf-m-tests/test/test_services/tfm_irq_test_service_1
    ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_irq_test_service_1/: tfm_irq_test_service_1.c
  group tf-m-tests/test/test_services/tfm_irq_test_service_1/auto_generated
    ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_irq_test_service_1/auto_generated/: intermedia_tfm_irq_test_service_1.c
  group tf-m-tests/test/test_services/tfm_irq_test_service_1/psa_manifest
    ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_irq_test_service_1/psa_manifest/: tfm_irq_test_service_1.h
  group tf-m-tests/test/test_services/tfm_ps_test_service
    ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_ps_test_service/: tfm_ps_test_service.c tfm_ps_test_service_api.c tfm_ps_test_service_api.h
  group tf-m-tests/test/test_services/tfm_ps_test_service/auto_generated
    ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_ps_test_service/auto_generated/: intermedia_tfm_ps_test_service.c
  group tf-m-tests/test/test_services/tfm_ps_test_service/psa_manifest
    ../../../../../../middleware/tfm/tf-m-tests/test/test_services/tfm_ps_test_service/psa_manifest/: tfm_ps_test_service.h
  group utilities
    ../../../../../../devices/MIMXRT595S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT595S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT595S/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
