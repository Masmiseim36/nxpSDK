# Keil uVision project tfm_regression_s.uvprojx, settings and files
target tfm_regression_s debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tfm_regression_s.out
  BeforeMake: $KARM/ARMCLANG/bin/armclang -DTFM_LVL=2 -DTFM_PSA_API -DTFM_PARTITION_TEST_SECURE_SERVICES -DCONFIG_TFM_PARTITION_META -DENABLE_HEAP -D__ARM_ARCH_8M_MAIN__ -DCONFIG_TFM_USE_TRUSTZONE --target=arm-arm-none-eabi -march=armv8-m.main -E -P -xc -I"$P../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/partition" "$P../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/armclang/tfm_common_s.sct" -o "$P../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/armclang/tfm_common_s_pre.sct"
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, TFM_LVL=2, TFM_SPM_LOG_LEVEL=TFM_SPM_LOG_LEVEL_INFO, TFM_SP_LOG_RAW_ENABLED, TFM_PARTITION_LOG_LEVEL=TFM_PARTITION_LOG_LEVEL_INFO, TFM_CRYPTO_IOVEC_BUFFER_SIZE=5120, TFM_CRYPTO_ENGINE_BUF_SIZE=9600, ITS_MAX_ASSET_SIZE=512, ITS_NUM_ASSETS=5, PS_MAX_ASSET_SIZE=512, PS_NUM_ASSETS=5, PS_RAM_FS, PS_CREATE_FLASH_LAYOUT, PS_WIPE_ALL, ITS_RAM_FS, ITS_CREATE_FLASH_LAYOUT, OTP_NV_COUNTERS_RAM_EMULATION, ITS_WIPE_ALL, CONFIG_TFM_CONN_HANDLE_MAX_NUM=8, DAUTH_CHIP_DEFAULT, __SEMIHOST_HARDFAULT_DISABLE, TFM_CRYPTO_TEST_ALG_CCM, TFM_CRYPTO_TEST_HKDF, CRYPTO_HW_ACCELERATOR, TFM_PARTITION_INTERNAL_TRUSTED_STORAGE, TFM_PARTITION_CRYPTO, PLATFORM_DEFAULT_CRYPTO_KEYS, MBEDTLS_PSA_CRYPTO_DRIVERS, MBEDTLS_PSA_CRYPTO_BUILTIN_KEYS, PSA_CRYPTO_DRIVER_TFM_BUILTIN_KEY, PSA_CRYPTO_DRIVER_TFM_BUILTIN_KEY_LOADER, TFM_PARTITION_INITIAL_ATTESTATION, T_COSE_USE_PSA_CRYPTO, TFM_PARTITION_PLATFORM, TEST_FRAMEWORK_S, USE_SP_LOG, TEST_S_ITS, TEST_S_ATTESTATION, TEST_S_CRYPTO, TEST_S_PLATFORM, TFM_PSA_API=1, CONFIG_TFM_ENABLE_MEMORY_PROTECT, TFM_PARTITION_NS_AGENT_TZ, TFM_PARTITION_IPC_TEST, TEST_S_IPC, TEST_NS_CORE, TFM_ENABLE_PERIPH_ACCESS_TEST, TFM_PARTITION_PROTECTED_STORAGE, PS_ENCRYPTION, PS_ROLLBACK_PROTECTION, TFM_PARTITION_TEST_PS, TEST_S_PS, MBEDTLS_CONFIG_FILE='\"tfm_mbedcrypto_config_profile_medium.h\"', MBEDTLS_PSA_CRYPTO_CONFIG_FILE='\"crypto_config_profile_medium.h\"', TFM_CRYPTO_ASYM_ENCRYPT_MODULE_DISABLED, PS_CRYPTO_AEAD_ALG=PSA_ALG_CCM, TEST_NS_SLIH_IRQ, SERIAL_PORT_TYPE_UART=1, CONFIG_TFM_BUILDING_SPE=1, PLATFORM_DEFAULT_NV_COUNTERS, PLATFORM_DEFAULT_OTP, PLATFORM_DEFAULT_PROVISIONING, OTP_WRITEABLE, TFM_DUMMY_PROVISIONING, CONFIG_TFM_PSA_API_SUPERVISOR_CALL, CONFIG_TFM_PARTITION_META, CONFIG_TFM_FLOAT_ABI=2, CONFIG_TFM_ENABLE_CP10CP11, CONFIG_TFM_LAZY_STACKING, CONFIG_TFM_HALT_ON_CORE_PANIC, CONFIG_TFM_USE_TRUSTZONE, ATTEST_TOKEN_PROFILE_PSA_IOT_1, ATTEST_KEY_BITS=256, TFM_PARTITION_TEST_SECURE_SERVICES, MCUXPRESSO_SDK
  c misc: -Wno-gnu-variable-sized-type-not-at-end  -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../../devices/MIMXRT595S;..;../../../../../../devices/MIMXRT595S/drivers;../../../../../../middleware/tfm/mbed-crypto/include/mbedtls;../../../../../../middleware/tfm/mbed-crypto/include/mbed_psa;../../../../../../middleware/tfm/mbed-crypto/library;../../../../../../middleware/tfm/mbed-crypto/port;../../../../../../middleware/tfm/mbed-crypto/include;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Include;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/partition;../../../../../../middleware/tfm/tf-m/interface/include;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/flash;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/flash_fs;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/psa_driver_api;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation;../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/src;../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/inc;../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/src;../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/inc;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform;../../../../../../middleware/tfm/tf-m-tests;../../../../../../middleware/tfm/tf-m-tests/test;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/audit/secure;../../../../../../middleware/tfm/tf-m-tests/test/framework;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/common_test_services/tfm_secure_client_service;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/common_test_services/tfm_secure_client_2;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/ipc/secure;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_secure_client_service/psa_manifest;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_secure_client_service;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_secure_client_2/psa_manifest;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_secure_client_2;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/its;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/its/secure;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/attestation/ext/qcbor_util;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/attestation/secure;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/attestation;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/crypto;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/crypto/secure;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/platform;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/platform/secure;../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest;../../../../../../middleware/tfm/tf-m/secure_fw/spm/cmsis_psa;../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/ffm;../../../../../../middleware/tfm/tf-m/secure_fw/spm/include;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_ipc_service/psa_manifest;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_ipc_service;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/common;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/common/suites;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/common/service;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/ipc/service/tfm_ipc_service;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_ipc_client/psa_manifest;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_ipc_client;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/ipc/service/tfm_ipc_client;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/core/service/tfm_core_test;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/core/service/tfm_core_test_2;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_core_test/psa_manifest;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_core_test;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_core_test_2/psa_manifest;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_core_test_2;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/crypto;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/nv_counters;../../../../../../middleware/tfm/tf-m;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/ps/secure;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/ps/service;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_ps_test_service/psa_manifest;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_ps_test_service;../../../../../../middleware/tfm/tf-m/lib/ext/mbedcrypto/mbedcrypto_config;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/irq/service/tfm_slih_test_service;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_slih_test_service;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_slih_test_service/psa_manifest;../../../../../../devices/MIMXRT595S/utilities/str;../../../../../../devices/MIMXRT595S/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../flash_config;../../../../../../CMSIS/Core/Include;../../../../../../middleware/tfm/tf-m/bl2/include;../../../../../../middleware/tfm/tf-m/bl2/ext/mcuboot/bootutil/include/bootutil;../../../../../../middleware/tfm/tf-m/platform/ext;../../../../../../middleware/tfm/tf-m/platform/ext/common;../../../../../../middleware/tfm/tf-m/platform/ext/common/template;../../../../../../middleware/tfm/tf-m/platform/ext/driver;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Native_Driver;../../../../../../middleware/tfm/tf-m/platform/ext/accelerator/interface;../../../../../../middleware/tfm/tf-m/platform/include;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Config;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Include;../../../../../../middleware/tfm/tf-m/interface/include/psa;../../../../../../middleware/tfm/tf-m/interface/include/crypto_keys;../../../../../../middleware/tfm/tf-m/secure_fw/include;../../../../../../middleware/tfm/tf-m/secure_fw/include/tfm;../../../../../../middleware/tfm/tf-m/secure_fw/spm;../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/boot;../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/interface;../../../../../../middleware/tfm/tf-m/secure_fw/spm/cmsis_func/include;../../../../../../middleware/tfm/tf-m/secure_fw/partitions;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/psa_manifest;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/audit_logging/psa_manifest;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/psa_manifest;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform/psa_manifest;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation/psa_manifest;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/psa_manifest;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/lib/runtime/include;../../../../../../middleware/tfm/tf-m/lib/fih/inc
  asm define: DEBUG
  asm include: ../../../../../../middleware/tfm/tf-m/platform/include
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/armclang/tfm_common_s_pre.sct
  link misc: --remove --entry=Reset_Handler --import-cmse-lib-out="./debug/tfm_regression_s_CMSE_lib.o"
  group startup
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Source/armclang/: startup_MIMXRT595S_cm33_s.S
  group device
    ../../../../../../devices/MIMXRT595S/: system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group board
    ../: pin_mux.c pin_mux.h hardware_init.c app.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MIMXRT595S/drivers/: fsl_casper.h fsl_casper.c fsl_hashcrypt.h fsl_hashcrypt.c fsl_trng.c fsl_trng.h fsl_ctimer.h fsl_ctimer.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c fsl_iap.h fsl_iap.c
  group tf-m/platform/ext/target/nxp/common/CMSIS_Driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/CMSIS_Driver/: Driver_Flash_iap.c Driver_USART.c
  group mbed-crypto/include/mbedtls
    ../../../../../../middleware/tfm/mbed-crypto/include/mbedtls/: aes.h aria.h asn1.h asn1write.h base64.h bignum.h build_info.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cipher.h compat-2.x.h cmac.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h error.h gcm.h hkdf.h hmac_drbg.h md.h md5.h memory_buffer_alloc.h nist_kw.h oid.h pem.h pk.h pkcs5.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h private_access.h psa_util.h ripemd160.h rsa.h sha1.h sha256.h sha512.h threading.h timing.h version.h
  group mbed-crypto/include/mbed_psa
    ../../../../../../middleware/tfm/mbed-crypto/include/mbed_psa/: crypto.h crypto_builtin_composites.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group mbed-crypto/library
    ../../../../../../middleware/tfm/mbed-crypto/library/: aes.c aesni.c aesni.h asn1parse.c asn1write.c base64.c bignum.c bignum_internal.h bn_mul.h camellia.c ccm.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cipher_wrap.h cmac.c common.h constant_time.c constant_time_internal.h constant_time_invasive.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_internal_alt.h ecp_invasive.h entropy.c entropy_poll.c entropy_poll.h error.c gcm.c hkdf.c hmac_drbg.c md.c md_wrap.h md5.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c padlock.h pem.c pk.c pk_wrap.c pk_wrap.h pkcs5.c pkcs12.c pkparse.c pkwrite.c pkwrite.h platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_alt_helpers.c rsa_alt_helpers.h sha1.c sha256.c sha512.c threading.c timing.c version.c version_features.c
  group mbed-crypto/port
    ../../../../../../middleware/tfm/mbed-crypto/port/: aes_alt.h mbedcrypto_mcux_casper.c mbedcrypto_mcux_css.c mbedcrypto_mcux_hashcrypt.c mbedcrypto_mcux_config.h mbedcrypto_mcux_entropy.c mbedcrypto_mcux_pkc.c mbedtls_accelerator_config.h sha1_alt.h sha256_alt.h sha512_alt.h
  group tf-m/platform/ext/target/nxp/evkmimxrt595
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/: target_cfg.c target_cfg.h tfm_peripherals_def.h
  group tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/Device/Include/: platform_base_address.h
  group tf-m/platform/ext/target/nxp/evkmimxrt595/partition
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/evkmimxrt595/partition/: flash_layout.h region_defs.h
  group tf-m/interface/include
    ../../../../../../middleware/tfm/tf-m/interface/include/: tfm_its_defs.h tfm_attest_defs.h tfm_attest_iat_defs.h tfm_ps_defs.h config_impl.h psa_audit_defs.h psa_config.h psa_interface_redirect.h tfm_api.h tfm_crypto_defs.h tfm_ns_client_ext.h tfm_platform_api.h tfm_psa_call_pack.h tfm_veneers.h
  group tf-m/secure_fw/partitions/internal_trusted_storage/auto_generated
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/auto_generated/: intermedia_tfm_internal_trusted_storage.c load_info_tfm_internal_trusted_storage.c
  group tf-m/secure_fw/partitions/internal_trusted_storage
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/: its_utils.c its_utils.h tfm_internal_trusted_storage.c tfm_internal_trusted_storage.h tfm_its_req_mngr.h tfm_its_req_mngr.c tfm_its_secure_api.c
  group tf-m/secure_fw/partitions/internal_trusted_storage/psa_manifest
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/psa_manifest/: tfm_internal_trusted_storage.h
  group tf-m/secure_fw/partitions/internal_trusted_storage/flash
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/flash/: its_flash.c its_flash.h its_flash_nand.c its_flash_nand.h its_flash_nor.c its_flash_nor.h its_flash_ram.c its_flash_ram.h
  group tf-m/secure_fw/partitions/internal_trusted_storage/flash_fs
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/flash_fs/: its_flash_fs.c its_flash_fs.h its_flash_fs_dblock.c its_flash_fs_dblock.h its_flash_fs_mblock.c its_flash_fs_mblock.h
  group tf-m/secure_fw/partitions/protected_storage
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/: ps_object_defs.h ps_encrypted_object.c ps_encrypted_object.h ps_object_defs.h ps_object_system.c ps_object_system.h ps_object_table.c ps_object_table.h ps_utils.c ps_utils.h tfm_protected_storage.c tfm_protected_storage.h tfm_ps_req_mngr.h tfm_ps_req_mngr.c tfm_ps_secure_api.c
  group tf-m/secure_fw/partitions/crypto/auto_generated
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/auto_generated/: intermedia_tfm_crypto.c load_info_tfm_crypto.c
  group tf-m/secure_fw/partitions/crypto/psa_driver_api
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/psa_driver_api/: tfm_builtin_key_loader.c tfm_builtin_key_loader.h
  group tf-m/secure_fw/partitions/crypto
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/: crypto_aead.c crypto_alloc.c crypto_asymmetric.c crypto_check_config.h crypto_cipher.c crypto_hash.c crypto_init.c crypto_key.c crypto_key_derivation.c crypto_key_management.c crypto_mac.c crypto_rng.c crypto_spe.h tfm_crypto_api.h tfm_crypto_secure_api.c tfm_mbedcrypto_builtin_keys.c tfm_mbedcrypto_include.h
  group tf-m/secure_fw/partitions/crypto/psa_manifest
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/psa_manifest/: tfm_crypto.h
  group tf-m/platform/ext/common/template
    ../../../../../../middleware/tfm/tf-m/platform/ext/common/template/: tfm_initial_attest_pub_key.c attest_hal.c crypto_keys.c flash_otp_nv_counters_backend.c flash_otp_nv_counters_backend.h nv_counters.c otp_flash.c
  group tf-m/secure_fw/partitions/initial_attestation/auto_generated
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation/auto_generated/: intermedia_tfm_initial_attestation.c load_info_tfm_initial_attestation.c
  group tf-m/secure_fw/partitions/initial_attestation
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation/: attest.h attest_asymmetric_key.c attest_boot_data.c attest_boot_data.h attest_core.c attest_key.h attest_token.h attest_token_encode.c tfm_attest.c tfm_attest_req_mngr.c tfm_attest_secure_api.c
  group tf-m/secure_fw/partitions/initial_attestation/psa_manifest
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation/psa_manifest/: tfm_initial_attestation.h
  group tf-m/lib/ext/t_cose/crypto_adapters
    ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/crypto_adapters/: t_cose_psa_crypto.c
  group tf-m/lib/ext/t_cose/src
    ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/src/: t_cose_crypto.h t_cose_parameters.c t_cose_parameters.h t_cose_sign1_sign.c t_cose_standard_constants.h t_cose_util.c t_cose_util.h t_cose_sign1_verify.c
  group tf-m/lib/ext/t_cose/inc
    ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/inc/: t_cose_common.h q_useful_buf.h t_cose_sign1_sign.h t_cose_sign1_verify.h
  group tf-m/lib/ext/qcbor/src
    ../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/src/: ieee754.c ieee754.h qcbor_decode.c qcbor_encode.c UsefulBuf.c
  group tf-m/lib/ext/qcbor/inc
    ../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/inc/: qcbor.h q_useful_buf.h UsefulBuf.h
  group tf-m/secure_fw/partitions/platform/auto_generated
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform/auto_generated/: intermedia_tfm_platform.c load_info_tfm_platform.c
  group tf-m/secure_fw/partitions/platform
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform/: platform_sp.c platform_sp.h tfm_platform_secure_api.c
  group tf-m/secure_fw/partitions/platform/psa_manifest
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform/psa_manifest/: tfm_platform.h
  group tf-m-tests/test/secure_fw/suites/audit/secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/audit/secure/: audit_s_tests.h
  group tf-m-tests/test/secure_fw
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/: secure_suites.c
  group tf-m-tests/test/framework
    ../../../../../../middleware/tfm/tf-m-tests/test/framework/: test_framework.c test_framework.h test_framework_error_codes.h test_framework_helpers.c test_framework_helpers.h test_framework_integ_test.h test_framework_integ_test_helper.c test_framework_integ_test_helper.h test_log.h
  group tf-m-tests/test/secure_fw/test_services/tfm_secure_client_service/auto_generated
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_secure_client_service/auto_generated/: intermedia_tfm_secure_client_service.c load_info_tfm_secure_client_service.c
  group tf-m-tests/test/secure_fw/common_test_services/tfm_secure_client_service
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/common_test_services/tfm_secure_client_service/: tfm_secure_client_service.c tfm_secure_client_service.h
  group tf-m-tests/test/secure_fw/test_services/tfm_secure_client_service/psa_manifest
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_secure_client_service/psa_manifest/: tfm_secure_client_service.h
  group tf-m-tests/test/secure_fw/test_services/tfm_secure_client_2/auto_generated
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_secure_client_2/auto_generated/: intermedia_tfm_secure_client_2.c load_info_tfm_secure_client_2.c
  group tf-m-tests/test/secure_fw/test_services/tfm_secure_client_2/psa_manifest
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_secure_client_2/psa_manifest/: tfm_secure_client_2.h
  group tf-m-tests/test/secure_fw/common_test_services/tfm_secure_client_2
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/common_test_services/tfm_secure_client_2/: tfm_secure_client_2.c tfm_secure_client_2_api.c tfm_secure_client_2_api.h
  group tf-m-tests/test/secure_fw/suites/spm/ipc/secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/ipc/secure/: ipc_s_tests.h ipc_s_tests.h ipc_s_interface_testsuite.c
  group tf-m-tests/test/secure_fw/suites/its
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/its/: its_tests_common.c its_tests_common.h
  group tf-m-tests/test/secure_fw/suites/its/secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/its/secure/: its_s_tests.h psa_its_s_interface_testsuite.c psa_its_s_reliability_testsuite.c
  group tf-m-tests/test/secure_fw/suites/attestation/ext/qcbor_util
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/attestation/ext/qcbor_util/: qcbor_util.c qcbor_util.h
  group tf-m-tests/test/secure_fw/suites/attestation/secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/attestation/secure/: attest_asymmetric_s_interface_testsuite.c attest_s_tests.h
  group tf-m-tests/test/secure_fw/suites/attestation
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/attestation/: attest_token_decode_asymmetric.c attest_token_decode.h attest_token_decode_common.c attest_token_test.c attest_token_test.h attest_token_test_values.h attest_tests_common.h
  group tf-m-tests/test/secure_fw/suites/crypto
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/crypto/: crypto_tests_common.c crypto_tests_common.h crypto_tests_check_config.h
  group tf-m-tests/test/secure_fw/suites/crypto/secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/crypto/secure/: crypto_s_tests.h crypto_sec_interface_testsuite.c
  group tf-m-tests/test/secure_fw/suites/platform
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/platform/: platform_tests_common.c platform_tests_common.h
  group tf-m-tests/test/secure_fw/suites/platform/secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/platform/secure/: platform_s_tests.h platform_s_interface_testsuite.c
  group tf-m/interface/include/psa_manifest
    ../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest/: sid.h pid.h
  group tf-m/interface/src
    ../../../../../../middleware/tfm/tf-m/interface/src/: tfm_psa_call_pack.c
  group tf-m/secure_fw/partitions/ns_agent_tz
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/ns_agent_tz/: load_info_ns_agent_tz.c ns_agent_tz.h ns_agent_tz_init.c ns_agent_tz_v80m.c psa_api_veneers_v80m.c
  group tf-m/secure_fw/partitions/idle_partition
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/idle_partition/: idle_partition.c load_info_idle_sp.c
  group tf-m/secure_fw/spm/cmsis_psa
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/cmsis_psa/: internal_errors.h main.c tfm_pools.h tfm_rpc.h tfm_svcalls.h psa_interface_svc.c spm_ipc.c spm_ipc.h static_loader.c tfm_core_svcalls_ipc.c tfm_pools.c thread.c thread.h
  group tf-m/secure_fw/spm/cmsis_psa/arch
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/cmsis_psa/arch/: tfm_arch.c tfm_arch_v8m_main.c
  group tf-m/secure_fw/spm/ffm
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/ffm/: backend_ipc.c psa_api.c interrupt.c interrupt.h spm_log.c stack_watermark.c stack_watermark.h tfm_boot_data.c tfm_boot_data.h tfm_core_mem_check.c utilities.c
  group tf-m/secure_fw/spm/include/ffm
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/ffm/: backend.h backend_ipc.h backend_sfn.h psa_api.h
  group tf-m/secure_fw/spm/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/: critical_section.h aapcs_local.h bitops.h current.h lists.h tfm_assert.h tfm_core_mem_check.h tfm_core_trustzone.h tfm_nspm.h tfm_platform_core_api.h tfm_spm_log.h tfm_version.h utilities.h tfm_arch.h tfm_arch_v8m.h
  group tf-m-tests/test/secure_fw/suites/spm/common
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/common/: spm_test_defs.h spm_test_defs.h
  group tf-m-tests/test/secure_fw/suites/spm/common/suites
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/common/suites/: client_api_tests.c client_api_tests.h
  group tf-m-tests/test/secure_fw/suites/spm/common/service
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/common/service/: client_api_test_defs.h client_api_test_service.c client_api_test_service.h tfm_irq_test_service.c tfm_irq_test_service.h
  group tf-m-tests/test/secure_fw/test_services/tfm_ipc_service/auto_generated
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_ipc_service/auto_generated/: intermedia_tfm_ipc_service_test.c load_info_tfm_ipc_service_test.c
  group tf-m-tests/test/secure_fw/test_services/tfm_ipc_service/psa_manifest
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_ipc_service/psa_manifest/: tfm_ipc_service_test.h
  group tf-m-tests/test/secure_fw/suites/spm/ipc/service/tfm_ipc_service
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/ipc/service/tfm_ipc_service/: tfm_ipc_service_test.c
  group tf-m-tests/test/secure_fw/test_services/tfm_ipc_client/auto_generated
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_ipc_client/auto_generated/: intermedia_tfm_ipc_client_test.c load_info_tfm_ipc_client_test.c
  group tf-m-tests/test/secure_fw/test_services/tfm_ipc_client/psa_manifest
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_ipc_client/psa_manifest/: tfm_ipc_client_test.h
  group tf-m-tests/test/secure_fw/suites/spm/ipc/service/tfm_ipc_client
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/ipc/service/tfm_ipc_client/: tfm_ipc_client_test.c
  group tf-m-tests/test/secure_fw/test_services/tfm_core_test/auto_generated
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_core_test/auto_generated/: intermedia_tfm_ss_core_test.c load_info_tfm_ss_core_test.c
  group tf-m-tests/test/secure_fw/suites/core/service/tfm_core_test
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/core/service/tfm_core_test/: core_test_defs.h tfm_ss_core_test.c tfm_ss_core_test.h
  group tf-m-tests/test/secure_fw/test_services/tfm_core_test/psa_manifest
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_core_test/psa_manifest/: tfm_ss_core_test.h
  group tf-m-tests/test/secure_fw/test_services/tfm_core_test_2/auto_generated
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_core_test_2/auto_generated/: intermedia_tfm_ss_core_test_2.c load_info_tfm_ss_core_test_2.c
  group tf-m-tests/test/secure_fw/suites/core/service/tfm_core_test_2
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/core/service/tfm_core_test_2/: tfm_ss_core_test_2.c tfm_ss_core_test_2.h
  group tf-m-tests/test/secure_fw/test_services/tfm_core_test_2/psa_manifest
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_core_test_2/psa_manifest/: tfm_ss_core_test_2.h
  group tf-m/secure_fw/partitions/protected_storage/auto_generated
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/auto_generated/: intermedia_tfm_protected_storage.c load_info_tfm_protected_storage.c
  group tf-m/secure_fw/partitions/protected_storage/crypto
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/crypto/: ps_crypto_interface.c ps_crypto_interface.h
  group tf-m/secure_fw/partitions/protected_storage/psa_manifest
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/psa_manifest/: tfm_protected_storage.h
  group tf-m/secure_fw/partitions/protected_storage/nv_counters
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/nv_counters/: ps_nv_counters.h ps_nv_counters.c
  group tf-m-tests/test/secure_fw/suites/ps/secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/ps/secure/: psa_ps_s_interface_testsuite.c psa_ps_s_reliability_testsuite.c s_test_helpers.h ps_tests.h
  group tf-m-tests/test/secure_fw/test_services/tfm_ps_test_service/auto_generated
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_ps_test_service/auto_generated/: intermedia_tfm_ps_test_service.c load_info_tfm_ps_test_service.c
  group tf-m-tests/test/secure_fw/test_services/tfm_ps_test_service/psa_manifest
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_ps_test_service/psa_manifest/: tfm_ps_test_service.h
  group tf-m-tests/test/secure_fw/suites/ps/service
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/ps/service/: tfm_ps_test_service.c tfm_ps_test_service_api.c tfm_ps_test_service_api.h
  group tf-m/lib/ext/mbedcrypto/mbedcrypto_config
    ../../../../../../middleware/tfm/tf-m/lib/ext/mbedcrypto/mbedcrypto_config/: tfm_mbedcrypto_config_profile_medium.h crypto_config_profile_medium.h tfm_mbedcrypto_config_extra_nv_seed.h
  group tf-m-tests/test/secure_fw/test_services/tfm_slih_test_service/auto_generated
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_slih_test_service/auto_generated/: intermedia_tfm_slih_test_service.c load_info_tfm_slih_test_service.c
  group tf-m-tests/test/secure_fw/suites/spm/irq/service/tfm_slih_test_service
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/irq/service/tfm_slih_test_service/: tfm_slih_test_service.c
  group tf-m-tests/test/secure_fw/test_services/tfm_slih_test_service/psa_manifest
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/test_services/tfm_slih_test_service/psa_manifest/: tfm_slih_test_service.h
  group utilities
    ../../../../../../devices/MIMXRT595S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT595S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT595S/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group tf-m/lib/fih/inc
    ../../../../../../middleware/tfm/tf-m/lib/fih/inc/: fih.h tfm_fih_rng.h
  group tf-m/lib/fih/src
    ../../../../../../middleware/tfm/tf-m/lib/fih/src/: fih.c
  group tf-m/platform/ext/common
    ../../../../../../middleware/tfm/tf-m/platform/ext/common/: core_ext.h exception_info.c faults.c provisioning.c tfm_hal_its.c tfm_hal_memory_symbols.c tfm_hal_nvic.c tfm_hal_ps.c tfm_hal_sp_logdev.h tfm_hal_sp_logdev_periph.c tfm_hal_spm_logdev.h tfm_hal_spm_logdev_peripheral.c tfm_hal_reset_halt.c uart_stdout.c uart_stdout.h
  group tf-m/platform/ext/driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/driver/: Driver_Common.h Driver_Flash.h Driver_MPC.h Driver_PPC.h Driver_USART.h
  group tf-m/platform/ext/accelerator/interface
    ../../../../../../middleware/tfm/tf-m/platform/ext/accelerator/interface/: crypto_hw.h
  group tf-m/platform/ext/target/nxp/common/Native_Driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Native_Driver/: mpu_armv8m_drv.c mpu_armv8m_drv.h
  group tf-m/platform/ext/target/nxp/common
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/: crypto_hw.c spm_hal.c tfm_hal_isolation.c mmio_defs.h plat_huk.c tfm_hal_platform.c tfm_interrupts.c plat_test.c
  group tf-m/platform/ext/target/nxp/common/services/src
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/services/src/: tfm_platform_system.c
  group tf-m/platform/ext/target/nxp/common/Device/Config
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Config/: device_cfg.h
  group tf-m/platform/ext/target/nxp/common/Device/Include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Include/: cmsis.h device_definition.h platform_description.h platform_irq.h platform_regs.h
  group tf-m/platform/include
    ../../../../../../middleware/tfm/tf-m/platform/include/: exception_info.h mbedtls_entropy_nv_seed_config.h region.h tfm_attest_hal.h tfm_hal_defs.h tfm_hal_device_header.h tfm_hal_interrupt.h tfm_hal_isolation.h tfm_hal_its.h tfm_hal_memory_symbols.h tfm_hal_platform.h tfm_hal_ps.h tfm_plat_boot_seed.h tfm_plat_config.h tfm_plat_crypto_keys.h tfm_plat_defs.h tfm_plat_device_id.h tfm_plat_ns.h tfm_plat_nv_counters.h tfm_plat_otp.h tfm_plat_provisioning.h tfm_plat_test.h tfm_platform_system.h tfm_spm_hal.h
  group tf-m/interface/include/crypto_keys
    ../../../../../../middleware/tfm/tf-m/interface/include/crypto_keys/: tfm_builtin_key_ids.h
  group tf-m/interface/include/psa
    ../../../../../../middleware/tfm/tf-m/interface/include/psa/: client.h crypto.h crypto_client_struct.h crypto_compat.h crypto_extra.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h error.h framework_feature.h initial_attestation.h internal_trusted_storage.h lifecycle.h protected_storage.h service.h storage_common.h
  group tf-m/secure_fw/spm/include/boot
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/boot/: tfm_boot_status.h
  group tf-m/secure_fw/spm/include/interface
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/interface/: runtime_defs.h svc_num.h
  group tf-m/secure_fw/spm/include/load
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/load/: asset_defs.h interrupt_defs.h partition_defs.h service_defs.h spm_load_api.h
  group tf-m/secure_fw/spm/cmsis_func/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/cmsis_func/include/: spm_partition_defs.h spm_func.h tfm_secure_api.h tfm_core_svc.h
  group tf-m/secure_fw/spm/ns_client_ext
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/ns_client_ext/: tfm_ns_ctx.h tfm_spm_ns_ctx.c
  group tf-m/secure_fw/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/include/: array.h build_config_check.h compiler_ext_defs.h security_defs.h
  group tf-m/secure_fw/partitions/lib/runtime/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/lib/runtime/include/: service_api.h rt_main.h tfm_sp_log.h tfm_strnlen.h
  group tf-m/secure_fw/partitions/lib/runtime
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/lib/runtime/: service_api.c sfn_common_thread.c rt_main.c sprt_partition_metadata_indicator.c sprt_partition_metadata_indicator.h tfm_sp_log_raw.c crt_strnlen.c
target tfm_regression_s release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tfm_regression_s.out
  BeforeMake: as above
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, TFM_LVL=2, TFM_SPM_LOG_LEVEL=TFM_SPM_LOG_LEVEL_INFO, TFM_SP_LOG_RAW_ENABLED, TFM_PARTITION_LOG_LEVEL=TFM_PARTITION_LOG_LEVEL_INFO, TFM_CRYPTO_IOVEC_BUFFER_SIZE=5120, TFM_CRYPTO_ENGINE_BUF_SIZE=9600, ITS_MAX_ASSET_SIZE=512, ITS_NUM_ASSETS=5, PS_MAX_ASSET_SIZE=512, PS_NUM_ASSETS=5, PS_RAM_FS, PS_CREATE_FLASH_LAYOUT, PS_WIPE_ALL, ITS_RAM_FS, ITS_CREATE_FLASH_LAYOUT, OTP_NV_COUNTERS_RAM_EMULATION, ITS_WIPE_ALL, CONFIG_TFM_CONN_HANDLE_MAX_NUM=8, DAUTH_CHIP_DEFAULT, __SEMIHOST_HARDFAULT_DISABLE, TFM_CRYPTO_TEST_ALG_CCM, TFM_CRYPTO_TEST_HKDF, CRYPTO_HW_ACCELERATOR, TFM_PARTITION_INTERNAL_TRUSTED_STORAGE, TFM_PARTITION_CRYPTO, PLATFORM_DEFAULT_CRYPTO_KEYS, MBEDTLS_PSA_CRYPTO_DRIVERS, MBEDTLS_PSA_CRYPTO_BUILTIN_KEYS, PSA_CRYPTO_DRIVER_TFM_BUILTIN_KEY, PSA_CRYPTO_DRIVER_TFM_BUILTIN_KEY_LOADER, TFM_PARTITION_INITIAL_ATTESTATION, T_COSE_USE_PSA_CRYPTO, TFM_PARTITION_PLATFORM, TEST_FRAMEWORK_S, USE_SP_LOG, TEST_S_ITS, TEST_S_ATTESTATION, TEST_S_CRYPTO, TEST_S_PLATFORM, TFM_PSA_API=1, CONFIG_TFM_ENABLE_MEMORY_PROTECT, TFM_PARTITION_NS_AGENT_TZ, TFM_PARTITION_IPC_TEST, TEST_S_IPC, TEST_NS_CORE, TFM_ENABLE_PERIPH_ACCESS_TEST, TFM_PARTITION_PROTECTED_STORAGE, PS_ENCRYPTION, PS_ROLLBACK_PROTECTION, TFM_PARTITION_TEST_PS, TEST_S_PS, MBEDTLS_CONFIG_FILE='\"tfm_mbedcrypto_config_profile_medium.h\"', MBEDTLS_PSA_CRYPTO_CONFIG_FILE='\"crypto_config_profile_medium.h\"', TFM_CRYPTO_ASYM_ENCRYPT_MODULE_DISABLED, PS_CRYPTO_AEAD_ALG=PSA_ALG_CCM, TEST_NS_SLIH_IRQ, SERIAL_PORT_TYPE_UART=1, CONFIG_TFM_BUILDING_SPE=1, PLATFORM_DEFAULT_NV_COUNTERS, PLATFORM_DEFAULT_OTP, PLATFORM_DEFAULT_PROVISIONING, OTP_WRITEABLE, TFM_DUMMY_PROVISIONING, CONFIG_TFM_PSA_API_SUPERVISOR_CALL, CONFIG_TFM_PARTITION_META, CONFIG_TFM_FLOAT_ABI=2, CONFIG_TFM_ENABLE_CP10CP11, CONFIG_TFM_LAZY_STACKING, CONFIG_TFM_HALT_ON_CORE_PANIC, CONFIG_TFM_USE_TRUSTZONE, ATTEST_TOKEN_PROFILE_PSA_IOT_1, ATTEST_KEY_BITS=256, TFM_PARTITION_TEST_SECURE_SERVICES, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG
  asm include: ../../../../../../middleware/tfm/tf-m/platform/include
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: as above
  link misc: --remove --entry=Reset_Handler --import-cmse-lib-out="./release/tfm_regression_s_CMSE_lib.o"
