<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>hello_world_s</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>hello_world_s</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>hello_world_s</project>
        <configuration>flash_debug</configuration>
      </member>
      <member>
        <project>hello_world_s</project>
        <configuration>flash_release</configuration>
      </member>
      <member>
        <project>hello_world_ns</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>hello_world_ns</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>hello_world_ns</project>
        <configuration>flash_debug</configuration>
      </member>
      <member>
        <project>hello_world_ns</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>hello_world_s</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>hello_world_ns</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>hello_world_s</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>hello_world_ns</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_debug</name>
      <member>
        <project>hello_world_s</project>
        <configuration>flash_debug</configuration>
      </member>
      <member>
        <project>hello_world_ns</project>
        <configuration>flash_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_release</name>
      <member>
        <project>hello_world_s</project>
        <configuration>flash_release</configuration>
      </member>
      <member>
        <project>hello_world_ns</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/hello_world_s.ewp</path>
  </project>
</workspace>
