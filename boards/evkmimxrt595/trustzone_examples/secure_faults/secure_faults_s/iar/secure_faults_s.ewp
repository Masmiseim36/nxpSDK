# IAR project secure_faults_s.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT595S_M33 NXP MIMXRT595S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEMO_CODE_START_NS=2883584; DEBUG; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MIMXRT595S/utilities/debug_console_lite; ../../../../../../devices/MIMXRT595S/drivers; ../../../../../../devices/MIMXRT595S; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../flash_config; ../../../../../../devices/MIMXRT595S/utilities/str; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: secure_faults_s.out
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_ram_s.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEMO_CODE_START_NS=135266304; DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT595SFFOC_cm33; MCUXPRESSO_SDK
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_flash_s.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEMO_CODE_START_NS=2883584; NDEBUG; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEMO_CODE_START_NS=135266304; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_flash_s.icf
  group source
    ../: secure_faults_s.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group trustzone
    ../: tzm_config.c tzm_config.h veneer_table.c veneer_table.h tzm_api.c tzm_api.h
  group doc
    ../: readme.md
  group utilities
    ../../../../../../devices/MIMXRT595S/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c fsl_assert.h
    ../../../../../../devices/MIMXRT595S/utilities/str/: fsl_str.c fsl_str.h
  group drivers
    ../../../../../../devices/MIMXRT595S/drivers/: fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c fsl_iap.h fsl_iap.c
  group device
    ../../../../../../devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group startup
    ../../../../../../devices/MIMXRT595S/iar/: startup_MIMXRT595S_cm33.s
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
