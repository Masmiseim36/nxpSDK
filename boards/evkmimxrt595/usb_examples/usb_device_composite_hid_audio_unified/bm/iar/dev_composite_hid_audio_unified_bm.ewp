# IAR project dev_composite_hid_audio_unified_bm.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT595S_M33 NXP MIMXRT595S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: _DEBUG=1; DEBUG; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; USB_STACK_BM; CPU_MIMXRT595SEVKA=1; USB_STACK_USE_DEDICATED_RAM=1; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8904_ENABLE; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../middleware/usb/device; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/phy; ../../../../../../devices/MIMXRT595S/drivers; ../../../../../../components/codec/wm8904; ../../../../../../components/codec; ../../../../../../components/codec/port/wm8904; ../../../../../../components/codec/i2c; ../../../../../../components/i2c; ../../../../../../devices/MIMXRT595S/utilities/debug_console_lite; ../../../../../../devices/MIMXRT595S; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../flash_config; ../../../../../../components/osa; ../../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: dev_composite_hid_audio_unified_bm.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT595SFFOC_cm33; USB_STACK_BM; CPU_MIMXRT595SEVKA=1; USB_STACK_USE_DEDICATED_RAM=1; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8904_ENABLE; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; NDEBUG; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; USB_STACK_BM; CPU_MIMXRT595SEVKA=1; USB_STACK_USE_DEDICATED_RAM=1; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8904_ENABLE; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; USB_STACK_BM; CPU_MIMXRT595SEVKA=1; USB_STACK_USE_DEDICATED_RAM=1; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8904_ENABLE; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_flash.icf
  group doc
    ../: readme.txt
  group source
    ../: audio_unified.c audio_unified.h composite.c composite.h hid_keyboard.c hid_keyboard.h usb_device_descriptor.c usb_device_descriptor.h usb_device_config.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h usb_device_dci.h
  group usb/device/source/lpcip3511
    ../../../../../../middleware/usb/device/: usb_device_lpcip3511.c usb_device_lpcip3511.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/audio
    ../: usb_device_audio.c usb_device_audio.h
  group usb/device/class/hid
    ../: usb_device_hid.c usb_device_hid.h
  group usb/device/include
    ../../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group usb/phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group drivers
    ../../../../../../devices/MIMXRT595S/drivers/: fsl_i2c.h fsl_i2c.c fsl_i2s.h fsl_i2s.c fsl_i2s_dma.h fsl_i2s_dma.c fsl_dma.c fsl_dma.h fsl_usart.h fsl_usart.c fsl_i3c.h fsl_i3c.c fsl_pint.h fsl_pint.c fsl_inputmux.h fsl_inputmux.c fsl_sctimer.h fsl_sctimer.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c fsl_inputmux_connections.h fsl_iap.h fsl_iap.c
  group codec
    ../../../../../../components/codec/wm8904/: fsl_wm8904.h fsl_wm8904.c
    ../../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../../components/codec/port/wm8904/: fsl_codec_adapter.c fsl_codec_adapter.h
    ../../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
  group component/i2c
    ../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_i3c.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c
  group utilities
    ../../../../../../devices/MIMXRT595S/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group device
    ../../../../../../devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group startup
    ../../../../../../devices/MIMXRT595S/iar/: startup_MIMXRT595S_cm33.s
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm33.h tz_context.h mpu_armv8.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
