# Keil uVision project dev_mtp_lite_bm.uvprojx, settings and files
target dev_mtp_lite_bm debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: dev_mtp_lite_bm.out
  AfterMake: fromelf.exe --output "$Lsdk20-app.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, _DEBUG=1, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, USB_STACK_BM, CPU_MIMXRT595SEVKA=1, USB_STACK_USE_DEDICATED_RAM=1, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SDK_DEBUGCONSOLE=1, MCUXPRESSO_SDK, MMC_ENABLED, SDK_OS_BAREMETAL, SERIAL_PORT_TYPE_UART=1
  c misc: -mno-unaligned-access  -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../..;../../../../../../middleware/usb/example/boards/evkmimxrt595/usb_device_mtp_lite/bm;../../../../../../components/gpio;../../../../../../devices/MIMXRT595S/drivers;../../../../../../middleware/fatfs/source/fsl_mmc_disk;../../../../../../middleware/fatfs/source;../../../../../../middleware/sdmmc/host/usdhc;../../../../../../middleware/sdmmc/mmc;../../../../../../middleware/usb/device;../../../../../../middleware/usb/include;../../../../../../middleware/usb/phy;../../../../../../components/lists;../../../../../../components/serial_manager;../../../../../../components/uart;../../../../../../devices/MIMXRT595S;../../../../flash_config;../../../../../../devices/MIMXRT595S/utilities;../../../../../../devices/MIMXRT595S/utilities/debug_console;../../../../../../middleware/sdmmc/common;../../../../../../middleware/sdmmc/osa;../../../../../../components/osa;../../../../../../CMSIS/Core/Include;../../../../../../devices/MIMXRT595S/utilities/str
  asm define: DEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_ram.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314 --predefine="-D__stack_size__=0x2000"
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h sdmmc_config.c sdmmc_config.h
  group source
    ../: ffconf.h mtp.c mtp.h mtp_operation.c mtp_operation.h mtp_file_system_adapter.c mtp_file_system_adapter.h mtp_object_handle.c mtp_object_handle.h usb_device_descriptor.c usb_device_descriptor.h usb_device_ch9.c usb_device_ch9.h usb_device_mtp.c usb_device_mtp.h usb_device_mtp_operation.c usb_device_mtp_operation.h usb_device_config.h
  group doc
    ../: readme.txt
  group component/gpio
    ../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_rt_gpio.c
  group drivers
    ../../../../../../devices/MIMXRT595S/drivers/: fsl_usdhc.c fsl_usdhc.h fsl_usart.h fsl_usart.c fsl_cache.c fsl_cache.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_flexcomm.h fsl_flexcomm.c fsl_flexspi.c fsl_flexspi.h fsl_gpio.h fsl_gpio.c fsl_iopctl.h fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_iap.h fsl_iap.c
  group fatfs/source/fsl_mmc_disk
    ../../../../../../middleware/fatfs/source/fsl_mmc_disk/: fsl_mmc_disk.c fsl_mmc_disk.h
  group fatfs/source
    ../../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group sdmmc/host
    ../../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
    ../../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt ChangeLogKSDK.txt
  group sdmmc/src
    ../../../../../../middleware/sdmmc/mmc/: fsl_mmc.c
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../../middleware/sdmmc/mmc/: fsl_mmc.h
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/mmc
    ../../../../../../middleware/sdmmc/mmc/: ChangeLogKSDK.txt
  group usb/device/source/lpcip3511
    ../../../../../../middleware/usb/device/: usb_device_lpcip3511.c usb_device_lpcip3511.h
  group usb/phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group device
    ../../../../../../devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group startup
    ../../../../../../devices/MIMXRT595S/arm/: startup_MIMXRT595S_cm33.S
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group usb/device/include
    ../../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group usb/device/source
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h usb_device_dci.h
  group utilities
    ../../../../../../devices/MIMXRT595S/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../../devices/MIMXRT595S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT595S/utilities/str/: fsl_str.c fsl_str.h
  group sdmmc/osa
    ../../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target dev_mtp_lite_bm flash_debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: dev_mtp_lite_bm.out
  AfterMake: fromelf.exe --output "$Lsdk20-app.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, USB_STACK_BM, CPU_MIMXRT595SEVKA=1, USB_STACK_USE_DEDICATED_RAM=1, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SDK_DEBUGCONSOLE=1, MCUXPRESSO_SDK, MMC_ENABLED, SDK_OS_BAREMETAL, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: DEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_flash.scf
  link misc: as above
target dev_mtp_lite_bm release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: dev_mtp_lite_bm.out
  AfterMake: fromelf.exe --output "$Lsdk20-app.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, _DEBUG=0, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, USB_STACK_BM, CPU_MIMXRT595SEVKA=1, USB_STACK_USE_DEDICATED_RAM=1, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SDK_DEBUGCONSOLE=1, MCUXPRESSO_SDK, MMC_ENABLED, SDK_OS_BAREMETAL, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_ram.scf
  link misc: as above
target dev_mtp_lite_bm flash_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: dev_mtp_lite_bm.out
  AfterMake: fromelf.exe --output "$Lsdk20-app.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, USB_STACK_BM, CPU_MIMXRT595SEVKA=1, USB_STACK_USE_DEDICATED_RAM=1, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SDK_DEBUGCONSOLE=1, MCUXPRESSO_SDK, MMC_ENABLED, SDK_OS_BAREMETAL, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: MIMXRT595Sxxxx_cm33_flash.scf
  link misc: as above
