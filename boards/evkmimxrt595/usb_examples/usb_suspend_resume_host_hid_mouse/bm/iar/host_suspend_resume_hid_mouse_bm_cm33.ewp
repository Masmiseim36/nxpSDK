# IAR project host_suspend_resume_hid_mouse_bm_cm33.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT595S_M33 NXP MIMXRT595S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; USB_STACK_BM; USB_STACK_USE_DEDICATED_RAM=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT595SFFOC_cm33; MIMXRT595S_cm33_SERIES; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; BOOT_HEADER_ENABLE=1; SERIAL_PORT_TYPE_UART=1; TIMER_PORT_TYPE_MRT=1; USE_RTOS=0; SDK_I2C_BASED_COMPONENT_USED=1
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../flash_config; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT595S; ../../../../../../devices/MIMXRT595S/periph; ../../../../../../devices/MIMXRT595S/drivers; ../../../../../../devices/MIMXRT595S/utilities/debug_console; ../../../../../../components/lists; ../../../../../../devices/MIMXRT595S/utilities/str; ../../../../../../components/serial_manager; ../../../../../../components/timer; ../../../../../../components/uart; ../../../../../../components/osa; ../../../../../../components/pmic/pca9420; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/host; ../../../../../../middleware/usb/config/host/ip3516hs; ../../../../../../middleware/usb/host/class; ../../../../../../middleware/usb/phy
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT595SFFOC_cm33; MIMXRT595S_cm33_SERIES; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: host_suspend_resume_hid_mouse_bm.bin
  ILINK.IlinkOutputFile: host_suspend_resume_hid_mouse_bm_cm33.out
  ILINK.IlinkConfigDefines: __heap_size__=0x2000; __stack_size__=0x2000
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USB_STACK_BM; USB_STACK_USE_DEDICATED_RAM=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT595SFFOC_cm33; MIMXRT595S_cm33_SERIES; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; BOOT_HEADER_ENABLE=1; SERIAL_PORT_TYPE_UART=1; TIMER_PORT_TYPE_MRT=1; USE_RTOS=0; SDK_I2C_BASED_COMPONENT_USED=1
  ICCARM.IExtraOptions: --no_unaligned_access  --diag_suppress=Pa082,Pa050 --diag_suppress=Pa082,Pa050
  ICCARM.CCOptLevel: 3
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.IExtraOptions: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_flash.icf
  group source
    ../: app.c app.h host_mouse.c host_mouse.h pmic_support.c pmic_support.h hardware_init.c pin_mux.c pin_mux.h fsl_debug_console_conf.h fsl_os_abstraction_config.h mcux_config.h usb_host_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group device
    ../../../../../../devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_COMMON.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group device/periph
    ../../../../../../devices/MIMXRT595S/periph/: PERI_ADC.h PERI_AHB_SECURE_CTRL.h PERI_AXI_SWITCH_AMIB.h PERI_AXI_SWITCH_ASIB.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CASPER.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CMP.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUGGER_MAILBOX.h PERI_DMA.h PERI_DMIC.h PERI_FLEXCOMM.h PERI_FLEXIO.h PERI_FLEXSPI.h PERI_FREQME.h PERI_GPIO.h PERI_HASHCRYPT.h PERI_I2C.h PERI_I2S.h PERI_I3C.h PERI_INPUTMUX.h PERI_IOPCTL.h PERI_LCDIF.h PERI_MIPI_DSI_HOST.h PERI_MRT.h PERI_MU.h PERI_OCOTP.h PERI_OSTIMER.h PERI_OTFAD.h PERI_PINT.h PERI_PMC.h PERI_POWERQUAD.h PERI_PUF.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RTC.h PERI_SCT.h PERI_SEMA42.h PERI_SPI.h PERI_SYSCTL0.h PERI_SYSCTL1.h PERI_TRNG.h PERI_USART.h PERI_USBHSD.h PERI_USBHSDCD.h PERI_USBHSH.h PERI_USBPHY.h PERI_USDHC.h PERI_UTICK.h PERI_WWDT.h
  group startup/iar
    ../../../../../../devices/MIMXRT595S/iar/: startup_MIMXRT595S_cm33.s
  group drivers
    ../../../../../../devices/MIMXRT595S/drivers/: fsl_clock.c fsl_clock.h fsl_dsp.c fsl_dsp.h fsl_i2s_bridge.c fsl_i2s_bridge.h fsl_inputmux_connections.h fsl_memory.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_soc_mipi_dsi.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_flexcomm.h fsl_flexcomm.c fsl_usart.h fsl_usart.c fsl_i2c.h fsl_i2c.c fsl_flexspi.c fsl_flexspi.h fsl_iap.h fsl_iap.c fsl_inputmux.h fsl_inputmux.c fsl_gpio.h fsl_gpio.c fsl_iopctl.h fsl_mrt.h fsl_mrt.c fsl_pint.h fsl_pint.c
  group utilities
    ../../../../../../devices/MIMXRT595S/utilities/debug_console/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../../devices/MIMXRT595S/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console
    ../../../../../../devices/MIMXRT595S/utilities/debug_console/: fsl_debug_console.h fsl_debug_console.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/timer
    ../../../../../../components/timer/: fsl_adapter_timer.h fsl_adapter_mrt.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c fsl_os_abstraction.h
  group component/pmic/pca9420
    ../../../../../../components/pmic/pca9420/: fsl_pca9420.c fsl_pca9420.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group usb/host
    ../../../../../../middleware/usb/host/: usb_host.h usb_host_hci.h usb_host_devices.h usb_host_framework.h usb_host_ip3516hs.c usb_host_ip3516hs.h usb_host_hci.c usb_host_devices.c usb_host_framework.c
  group usb/host/class
    ../../../../../../middleware/usb/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_hid.c usb_host_hid.h
  group usb/phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group doc
    ../: readme.md examples_shared_readme.md
