# IAR project clock_freertos_cm33.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT595S_M33 NXP MIMXRT595S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; GCID_REV_CID=gc255/0x40A; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; SDK_DEBUGCONSOLE_UART; CUSTOM_VGLITE_MEMORY_CONFIG=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT595SFFOC_cm33; MIMXRT595S_cm33_SERIES; BOOT_HEADER_ENABLE=1; SDK_OS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pa092
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../flash_config; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT595S; ../../../../../../devices/MIMXRT595S/periph; ../../../../../../devices/MIMXRT595S/drivers; ../../../../../../devices/MIMXRT595S/utilities/debug_console_lite; ../../../../../../devices/MIMXRT595S/utilities/str; ../../../../../../components/uart; ../../../../../../components/video; ../../../../../../components/video/display/dc; ../../../../../../components/video/display; ../../../../../../components/video/display/fbdev; ../../../../../../components/video/display/dbi; ../../../../../../components/video/display/dbi/flexio; ../../../../../../components/video/display/dc/dsi_cmd; ../../../../../../components/video/display/dc/lcdif; ../../../../../../components/video/display/dc/ssd1963; ../../../../../../components/video/display/mipi_dsi_cmd; ../../../../../../components/video/display/hx8394; ../../../../../../components/video/display/rm68191; ../../../../../../components/video/display/rm68200; ../../../../../../components/video/display/rm67162; ../../../../../../components/video/display/co5300; ../../../../../../components/display/ssd1963; ../../../../../../middleware/vglite/driver/inc; ../../../../../../middleware/vglite/driver/VGLite; ../../../../../../middleware/vglite/driver/VGLite/rtos; ../../../../../../middleware/vglite/driver/VGLite/Series/gc555/0x423_ECO; ../../../../../../middleware/vglite/driver/VGLite/Series/gc355/0x0_1216; ../../../../../../middleware/vglite/driver/VGLite/Series/gc255/0x40A; ../../../../../../middleware/vglite/driver/VGLiteKernel; ../../../../../../middleware/vglite/driver/VGLiteKernel/rtos; ../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../../rtos/freertos/freertos-kernel/template
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT595SFFOC_cm33; MIMXRT595S_cm33_SERIES
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: clock_freertos.bin
  ILINK.IlinkOutputFile: clock_freertos_cm33.out
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_ram.icf
  ILINK.IlinkExtraOptions: --redirect  __iar_sh_stdout=__iar_sh_stdout_swo
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; GCID_REV_CID=gc255/0x40A; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; SDK_DEBUGCONSOLE_UART; CUSTOM_VGLITE_MEMORY_CONFIG=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT595SFFOC_cm33; MIMXRT595S_cm33_SERIES; BOOT_HEADER_ENABLE=1; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 3
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_flash.icf
  group source
    ../: clock_freertos.c clock_analog.h hour_needle.h minute_needle.h layer.h layer.c vglite_window.h vglite_window.c pin_mux.c pin_mux.h FreeRTOSConfigBoard.h display_support.h display_support.c vglite_support.h vglite_support.c FreeRTOSConfig_Gen.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c hardware_init.c app.h
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group device
    ../../../../../../devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_COMMON.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group device/periph
    ../../../../../../devices/MIMXRT595S/periph/: PERI_ADC.h PERI_AHB_SECURE_CTRL.h PERI_AXI_SWITCH_AMIB.h PERI_AXI_SWITCH_ASIB.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CASPER.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CMP.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUGGER_MAILBOX.h PERI_DMA.h PERI_DMIC.h PERI_FLEXCOMM.h PERI_FLEXIO.h PERI_FLEXSPI.h PERI_FREQME.h PERI_GPIO.h PERI_HASHCRYPT.h PERI_I2C.h PERI_I2S.h PERI_I3C.h PERI_INPUTMUX.h PERI_IOPCTL.h PERI_LCDIF.h PERI_MIPI_DSI_HOST.h PERI_MRT.h PERI_MU.h PERI_OCOTP.h PERI_OSTIMER.h PERI_OTFAD.h PERI_PINT.h PERI_PMC.h PERI_POWERQUAD.h PERI_PUF.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RTC.h PERI_SCT.h PERI_SEMA42.h PERI_SPI.h PERI_SYSCTL0.h PERI_SYSCTL1.h PERI_TRNG.h PERI_USART.h PERI_USBHSD.h PERI_USBHSDCD.h PERI_USBHSH.h PERI_USBPHY.h PERI_USDHC.h PERI_UTICK.h PERI_WWDT.h
  group startup/iar
    ../../../../../../devices/MIMXRT595S/iar/: startup_MIMXRT595S_cm33.s
  group drivers
    ../../../../../../devices/MIMXRT595S/drivers/: fsl_clock.c fsl_clock.h fsl_dsp.c fsl_dsp.h fsl_i2s_bridge.c fsl_i2s_bridge.h fsl_inputmux_connections.h fsl_memory.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_soc_mipi_dsi.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_flexcomm.h fsl_flexcomm.c fsl_usart.h fsl_usart.c fsl_flexio.c fsl_flexio.h fsl_flexio_mculcd_smartdma.c fsl_flexio_mculcd_smartdma.h fsl_flexio_mculcd.c fsl_flexio_mculcd.h fsl_flexspi.c fsl_flexspi.h fsl_iap.h fsl_iap.c fsl_inputmux.h fsl_inputmux.c fsl_lcdif.h fsl_lcdif.c fsl_dma.c fsl_dma.h fsl_gpio.h fsl_gpio.c fsl_iopctl.h fsl_mipi_dsi_smartdma.c fsl_mipi_dsi_smartdma.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_smartdma.h fsl_smartdma.c fsl_smartdma_prv.h fsl_smartdma_rt500.c fsl_smartdma_rt500.h
  group utilities
    ../../../../../../devices/MIMXRT595S/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../../devices/MIMXRT595S/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MIMXRT595S/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group video
    ../../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../../components/video/display/dc/: fsl_dc_fb.h
    ../../../../../../components/video/display/: fsl_display.h
    ../../../../../../components/video/display/fbdev/: fsl_fbdev.h fsl_fbdev.c
    ../../../../../../components/video/display/dbi/: fsl_dbi.h fsl_dbi.c
    ../../../../../../components/video/display/dbi/flexio/: fsl_dbi_flexio_smartdma.h fsl_dbi_flexio_smartdma.c
    ../../../../../../components/video/display/dc/dsi_cmd/: fsl_dc_fb_dsi_cmd.h fsl_dc_fb_dsi_cmd.c
    ../../../../../../components/video/display/dc/lcdif/: fsl_dc_fb_lcdif.h fsl_dc_fb_lcdif.c
    ../../../../../../components/video/display/dc/ssd1963/: fsl_dc_fb_ssd1963.h fsl_dc_fb_ssd1963.c
    ../../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
    ../../../../../../components/video/display/hx8394/: fsl_hx8394.h fsl_hx8394.c
    ../../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../../components/video/display/rm67162/: fsl_rm67162.h fsl_rm67162.c
    ../../../../../../components/video/display/co5300/: fsl_co5300.h fsl_co5300.c
  group lcdc
    ../../../../../../components/display/ssd1963/: fsl_ssd1963.h fsl_ssd1963.c
  group vglite
    ../../../../../../middleware/vglite/driver/: RELEASE_NOTES.txt LICENSE.txt
  group vglite/inc
    ../../../../../../middleware/vglite/driver/inc/: vg_lite.h
  group vglite/VGLite
    ../../../../../../middleware/vglite/driver/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_stroke.c vg_lite_options.h vg_lite_context.h
  group vglite/VGLite/rtos
    ../../../../../../middleware/vglite/driver/VGLite/rtos/: vg_lite_os.c
  group vglite/VGLite/Series/gc555/0x423_ECO
    ../../../../../../middleware/vglite/driver/VGLite/Series/gc555/0x423_ECO/: vg_lite_options.h
  group vglite/VGLite/Series/gc355/0x0_1216
    ../../../../../../middleware/vglite/driver/VGLite/Series/gc355/0x0_1216/: vg_lite_options.h
  group vglite/VGLite/Series/gc255/0x40A
    ../../../../../../middleware/vglite/driver/VGLite/Series/gc255/0x40A/: vg_lite_options.h
  group vglite/VGLiteKernel
    ../../../../../../middleware/vglite/driver/VGLiteKernel/: vg_lite_hal.h vg_lite_hw.h vg_lite_kernel.c vg_lite_kernel.h vg_lite_option.h vg_lite_type.h vg_lite_debug.h
  group vglite/VGLiteKernel/rtos
    ../../../../../../middleware/vglite/driver/VGLiteKernel/rtos/: vg_lite_hal.c vg_lite_platform.h
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/template
    ../../../../../../rtos/freertos/freertos-kernel/template/: FreeRTOSConfig.h
  group doc
    ../: readme.md examples_shared_readme.md
