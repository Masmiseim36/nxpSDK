# IAR project clock_freertos.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT595S_M33 NXP MIMXRT595S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; SDK_DEBUGCONSOLE_UART; VG_BLIT_WORKAROUND=1; MCUXPRESSO_SDK; VG_COMMAND_CALL=1; VG_TARGET_FAST_CLEAR=0; VG_RENDER_TEXT=1; RTOS; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pa092
  ICCARM.CCIncludePath2: ..; ../../vglite_support; ../../vglite_window; ../../../../../devices/MIMXRT595S/drivers; ../../../../../components/ssd1963; ../../../../../components/video/display/dbi; ../../../../../components/video/display/dbi/flexio; ../../../../../components/video/display/dc/ssd1963; ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../middleware/vglite/inc; ../../../../../middleware/vglite/font; ../../../../../middleware/vglite/font/mcufont/decoder; ../../../../../middleware/vglite/VGLite/rtos; ../../../../../middleware/vglite/VGLiteKernel; ../../../../../middleware/vglite/VGLiteKernel/rtos; ../../../../../middleware/vglite/elementary/inc; ../../../../../middleware/vglite/elementary/src; ../../../../../components/video/display/dc/lcdif; ../../../../../components/video/display; ../../../../../components/video/display/rm68191; ../../../../../components/video/display/mipi_dsi_cmd; ../../../../../components/video/display/rm68200; ../../../../../components/video/display/rm67162; ../../../../../components/video/display/dc/dsi_cmd; ../../../../../components/video/display/hx8394; ../../../../../components/video/display/fbdev; ../../../../../components/video; ../../../../../devices/MIMXRT595S; ../../../../../devices/MIMXRT595S/utilities/debug_console; ../../../../../devices/MIMXRT595S/utilities; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../flash_config; ../../../../../components/video/display/dc; ../../../../../rtos/freertos/freertos-kernel/include; ../../../../../CMSIS/Core/Include; ../../../../../devices/MIMXRT595S/utilities/str
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..; ../../../../../rtos/freertos/freertos-kernel/include
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: clock_freertos.out
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT595SFFOC_cm33; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; SDK_DEBUGCONSOLE_UART; VG_BLIT_WORKAROUND=1; MCUXPRESSO_SDK; VG_COMMAND_CALL=1; VG_TARGET_FAST_CLEAR=0; VG_RENDER_TEXT=1; RTOS; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; SDK_DEBUGCONSOLE_UART; VG_BLIT_WORKAROUND=1; MCUXPRESSO_SDK; VG_COMMAND_CALL=1; VG_TARGET_FAST_CLEAR=0; VG_RENDER_TEXT=1; RTOS; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; SDK_DEBUGCONSOLE_UART; VG_BLIT_WORKAROUND=1; MCUXPRESSO_SDK; VG_COMMAND_CALL=1; VG_TARGET_FAST_CLEAR=0; VG_RENDER_TEXT=1; RTOS; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_flash.icf
  group source
    ../: clock_freertos.c clock_analog.h hour_needle.h minute_needle.h FreeRTOSConfig.h
    ../../vglite_window/: vglite_window.h vglite_window.c
  group board
    ../: display_support.h display_support.c pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
    ../../vglite_support/: vglite_support.h vglite_support.c
  group doc
    ../: readme.md
  group drivers
    ../../../../../devices/MIMXRT595S/drivers/: fsl_flexio.c fsl_flexio.h fsl_flexio_mculcd.c fsl_flexio_mculcd.h fsl_dma.c fsl_dma.h fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_power.h fsl_power.c fsl_inputmux.h fsl_inputmux.c fsl_flexio_mculcd_smartdma.c fsl_flexio_mculcd_smartdma.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_lcdif.h fsl_lcdif.c fsl_mipi_dsi_smartdma.c fsl_mipi_dsi_smartdma.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_reset.h fsl_reset.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_inputmux_connections.h fsl_smartdma.h fsl_smartdma.c fsl_smartdma_prv.h fsl_smartdma_rt500.c fsl_smartdma_rt500.h fsl_smartdma_mcxn.c fsl_smartdma_mcxn.h fsl_soc_mipi_dsi.h fsl_iap.h fsl_iap.c
  group lcdc
    ../../../../../components/ssd1963/: fsl_ssd1963.h fsl_ssd1963.c
  group video
    ../../../../../components/video/display/dbi/: fsl_dbi.h fsl_dbi.c
    ../../../../../components/video/display/dbi/flexio/: fsl_dbi_flexio_smartdma.h fsl_dbi_flexio_smartdma.c
    ../../../../../components/video/display/dc/ssd1963/: fsl_dc_fb_ssd1963.h fsl_dc_fb_ssd1963.c
    ../../../../../components/video/display/dc/lcdif/: fsl_dc_fb_lcdif.h fsl_dc_fb_lcdif.c
    ../../../../../components/video/display/: fsl_display.h
    ../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
    ../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../components/video/display/rm67162/: fsl_rm67162.h fsl_rm67162.c
    ../../../../../components/video/display/dc/dsi_cmd/: fsl_dc_fb_dsi_cmd.h fsl_dc_fb_dsi_cmd.c
    ../../../../../components/video/display/hx8394/: fsl_hx8394.h fsl_hx8394.c
    ../../../../../components/video/display/fbdev/: fsl_fbdev.h fsl_fbdev.c
    ../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../components/video/display/dc/: fsl_dc_fb.h
  group freertos/freertos-kernel
    ../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/portable
    ../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos-kernel/include
    ../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group vglite
    ../../../../../middleware/vglite/: ChangeLogKSDK.txt
  group vglite/inc
    ../../../../../middleware/vglite/inc/: vg_lite.h vg_lite_hal.h vg_lite_text.h nxp_support.h
  group vglite/VGLite
    ../../../../../middleware/vglite/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c nxp_support.c vg_lite_flat.h vg_lite_flat.c
  group vglite/VGLite/rtos
    ../../../../../middleware/vglite/VGLite/rtos/: vg_lite_os.h vg_lite_os.c
  group vglite/font
    ../../../../../middleware/vglite/font/: buf_reader.c buf_reader.h fonts.h rle_font_read.c vft_debug.c vft_debug.h vft_draw.c vft_draw.h vg_lite_text.c
  group vglite/font/mcufont
    ../../../../../middleware/vglite/font/mcufont/: LICENSE
  group vglite/font/mcufont/decoder
    ../../../../../middleware/vglite/font/mcufont/decoder/: mcufont.h mf_bwfont.c mf_bwfont.h mf_config.h mf_encoding.c mf_encoding.h mf_font.c mf_font.h mf_justify.c mf_justify.h mf_kerning.c mf_kerning.h mf_rlefont.c mf_rlefont.h mf_scaledfont.c mf_scaledfont.h mf_wordwrap.c mf_wordwrap.h
  group vglite/VGLiteKernel
    ../../../../../middleware/vglite/VGLiteKernel/: vg_lite_hw.h vg_lite_kernel.h vg_lite_kernel.c
  group vglite/VGLiteKernel/rtos
    ../../../../../middleware/vglite/VGLiteKernel/rtos/: vg_lite_hal.c vg_lite_platform.h
  group elementary/inc
    ../../../../../middleware/vglite/elementary/inc/: Elm.h
  group elementary/src
    ../../../../../middleware/vglite/elementary/src/: elm_buffer.c elm_draw.c elm_init.c elm_object.c elm_os.c elm_os.h elm_text.c elm_text.h velm.h elm_headers.h elm_precom.h
  group device
    ../../../../../devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group utilities
    ../../../../../devices/MIMXRT595S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT595S/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../devices/MIMXRT595S/utilities/str/: fsl_str.c fsl_str.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group startup
    ../../../../../devices/MIMXRT595S/iar/: startup_MIMXRT595S_cm33.s
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
