<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>aws_greengrass_discovery_wiced</project>
        <configuration>flash_debug</configuration>
      </member>
      <member>
        <project>aws_greengrass_discovery_wiced</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_debug</name>
      <member>
        <project>aws_greengrass_discovery_wiced</project>
        <configuration>flash_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_release</name>
      <member>
        <project>aws_greengrass_discovery_wiced</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/aws_greengrass_discovery_wiced.ewp</path>
  </project>
</workspace>
