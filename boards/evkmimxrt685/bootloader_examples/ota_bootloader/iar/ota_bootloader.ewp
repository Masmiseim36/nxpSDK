# IAR project ota_bootloader.ewp, settings and files
configuration flexspi_nor_release (ARM)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; BL_TARGET_FLASH; MIMXRT685S
  ICCARM.CCDiagSuppress: Pa082,Pe177,Pe186,Ms014,Pa182
  ICCARM.CCIncludePath2: ../../../../../middleware/mcu-boot/src/bootloader; ../../../../../devices/MIMXRT685S; ../../../../../devices/MIMXRT685S/drivers; ../../../../../middleware/mcu-boot/targets/MIMXRT685S/src; ../../../../../middleware/mcu-boot/components/osa; ../../../../../middleware/mcu-boot/src/crc; ../../../../../middleware/mcu-boot/src/include; ../../../../../middleware/mcu-boot/src/memory; ../../../../../middleware/mcu-boot/src/memory/src; ../../../../../middleware/mcu-boot/src/startup; ../../../../../middleware/mcu-boot/src/packet; ../../../../../middleware/mcu-boot/src/property; ../../../../../middleware/mcu-boot/src/utilities; ../../../../../middleware/mcu-boot/src/drivers/microseconds; ../../../../../components/lists; ../../../../../components/osa; ../../../../../CMSIS/Include; ../../../../../middleware/mcu-boot/src/drivers/flexspi; ../../../../../middleware/mcu-boot/src/drivers/flexspi_nor
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../../../../../middleware/mcu-boot/src/startup
  ILINK.IlinkOutputFile: ota_bootloader.out
  ILINK.IlinkIcfFile: ../../../../../middleware/mcu-boot/targets/common/linker/iar/MIMXRT685S/MIMXRT685S_flash_bootloader.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group doc
    ../: readme.txt
  group source/bootloader
    ../../../../../middleware/mcu-boot/src/bootloader/: bl_reliable_update.h bl_version.h bootloader.h bl_context.h bl_peripheral_interface.h bl_user_entry.h bl_command.h bl_peripheral.h bl_shutdown_cleanup.h bl_app_crc_check.h
  group source/bootloader/src
    ../../../../../middleware/mcu-boot/src/bootloader/src/: bl_reliable_update_common.c bl_context.c bl_exception_handler.c bl_tree_root.c bl_app_crc_check.c
    ../../../../../middleware/mcu-boot/targets/MIMXRT685S/src/: bl_main.c
  group source/crc
    ../../../../../middleware/mcu-boot/src/crc/: crc16.h crc32.h
    ../../../../../middleware/mcu-boot/src/crc/src/: crc16.c crc32.c
  group source/include
    ../../../../../middleware/mcu-boot/src/include/: bootloader_common.h bootloader_core.h
  group source/memory
    ../../../../../middleware/mcu-boot/src/memory/: memory.h
  group source/memory/src
    ../../../../../middleware/mcu-boot/src/memory/src/: sram_init.h memory.c normal_memory.h normal_memory.c pattern_fill.s pattern_fill.h flexspi_nor_memory.c flexspi_nor_memory.h
  group source/packet
    ../../../../../middleware/mcu-boot/src/packet/: command_packet.h serial_packet.h
  group source/property
    ../../../../../middleware/mcu-boot/src/property/: property.h
  group source/property/src
    ../../../../../middleware/mcu-boot/src/property/src/: property_rt685s.c
  group source/utilities
    ../../../../../middleware/mcu-boot/src/utilities/: fsl_rtos_abstraction.h fsl_assert.h vector_table_info.h
  group source/utilities/src
    ../../../../../middleware/mcu-boot/src/utilities/src/: fsl_assert.c fsl_rtos_abstraction.c debug_util.c
  group source/startup
    ../../../../../middleware/mcu-boot/src/startup/: startup.c
  group source/drivers/microseconds
    ../../../../../middleware/mcu-boot/src/drivers/microseconds/: microseconds.h
    ../../../../../middleware/mcu-boot/src/drivers/microseconds/src/: microseconds_sysclk.c
  group source/drivers/flexspi
    ../../../../../middleware/mcu-boot/src/drivers/flexspi/: bl_flexspi.c bl_flexspi.h
  group source/drivers/flexspi_nor
    ../../../../../middleware/mcu-boot/src/drivers/flexspi_nor/: flexspi_nor_flash.c flexspi_nor_flash.h
  group MIMXRT685S
    ../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h
    ../../../../../middleware/mcu-boot/targets/MIMXRT685S/src/: bootloader_config.h bl_clock_config_MIMXRT685S.c hardware_init_MIMXRT685S.c memory_map_MIMXRT685S.c external_memory_property_map_MIMXRT685S.c target_config.h bl_api.h bl_api.c
  group drivers
    ../../../../../devices/MIMXRT685S/drivers/: fsl_clock.h fsl_clock.c fsl_crc.h fsl_crc.c fsl_usart.h fsl_usart.c fsl_common.h fsl_common.c fsl_reset.h fsl_reset.c fsl_flexcomm.h fsl_flexcomm.c
  group device
    ../../../../../devices/MIMXRT685S/: system_MIMXRT685S_cm33.h system_MIMXRT685S_cm33.c
  group startup
    ../../../../../middleware/mcu-boot/targets/MIMXRT685S/src/startup/iar/: startup_MIMXRT685S.s
    ../../../../../middleware/mcu-boot/src/startup/: ar_asm_macros.h
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.c
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm33.h tz_context.h mpu_armv8.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
