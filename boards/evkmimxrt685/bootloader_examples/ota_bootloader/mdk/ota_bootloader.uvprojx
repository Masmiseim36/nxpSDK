# Keil uVision project ota_bootloader.uvprojx, settings and files
target ota_bootloader flexspi_nor_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: IRAM(0x00080000,0x180000) IRAM2(0x00200000,0x280000) XRAM(0x00000000,0x020000) XRAM2(0x00020000,0x060000) XRAM3(0x40140000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: ota_bootloader.out
  AfterMake: fromelf --bincombined -o "$L@L.bin" "#L"
  AfterMake: fromelf --m32combined -o "$L@L.srec" "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, NDEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, BL_TARGET_FLASH, MIMXRT685S
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -Wno-null-dereference  -Wno-unknown-attributes  -Wno-expansion-to-defined  -Wno-invalid-noreturn
  c include: ../../../../../CMSIS/Include;../../../../../middleware/mcu-boot/targets/MIMXRT685S/src;../../../../../middleware/mcu-boot/src/autobaud;../../../../../middleware/mcu-boot/src/drivers/sdmmc/inc;..;../../../../../middleware/mcu-boot/src/bootloader;../../../../../devices/MIMXRT685S;../../../../../devices/MIMXRT685S/drivers;../../../../../middleware/mcu-boot/src/crc;../../../../../middleware/mcu-boot/src/include;../../../../../middleware/mcu-boot/src/startup;../../../../../middleware/mcu-boot/src/utilities;../../../../../middleware/mcu-boot/src/memory;../../../../../middleware/mcu-boot/src/memory/src;../../../../../middleware/mcu-boot/src/property;../../../../../middleware/mcu-boot/src/packet;../../../../../components/osa;../../../../../middleware/mcu-boot/src/drivers/microseconds;../../../../../components/lists;../../../../../middleware/mcu-boot/src/drivers/flexspi;../../../../../middleware/mcu-boot/src/drivers/flexspi_nor
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=0
  asm include: ../../../../../middleware/mcu-boot/src/startup
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685S_flash_bootloader.scf
  link misc: --remove --datacompressor off --entry=Reset_Handler
  group doc
    ../: readme.txt
  group source-bootloader
    ../../../../../middleware/mcu-boot/src/bootloader/: bl_reliable_update.h bl_app_crc_check.h bl_command.h bl_context.h bl_peripheral.h bl_peripheral_interface.h bl_shutdown_cleanup.h bl_user_entry.h bl_version.h bootloader.h
  group source-bootloader-src
    ../../../../../middleware/mcu-boot/src/bootloader/src/: bl_reliable_update_common.c bl_app_crc_check.c bl_context.c bl_exception_handler.c bl_tree_root.c
    ../../../../../middleware/mcu-boot/targets/MIMXRT685S/src/: bl_main.c
  group device
    ../../../../../devices/MIMXRT685S/: MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h fsl_device_registers.h system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group drivers
    ../../../../../devices/MIMXRT685S/drivers/: fsl_clock.c fsl_clock.h fsl_crc.c fsl_crc.h fsl_usart.c fsl_usart.h fsl_common.c fsl_common.h fsl_reset.c fsl_reset.h fsl_flexcomm.c fsl_flexcomm.h
  group startup
    ../../../../../middleware/mcu-boot/targets/MIMXRT685S/src/startup/arm/: startup_MIMXRT685S.s
    ../../../../../middleware/mcu-boot/src/startup/: ar_asm_macros.h startup.c
  group source/utilities
    ../../../../../components/osa/: fsl_os_abstraction.h
  group source-crc
    ../../../../../middleware/mcu-boot/src/crc/: crc16.h crc32.h
    ../../../../../middleware/mcu-boot/src/crc/src/: crc16.c crc32.c
  group source-include
    ../../../../../middleware/mcu-boot/src/include/: bootloader_common.h bootloader_core.h
  group source-memory
    ../../../../../middleware/mcu-boot/src/memory/: memory.h
  group source-memory-src
    ../../../../../middleware/mcu-boot/src/memory/src/: memory.c normal_memory.c normal_memory.h pattern_fill.h pattern_fill_mdk.s sram_init.h flexspi_nor_memory.c flexspi_nor_memory.h
  group source-packet
    ../../../../../middleware/mcu-boot/src/packet/: command_packet.h serial_packet.h
  group source-property
    ../../../../../middleware/mcu-boot/src/property/: property.h
  group source-property-src
    ../../../../../middleware/mcu-boot/src/property/src/: property_rt685s.c
  group source-utilities
    ../../../../../middleware/mcu-boot/src/utilities/: fsl_assert.h fsl_rtos_abstraction.h vector_table_info.h
  group source-utilities-src
    ../../../../../middleware/mcu-boot/src/utilities/src/: debug_util.c fsl_assert.c fsl_rtos_abstraction.c
  group MIMXRT685S
    ../../../../../middleware/mcu-boot/targets/MIMXRT685S/src/: bl_api.c bl_api.h bl_clock_config_MIMXRT685S.c bootloader_config.h external_memory_property_map_MIMXRT685S.c hardware_init_MIMXRT685S.c memory_map_MIMXRT685S.c target_config.h
  group source-drivers-microseconds
    ../../../../../middleware/mcu-boot/src/drivers/microseconds/: microseconds.h
    ../../../../../middleware/mcu-boot/src/drivers/microseconds/src/: microseconds_sysclk.c
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
  group source-drivers-flexspi
    ../../../../../middleware/mcu-boot/src/drivers/flexspi/: bl_flexspi.c bl_flexspi.h
  group source-drivers-flexspi_nor
    ../../../../../middleware/mcu-boot/src/drivers/flexspi_nor/: flexspi_nor_flash.c flexspi_nor_flash.h
