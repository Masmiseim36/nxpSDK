<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>acmp_round_robin</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>acmp_round_robin</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>acmp_round_robin</project>
        <configuration>flash_debug</configuration>
      </member>
      <member>
        <project>acmp_round_robin</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>acmp_round_robin</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>acmp_round_robin</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_debug</name>
      <member>
        <project>acmp_round_robin</project>
        <configuration>flash_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_release</name>
      <member>
        <project>acmp_round_robin</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/acmp_round_robin.ewp</path>
  </project>
</workspace>
