<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>i2s_dma_record_playback_cm33</project>
        <configuration>flash_debug</configuration>
      </member>
      <member>
        <project>i2s_dma_record_playback_cm33</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_debug</name>
      <member>
        <project>i2s_dma_record_playback_cm33</project>
        <configuration>flash_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_release</name>
      <member>
        <project>i2s_dma_record_playback_cm33</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/i2s_dma_record_playback_cm33.ewp</path>
  </project>
</workspace>
