<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>powerquad_benchmark_sw_fft</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>powerquad_benchmark_sw_fft</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>powerquad_benchmark_sw_fft</project>
        <configuration>flash_debug</configuration>
      </member>
      <member>
        <project>powerquad_benchmark_sw_fft</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>powerquad_benchmark_sw_fft</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>powerquad_benchmark_sw_fft</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_debug</name>
      <member>
        <project>powerquad_benchmark_sw_fft</project>
        <configuration>flash_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_release</name>
      <member>
        <project>powerquad_benchmark_sw_fft</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/powerquad_benchmark_sw_fft.ewp</path>
  </project>
</workspace>
