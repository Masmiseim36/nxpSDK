# IAR project powerquad_benchmark_sw_math.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; __FPU_PRESENT=1; __DSP_PRESENT=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MIMXRT685S/utilities/debug_console_lite; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S; ../../../../../../components/uart; ../../../../flash_config; ../../../../../../components/lists; ../../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: powerquad_benchmark_sw_math.out
  ILINK.IlinkConfigDefines: __stack_size__=0x8000
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; __FPU_PRESENT=1; __DSP_PRESENT=1
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; __FPU_PRESENT=1; __DSP_PRESENT=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; __FPU_PRESENT=1; __DSP_PRESENT=1
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
  group CMSIS
    ../../../../../../CMSIS/DSP/Source/TransformFunctions/: arm_bitreversal.c arm_bitreversal2.c arm_cfft_radix2_q31.c arm_cfft_radix2_init_q31.c arm_cfft_radix4_q31.c arm_cfft_radix4_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_init_q15.c arm_cfft_radix4_q15.c arm_cfft_radix4_init_q15.c arm_rfft_q15.c arm_rfft_init_q15.c arm_rfft_q31.c arm_rfft_init_q31.c arm_cfft_q15.c arm_cfft_q31.c arm_dct4_q15.c arm_dct4_init_q15.c arm_dct4_q31.c arm_dct4_init_q31.c
    ../../../../../../CMSIS/DSP/Source/BasicMathFunctions/: arm_mult_q31.c arm_shift_q31.c arm_mult_q15.c arm_shift_q15.c
    ../../../../../../CMSIS/DSP/Source/ComplexMathFunctions/: arm_cmplx_mult_cmplx_q31.c arm_cmplx_mult_cmplx_q15.c
    ../../../../../../CMSIS/DSP/Source/MatrixFunctions/: arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_add_f32.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_sub_f32.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_mult_f32.c arm_mat_inverse_f32.c arm_mat_trans_q15.c arm_mat_trans_q31.c arm_mat_trans_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_scale_f32.c arm_mat_init_f32.c arm_mat_init_q31.c arm_mat_init_q15.c
    ../../../../../../CMSIS/DSP/Source/FastMathFunctions/: arm_sqrt_q15.c arm_sqrt_q31.c arm_sin_q15.c arm_sin_q31.c arm_sin_f32.c arm_cos_q15.c arm_cos_q31.c arm_cos_f32.c
    ../../../../../../CMSIS/DSP/Source/FilteringFunctions/: arm_fir_q15.c arm_fir_init_q15.c arm_fir_q31.c arm_fir_init_q31.c arm_fir_f32.c arm_fir_init_f32.c arm_conv_q15.c arm_conv_q31.c arm_conv_f32.c arm_correlate_q15.c arm_correlate_q31.c arm_correlate_f32.c arm_biquad_cascade_df2T_init_f32.c arm_biquad_cascade_df2T_f32.c
    ../../../../../../CMSIS/DSP/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../../../../../../CMSIS/Include/: core_cm33.h tz_context.h mpu_armv8.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group source
    ../: powerquad_benchmark_sw_math.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../../devices/MIMXRT685S/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../devices/MIMXRT685S/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_power.h fsl_power.c fsl_gpio.h fsl_gpio.c fsl_inputmux.h fsl_inputmux.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_reset.h fsl_reset.c fsl_inputmux_connections.h
  group MIMXRT685S
    ../../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group MIMXRT685S/iar
    ../../../../../../devices/MIMXRT685S/iar/: startup_MIMXRT685S_cm33.s
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
