<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>flexcomm_spi_polling_b2b_transfer_slave_cm33</project>
        <configuration>flash_debug</configuration>
      </member>
      <member>
        <project>flexcomm_spi_polling_b2b_transfer_slave_cm33</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_debug</name>
      <member>
        <project>flexcomm_spi_polling_b2b_transfer_slave_cm33</project>
        <configuration>flash_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_release</name>
      <member>
        <project>flexcomm_spi_polling_b2b_transfer_slave_cm33</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/flexcomm_spi_polling_b2b_transfer_slave_cm33.ewp</path>
  </project>
</workspace>
