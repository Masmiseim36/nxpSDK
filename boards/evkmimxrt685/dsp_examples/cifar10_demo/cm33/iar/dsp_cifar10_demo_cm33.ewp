# IAR project dsp_cifar10_demo_cm33.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; DSP_IMAGE_COPY_TO_RAM=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; PRINTF_ADVANCED_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SCANF_ADVANCED_ENABLE=1; SCANF_FLOAT_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../lenet_demo/cm33; ..; ../../../..; ../../..; ../glow_bundle; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../rtos/freertos/freertos_kernel/include; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../middleware/multicore/rpmsg_lite/lib/include; ../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imxrt600_m33; ../../../../../../components/pca9420; ../../../../../../devices/MIMXRT685S; ../../../../../../devices/MIMXRT685S/utilities/str; ../../../../../../devices/MIMXRT685S/utilities/debug_console; ../../../../../../components/uart; ../../../../flash_config; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../devices/MIMXRT685S/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; DSP_IMAGE_COPY_TO_RAM=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; PRINTF_ADVANCED_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SCANF_ADVANCED_ENABLE=1; SCANF_FLOAT_ENABLE=1
  AARM.AUserIncludes: ../../../..; ../../dsp/binary; ..
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: dsp_cifar10_demo_cm33.out
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_ram.icf
  ILINK.IlinkExtraOptions: --diag_suppress=Lt009; --image_input=../../dsp/binary/dsp_text_release.bin,__dsp_text_bin,__dsp_text_section,4; --keep=__dsp_text_bin; --image_input=../../dsp/binary/dsp_data_release.bin,__dsp_data_bin,__dsp_data_section,4; --keep=__dsp_data_bin; --image_input=../../test/input.bin,__input_bin,__input_section,4; --keep=__input_bin; --image_input=../../test/output.bin,__output_bin,__output_section,4; --keep=__output_bin; --image_input=../glow_bundle/cifar10.weights.bin,__weights_bin,__weights_section,64; --keep=__weights_bin
  ILINK.IlinkAdditionalLibs: ../../../../../../devices/MIMXRT685S/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; DSP_IMAGE_COPY_TO_RAM=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; PRINTF_ADVANCED_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SCANF_ADVANCED_ENABLE=1; SCANF_FLOAT_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; DSP_IMAGE_COPY_TO_RAM=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; PRINTF_ADVANCED_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SCANF_ADVANCED_ENABLE=1; SCANF_FLOAT_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; DSP_IMAGE_COPY_TO_RAM=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; PRINTF_ADVANCED_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SCANF_ADVANCED_ENABLE=1; SCANF_FLOAT_ENABLE=1
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; DSP_IMAGE_COPY_TO_RAM=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; PRINTF_ADVANCED_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SCANF_ADVANCED_ENABLE=1; SCANF_FLOAT_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: DSP_IMAGE_COPY_TO_RAM=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; PRINTF_ADVANCED_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SCANF_ADVANCED_ENABLE=1; SCANF_FLOAT_ENABLE=1
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
  group source
    ../: main_cm33.c dsp_config.h srtm_config.h srtm_config_audio.h srtm_config_nn.h rpmsg_config.h FreeRTOSConfig.h
  group test
    ../../test/: input.bin output.bin
  group board
    ../: counter.c counter.h pin_mux.c pin_mux.h dsp_support.c dsp_support.h dsp_ipc.c dsp_ipc.h dsp_nn_utils.c dsp_nn_utils.h pmic_support.c pmic_support.h board.c board.h clock_config.c clock_config.h
  group nn
    ../: dsp_nn.c dsp_nn.h config_nn.h
  group glow_utils
    ../: glow_bundle_utils.h glow_bundle_utils.c
  group glow_bundle
    ../glow_bundle/: cifar10.h cifar10.o cifar10.weights.bin cifar10.weights.txt
  group doc
    ../: readme.txt
  group .
    ../../dsp/binary/: dsp_text_release.bin dsp_data_release.bin
  group drivers
    ../../../../../../devices/MIMXRT685S/drivers/: fsl_clock.c fsl_clock.h fsl_i2c.c fsl_i2c.h fsl_i3c.c fsl_i3c.h fsl_dma.c fsl_dma.h fsl_common.c fsl_common.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_dsp.c fsl_dsp.h fsl_inputmux.c fsl_inputmux.h fsl_mu.c fsl_mu.h fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_iopctl.h fsl_gpio.c fsl_gpio.h fsl_inputmux_connections.h
  group rpmsg_lite
    ../../../../../../middleware/multicore/rpmsg_lite/lib/common/: llist.c
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/: llist.h rpmsg_compiler.h rpmsg_default_config.h rpmsg_lite.h rpmsg_ns.h virtio_ring.h virtqueue.h
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c
    ../../../../../../middleware/multicore/rpmsg_lite/lib/virtio/: virtqueue.c
  group rpmsg_lite/env/freertos
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_env.h rpmsg_queue.h
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_freertos.c
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_queue.c
  group rpmsg_lite/porting
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imxrt600_m33/: rpmsg_platform.h
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/platform/imxrt600_m33/: rpmsg_platform.c
  group freertos/freertos_kernel
    ../../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.h portasm.s portmacro.h
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos_kernel/include
    ../../../../../../rtos/freertos/freertos_kernel/include/: FreeRTOS.h StackMacros.h atomic.h croutine.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group pmic_driver
    ../../../../../../components/pca9420/: fsl_pca9420.c fsl_pca9420.h
  group device
    ../../../../../../devices/MIMXRT685S/: MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h fsl_device_registers.h system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group utilities
    ../../../../../../devices/MIMXRT685S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT685S/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../components/uart/: uart.h usart_adapter.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group startup
    ../../../../../../devices/MIMXRT685S/iar/: startup_MIMXRT685S_cm33.s
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
