# IAR project dsp_xaf_demo_cm33.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DSP_IMAGE_COPY_TO_RAM=0; DEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; XA_MP3_DECODER=1; XA_AAC_DECODER=1; XA_VORBIS_DECODER=1; XA_OPUS_ENCODER=1; XA_OPUS_DECODER=1; XA_SBC_ENCODER=1; XA_SBC_DECODER=0; XA_PCM_GAIN=1; XA_SRC_PP_FX=1; XA_RENDERER=1; XA_CAPTURER=1; I2S_SUPPORT_44100_HZ=0; DSP_NCACHE; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8904_ENABLE; DEBUG_CONSOLE_RX_ENABLE=0; SD_ENABLED; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ..; ../../../..; ../../..; ../../../../../src/dsp_examples/xaf_demo/resources; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../rtos/freertos/freertos_kernel/include; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../components/codec/wm8904; ../../../../../../middleware/multicore/rpmsg_lite/lib/include; ../../../../../../devices/MIMXRT685S/utilities; ../../../../../../components/codec; ../../../../../../components/codec/port/wm8904; ../../../../../../components/codec/i2c; ../../../../../../components/i2c; ../../../../../../middleware/sdmmc/sd; ../../../../../../middleware/sdmmc/common; ../../../../../../middleware/sdmmc/host/usdhc; ../../../../../../middleware/fatfs/source; ../../../../../../middleware/fatfs/source/fsl_sd_disk; ../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imxrt600_m33; ../../../../../../components/pca9420; ../../../../../../devices/MIMXRT685S; ../../../../../../devices/MIMXRT685S/utilities/str; ../../../../../../devices/MIMXRT685S/utilities/debug_console; ../../../../../../components/uart; ../../../../flash_config; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../middleware/sdmmc/osa; ../../../../../../components/osa
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DSP_IMAGE_COPY_TO_RAM=0; DEBUG
  AARM.AUserIncludes: ../../../..; ../../dsp/binary; ..
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: dsp_xaf_demo_cm33.out
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_ram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../devices/MIMXRT685S/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DSP_IMAGE_COPY_TO_RAM=0; DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; XA_MP3_DECODER=1; XA_AAC_DECODER=1; XA_VORBIS_DECODER=1; XA_OPUS_ENCODER=1; XA_OPUS_DECODER=1; XA_SBC_ENCODER=1; XA_SBC_DECODER=0; XA_PCM_GAIN=1; XA_SRC_PP_FX=1; XA_RENDERER=1; XA_CAPTURER=1; I2S_SUPPORT_44100_HZ=0; DSP_NCACHE; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8904_ENABLE; DEBUG_CONSOLE_RX_ENABLE=0; SD_ENABLED; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DSP_IMAGE_COPY_TO_RAM=1; XA_VORBIS_DECODER=0; XA_OPUS_ENCODER=0; XA_OPUS_DECODER=0; XA_SBC_ENCODER=0; NDEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; XA_MP3_DECODER=1; XA_AAC_DECODER=1; XA_SBC_DECODER=0; XA_PCM_GAIN=1; XA_SRC_PP_FX=1; XA_RENDERER=1; XA_CAPTURER=1; I2S_SUPPORT_44100_HZ=0; DSP_NCACHE; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8904_ENABLE; DEBUG_CONSOLE_RX_ENABLE=0; SD_ENABLED; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: DSP_IMAGE_COPY_TO_RAM=1; NDEBUG
  ILINK.IlinkExtraOptions: --image_input=../../dsp/binary/dsp_text_release.bin,__dsp_text_bin,__dsp_text_section,4; --keep=__dsp_text_bin; --image_input=../../dsp/binary/dsp_data_release.bin,__dsp_data_bin,__dsp_data_section,4; --keep=__dsp_data_bin; --image_input=../../dsp/binary/dsp_ncache_release.bin,__dsp_ncache_bin,__dsp_ncache_section,4; --keep=__dsp_ncache_bin
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DSP_IMAGE_COPY_TO_RAM=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; XA_MP3_DECODER=1; XA_AAC_DECODER=1; XA_VORBIS_DECODER=1; XA_OPUS_ENCODER=1; XA_OPUS_DECODER=1; XA_SBC_ENCODER=1; XA_SBC_DECODER=0; XA_PCM_GAIN=1; XA_SRC_PP_FX=1; XA_RENDERER=1; XA_CAPTURER=1; I2S_SUPPORT_44100_HZ=0; DSP_NCACHE; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8904_ENABLE; DEBUG_CONSOLE_RX_ENABLE=0; SD_ENABLED; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: DSP_IMAGE_COPY_TO_RAM=1
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
  ILINK.IlinkExtraOptions: as above
  group source
    ../: main_cm33.c main_cm33.h cmd.c cmd.h ffconf.h dsp_config.h srtm_config.h srtm_config_audio.h srtm_config_nn.h rpmsg_config.h FreeRTOSConfig.h
  group resources
    ../: sine.pcm.h hihat_dec_out.pcm.h hihat.mp3.h hihat_48k.mp3.h hihat.ogg.h hihat_trim.pcm.h hihat_trim.sbc.h hihat_vorbis_dec_out_trim.pcm.h i9_trim_pcm.h i9_vor.h sbc_test_02_trim.sbc.h sbc_test_02_trim.out.h testvector04-48000-2ch-ogg-opus_trim.out.h testvector04.bit.opus.h testvector04-48000-2ch_trim.out.h testvector04.bit.h testvector11-16000-1ch_trim.out.h testvector11-16kHz-1ch-20kbps_trim.bit.h aac.adts.h aac.ref.h
  group board
    ../: pin_mux.c pin_mux.h dsp_support.c dsp_support.h dsp_ipc.c dsp_ipc.h pmic_support.c pmic_support.h board.c board.h clock_config.c clock_config.h
    ../../../../: sdmmc_config.c sdmmc_config.h
  group doc
    ../: readme.txt
  group .
    ../../dsp/binary/: dsp_text_release.bin dsp_data_release.bin dsp_ncache_release.bin
  group drivers
    ../../../../../../devices/MIMXRT685S/drivers/: fsl_clock.c fsl_clock.h fsl_i2c.c fsl_i2c.h fsl_i3c.c fsl_i3c.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_usdhc.c fsl_usdhc.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_dsp.c fsl_dsp.h fsl_inputmux.c fsl_inputmux.h fsl_mu.c fsl_mu.h fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_iopctl.h fsl_inputmux_connections.h
  group codec
    ../../../../../../components/codec/wm8904/: fsl_wm8904.c fsl_wm8904.h
    ../../../../../../components/codec/: fsl_codec_common.c fsl_codec_common.h
    ../../../../../../components/codec/port/wm8904/: fsl_codec_adapter.c fsl_codec_adapter.h
    ../../../../../../components/codec/i2c/: fsl_codec_i2c.c fsl_codec_i2c.h
  group rpmsg_lite
    ../../../../../../middleware/multicore/rpmsg_lite/lib/common/: llist.c
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/: llist.h rpmsg_compiler.h rpmsg_default_config.h rpmsg_lite.h rpmsg_ns.h virtio_ring.h virtqueue.h
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c
    ../../../../../../middleware/multicore/rpmsg_lite/lib/virtio/: virtqueue.c
  group rpmsg_lite/env/freertos
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_env.h rpmsg_queue.h
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_freertos.c
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_queue.c
  group rpmsg_lite/porting
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imxrt600_m33/: rpmsg_platform.h
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/platform/imxrt600_m33/: rpmsg_platform.c
  group freertos/freertos_kernel
    ../../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.h portasm.s portmacro.h
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos_kernel/include
    ../../../../../../rtos/freertos/freertos_kernel/include/: FreeRTOS.h StackMacros.h atomic.h croutine.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group utilities
    ../../../../../../devices/MIMXRT685S/utilities/: fsl_shell.c fsl_shell.h fsl_assert.c
    ../../../../../../devices/MIMXRT685S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
  group component/i2c
    ../../../../../../components/i2c/: i2c.h i3c_adapter.c
  group component/uart
    ../../../../../../components/uart/: uart.h usart_adapter.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction_free_rtos.h
  group sdmmc
    ../../../../../../middleware/sdmmc/sd/: ChangeLogKSDK.txt
  group sdmmc/src
    ../../../../../../middleware/sdmmc/sd/: fsl_sd.c
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../../middleware/sdmmc/sd/: fsl_sd.h
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.h fsl_sdmmc_spec.h
  group sdmmc/host
    ../../../../../../middleware/sdmmc/host/usdhc/: ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h
    ../../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group sdmmc/osa
    ../../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.c fsl_sdmmc_osa.h
  group fatfs/source
    ../../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_sd_disk
    ../../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group pmic_driver
    ../../../../../../components/pca9420/: fsl_pca9420.c fsl_pca9420.h
  group device
    ../../../../../../devices/MIMXRT685S/: MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h fsl_device_registers.h system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group startup
    ../../../../../../devices/MIMXRT685S/iar/: startup_MIMXRT685S_cm33.s
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
