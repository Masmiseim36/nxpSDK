<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>peripheral_pxr</project>
        <configuration>flash_debug</configuration>
      </member>
      <member>
        <project>peripheral_pxr</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_debug</name>
      <member>
        <project>peripheral_pxr</project>
        <configuration>flash_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_release</name>
      <member>
        <project>peripheral_pxr</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/peripheral_pxr.ewp</path>
  </project>
</workspace>
