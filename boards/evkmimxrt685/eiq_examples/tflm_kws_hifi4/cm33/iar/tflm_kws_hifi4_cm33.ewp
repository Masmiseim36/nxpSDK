# IAR project tflm_kws_hifi4_cm33.ewp, settings and files
configuration flash_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; DSP_IMAGE_COPY_TO_RAM=1; SDK_DEBUGCONSOLE_UART; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8904_ENABLE
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../components/i2c; ../../../../../../components/codec/i2c; ../../../../../../components/codec/port/wm8904; ../../../../../../components/codec/port; ../../../../../../components/codec; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../components/codec/wm8904; ../../../../../../components/lists; ../../../../../../components/uart; ../../../../../../devices/MIMXRT685S; ../../../../flash_config; ../../../../../../components/pca9420; ../../../../../../devices/MIMXRT685S/utilities/str; ../../../../../../devices/MIMXRT685S/utilities/debug_console_lite; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; DSP_IMAGE_COPY_TO_RAM=1
  AARM.AUserIncludes: ../../hifi4/binary
  ILINK.IlinkOutputFile: tflm_kws_hifi4_cm33.out
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
  ILINK.IlinkExtraOptions: --image_input=../../hifi4/binary/dsp_text_release.bin,__dsp_text_bin,__dsp_text_section,4; --keep=__dsp_text_bin; --image_input=../../hifi4/binary/dsp_data_release.bin,__dsp_data_bin,__dsp_data_section,4; --keep=__dsp_data_bin
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; DSP_IMAGE_COPY_TO_RAM=1; SDK_DEBUGCONSOLE_UART; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8904_ENABLE
  ICCARM.CCOptLevel: 3
  AARM.ADefines: DSP_IMAGE_COPY_TO_RAM=1
  group dsp_binary
    ../../hifi4/binary/: dsp_text_release.bin dsp_data_release.bin
  group board
    ../: board.c board.h clock_config.c clock_config.h dsp_support.c dsp_support.h pmic_support.c pmic_support.h pin_mux.c pin_mux.h board_init.c board_init.h
  group source
    ../: dsp_config.h main.c
  group doc
    ../: readme.txt
  group component/i2c
    ../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_i3c.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group codec
    ../../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
    ../../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../../components/codec/wm8904/: fsl_wm8904.h fsl_wm8904.c
  group codec/port
    ../../../../../../components/codec/port/: fsl_codec_adapter.h
  group codec/port/wm8904
    ../../../../../../components/codec/port/wm8904/: fsl_codec_wm8904_adapter.c fsl_codec_wm8904_adapter.h
  group drivers
    ../../../../../../devices/MIMXRT685S/drivers/: fsl_i2c.h fsl_i2c.c fsl_i3c.h fsl_i3c.c fsl_usart.h fsl_usart.c fsl_cache.c fsl_cache.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_dsp.h fsl_dsp.c fsl_flexcomm.h fsl_flexcomm.c fsl_flexspi.c fsl_flexspi.h fsl_inputmux.h fsl_inputmux.c fsl_gpio.h fsl_gpio.c fsl_iopctl.h fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_inputmux_connections.h
  group device
    ../../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h
  group MIMXRT685S
    ../../../../../../devices/MIMXRT685S/: system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group MIMXRT685S/iar
    ../../../../../../devices/MIMXRT685S/iar/: startup_MIMXRT685S_cm33.s
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group pmic_driver
    ../../../../../../components/pca9420/: fsl_pca9420.h fsl_pca9420.c
  group utilities
    ../../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT685S/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
