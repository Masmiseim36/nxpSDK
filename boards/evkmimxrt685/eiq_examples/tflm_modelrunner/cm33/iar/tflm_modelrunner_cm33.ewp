# IAR project tflm_modelrunner_cm33.ewp, settings and files
configuration flash_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; MODEL_SIZE=1024*1024; PRINTF_ADVANCED_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SDK_DEBUGCONSOLE_UART; ARM_MATH_CM33; __FPU_PRESENT=1; TF_LITE_STATIC_MEMORY; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Go003,Pa050,Pa082,Pa084,Pa093,Pe069,Pe111,Pe161,Pe174,Pe177,Pe186,Pe188,Pe550,Pe611,Pe997,Pe1444,Pe1675,Pa082,Pa050
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.CCIncludePath2: ../source; ../../../../../../middleware/eiq/common; ..; ../../../../../../devices/MIMXRT685S/utilities/str; ../../../../../../devices/MIMXRT685S/utilities/debug_console_lite; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../middleware/eiq/tensorflow-lite; ../../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include; ../../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp; ../../../../../../components/lists; ../../../../../../components/uart; ../../../../../../devices/MIMXRT685S; ../../../../flash_config; ../../../../../../middleware/eiq/tensorflow-lite/third_party/ruy; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../source
  ILINK.IlinkOutputFile: tflm_modelrunner_cm33.out
  ILINK.IlinkConfigDefines: __stack_size__=0x17000; __heap_size__=0x160000; __stack_size__=0x2000
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../middleware/eiq/tensorflow-lite/lib/cm33/iar/tflm.lib
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; MODEL_SIZE=1024*1024; PRINTF_ADVANCED_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SDK_DEBUGCONSOLE_UART; ARM_MATH_CM33; __FPU_PRESENT=1; TF_LITE_STATIC_MEMORY; MCUXPRESSO_SDK
  group source
    ../source/: main.cpp modelrunner.h modelrunner.cpp tf_benchmark.h tf_benchmark.cpp json_results.cpp timer.h timer.c app.h
  group source/cJSON
    ../source/cJSON/: cJSON.h cJSON.c
  group source/base64
    ../source/base64/: base64.h base64.c
  group scripts
    ../scripts/: cli.py main.py modelrunner.py xexpect.py requirements.txt
  group board
    ../: flash_opts.h flash_opts.c clock_config.c clock_config.h pin_mux.h pin_mux.c clock_config.h clock_config.c board.c board.h
    ./: retarget.c
  group utilities
    ../../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT685S/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c fsl_assert.h
  group drivers
    ../../../../../../devices/MIMXRT685S/drivers/: fsl_iap.h fsl_iap.c fsl_wwdt.h fsl_wwdt.c fsl_usart.h fsl_usart.c fsl_cache.c fsl_cache.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_flexcomm.h fsl_flexcomm.c fsl_flexspi.c fsl_flexspi.h fsl_gpio.h fsl_gpio.c fsl_iopctl.h fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c
  group eiq/tensorflow-lite
    ../../../../../../middleware/eiq/tensorflow-lite/: AUTHORS LICENSE NOTICE ChangeLogKSDK.txt readme.txt
  group eiq/tensorflow-lite/tensorflow/lite
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/: builtin_op_data.h builtin_ops.h context_util.h portable_type_to_tflitetype.h
  group eiq/tensorflow-lite/tensorflow/lite/micro
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/: debug_log.cpp compatibility.h debug_log.h fake_micro_context.h flatbuffer_utils.h memory_helpers.h micro_allocation_info.h micro_allocator.h micro_arena_constants.h micro_common.h micro_context.h micro_graph.h micro_interpreter.h micro_interpreter_context.h micro_interpreter_graph.h micro_log.h micro_mutable_op_resolver.h micro_op_resolver.h micro_profiler.h micro_profiler_interface.h micro_resource_variable.h micro_time.h micro_utils.h mock_micro_graph.h recording_micro_allocator.h recording_micro_interpreter.h system_setup.h test_helper_custom_ops.h test_helpers.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/: activation_utils.h activations.h add.h circular_buffer.h circular_buffer_flexbuffers_generated_data.h conv.h conv_test.h depthwise_conv.h dequantize.h detection_postprocess_flexbuffers_generated_data.h ethosu.h fully_connected.h hard_swish.h kernel_runner.h kernel_util.h leaky_relu.h logical.h logistic.h lstm_eval.h lstm_eval_test.h lstm_shared.h micro_ops.h micro_tensor_utils.h mul.h pad.h pooling.h prelu.h quantize.h reduce.h reshape.h softmax.h strided_slice.h sub.h svdf.h unidirectional_sequence_lstm.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/arena_allocator
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/arena_allocator/: ibuffer_allocator.h non_persistent_arena_buffer_allocator.h persistent_arena_buffer_allocator.h recording_single_arena_buffer_allocator.h single_arena_buffer_allocator.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/memory_planner
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.h linear_memory_planner.h memory_plan_struct.h micro_memory_planner.h non_persistent_buffer_planner_shim.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/tflite_bridge
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/tflite_bridge/: flatbuffer_conversions_bridge.h micro_error_reporter.h
  group eiq/tensorflow-lite/tensorflow/lite/c
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/c/: builtin_op_data.h c_api_types.h common.h
  group eiq/tensorflow-lite/tensorflow/lite/core
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/: macros.h
  group eiq/tensorflow-lite/tensorflow/lite/core/api
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/api/: error_reporter.h flatbuffer_conversions.h tensor_utils.h
  group eiq/tensorflow-lite/tensorflow/lite/core/c
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/c/: builtin_op_data.h c_api_types.h common.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/: kernel_util.h op_macros.h padding.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/: common.h compatibility.h cppmath.h max.h min.h portable_tensor.h portable_tensor_utils.h quantization_util.h runtime_shape.h strided_slice_logic.h tensor_ctypes.h types.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized/: neon_check.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/: add.h add_n.h arg_min_max.h batch_matmul.h batch_to_space_nd.h binary_function.h broadcast_args.h broadcast_to.h ceil.h comparisons.h concatenation.h conv.h cumsum.h depth_to_space.h depthwiseconv_float.h depthwiseconv_uint8.h dequantize.h div.h elu.h exp.h fill.h floor.h floor_div.h floor_mod.h fully_connected.h hard_swish.h l2normalization.h leaky_relu.h log_softmax.h logistic.h lstm_cell.h maximum_minimum.h mul.h neg.h pad.h pooling.h portable_tensor_utils.h portable_tensor_utils_impl.h prelu.h process_broadcast_shapes.h quantize.h reduce.h requantize.h resize_bilinear.h resize_nearest_neighbor.h round.h select.h slice.h softmax.h space_to_batch_nd.h space_to_depth.h strided_slice.h sub.h tanh.h transpose.h transpose_conv.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops/: add.h conv.h depthwise_conv.h fully_connected.h l2normalization.h logistic.h mean.h mul.h pooling.h tanh.h transpose_conv.h
  group eiq/tensorflow-lite/tensorflow/lite/schema
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/schema/: schema_generated.h schema_utils.h
  group eiq/tensorflow-lite/signal/micro/kernels
    ../../../../../../middleware/eiq/tensorflow-lite/signal/micro/kernels/: delay_flexbuffers_generated_data.h energy_flexbuffers_generated_data.h fft_flexbuffers_generated_data.h filter_bank_flexbuffers_generated_data.h filter_bank_log_flexbuffers_generated_data.h filter_bank_spectral_subtraction_flexbuffers_generated_data.h framer_flexbuffers_generated_data.h irfft.h overlap_add_flexbuffers_generated_data.h pcan_flexbuffers_generated_data.h rfft.h stacker_flexbuffers_generated_data.h window_flexbuffers_generated_data.h
  group eiq/tensorflow-lite/signal/src
    ../../../../../../middleware/eiq/tensorflow-lite/signal/src/: circular_buffer.h complex.h energy.h fft_auto_scale.h filter_bank.h filter_bank_log.h filter_bank_spectral_subtraction.h filter_bank_square_root.h irfft.h log.h max_abs.h msb.h overlap_add.h pcan_argc_fixed.h rfft.h square_root.h window.h
  group eiq/tensorflow-lite/signal/src/kiss_fft_wrappers
    ../../../../../../middleware/eiq/tensorflow-lite/signal/src/kiss_fft_wrappers/: kiss_fft_common.h kiss_fft_float.h kiss_fft_int16.h kiss_fft_int32.h
  group eiq/tensorflow-lite/third_party/flatbuffers
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/: readme.md LICENSE.txt
  group eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/: allocator.h array.h base.h buffer.h buffer_ref.h default_allocator.h detached_buffer.h flatbuffer_builder.h flatbuffers.h flexbuffers.h stl_emulation.h strings.h struct.h table.h util.h vector.h vector_downward.h verifier.h
  group eiq/tensorflow-lite/third_party/gemmlowp
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/: LICENSE README.md
  group eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint/: fixedpoint.h fixedpoint_neon.h fixedpoint_sse.h
  group eiq/tensorflow-lite/third_party/gemmlowp/internal
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/internal/: detect_platform.h
  group eiq/tensorflow-lite/third_party/ruy
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/: LICENSE README.md
  group eiq/tensorflow-lite/third_party/ruy/ruy/profiler
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/ruy/profiler/: instrumentation.h
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group device
    ../../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h
  group MIMXRT685S
    ../../../../../../devices/MIMXRT685S/: system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group MIMXRT685S/iar
    ../../../../../../devices/MIMXRT685S/iar/: startup_MIMXRT685S_cm33.s
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group doc
    ../: readme.md
