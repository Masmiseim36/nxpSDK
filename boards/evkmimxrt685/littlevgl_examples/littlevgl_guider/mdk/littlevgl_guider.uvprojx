# Keil uVision project littlevgl_guider.uvprojx, settings and files
target littlevgl_guider debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: littlevgl_guider.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, LV_CONF_INCLUDE_SIMPLE=1, LV_EX_CONF_INCLUDE_SIMPLE=1, SERIAL_PORT_TYPE_UART=1, SDK_OS_FREE_RTOS, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../..;..;../generated;../custom;../generated/guider_customer_fonts;../generated/guider_fonts;../../../../../components/ili9341;../../../../../components/ft6x06;../../../../../devices/MIMXRT685S/drivers;../../../../../devices/MIMXRT685S/cmsis_drivers;../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM33_NTZ/non_secure;../../../../../middleware/littlevgl/lvgl;../../../../../middleware/littlevgl/lvgl/src;../../../../../middleware/littlevgl;../../../../../devices/MIMXRT685S;../../../../../devices/MIMXRT685S/utilities/str;../../../../../devices/MIMXRT685S/utilities/debug_console;../../../../../components/uart;../../../flash_config;../../../../../components/serial_manager;../../../../../components/lists;../../../../../CMSIS/Core/Include;../../../../../CMSIS/Driver/Include;../../../../../rtos/freertos/freertos_kernel/include
  asm define: DEBUG
  asm include: ..
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_ram.scf
  link misc: --remove --entry=Reset_Handler
  group board
    ../../: RTE_Device.h littlevgl_support.h littlevgl_support.c
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source
    ../: littlevgl_guider.c FreeRTOSConfig.h lv_conf.h
  group generated/images
    ../generated/images/: images.c
  group generated/guider_fonts
    ../generated/guider_fonts/: guider_fonts.h
  group generated/guider_customer_fonts
    ../generated/guider_customer_fonts/: guider_customer_fonts.h
  group generated
    ../generated/: gui_guider.c gui_guider.h events_init.c events_init.h
  group custom
    ../custom/: custom.c custom.h
  group doc
    ../: readme.txt
  group lcd
    ../../../../../components/ili9341/: fsl_ili9341.h fsl_ili9341.c
  group touchpanel
    ../../../../../components/ft6x06/: fsl_ft6x06.h fsl_ft6x06.c
  group drivers
    ../../../../../devices/MIMXRT685S/drivers/: fsl_clock.h fsl_clock.c fsl_spi_dma.c fsl_spi_dma.h fsl_i2c.h fsl_i2c.c fsl_spi.c fsl_spi.h fsl_inputmux.h fsl_inputmux.c fsl_inputmux_connections.h fsl_i2c_dma.c fsl_i2c_dma.h fsl_dma.c fsl_dma.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_power.h fsl_power.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c
    ../../../../../devices/MIMXRT685S/cmsis_drivers/: fsl_spi_cmsis.h fsl_spi_cmsis.c fsl_i2c_cmsis.h fsl_i2c_cmsis.c
  group freertos/freertos_kernel/portable/GCC/ARM_CM33_NTZ/non_secure
    ../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c portasm.h portmacro.h
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group littlevgl/lvgl
    ../../../../../middleware/littlevgl/lvgl/: lvgl.h
  group littlevgl/lvgl/src
    ../../../../../middleware/littlevgl/lvgl/src/: lv_conf_kconfig.h lv_api_map.h lv_conf_internal.h
  group littlevgl/lvgl/src/lv_core
    ../../../../../middleware/littlevgl/lvgl/src/lv_core/: lv_disp.c lv_disp.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_obj.c lv_obj.h lv_obj_style_dec.h lv_refr.c lv_refr.h lv_style.c lv_style.h
  group littlevgl/lvgl/src/lv_draw
    ../../../../../middleware/littlevgl/lvgl/src/lv_draw/: lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_blend.c lv_draw_blend.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
  group littlevgl/lvgl/src/lv_font
    ../../../../../middleware/littlevgl/lvgl/src/lv_font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_loader.c lv_font_loader.h lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c lv_symbol_def.h
  group littlevgl/lvgl/src/lv_gpu
    ../../../../../middleware/littlevgl/lvgl/src/lv_gpu/: lv_gpu_stm32_dma2d.h lv_gpu_nxp_pxp.h lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.h lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_vglite.h lv_gpu_nxp_vglite.c
  group littlevgl/lvgl/src/lv_hal
    ../../../../../middleware/littlevgl/lvgl/src/lv_hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group littlevgl/lvgl/src/lv_misc
    ../../../../../middleware/littlevgl/lvgl/src/lv_misc/: lv_anim.c lv_anim.h lv_area.c lv_area.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_debug.c lv_debug.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_task.c lv_task.h lv_templ.c lv_templ.h lv_txt.c lv_txt.h lv_txt_ap.c lv_txt_ap.h lv_types.h lv_utils.c lv_utils.h
  group littlevgl/lvgl/src/lv_themes
    ../../../../../middleware/littlevgl/lvgl/src/lv_themes/: lv_theme.c lv_theme.h lv_theme_empty.c lv_theme_empty.h lv_theme_material.c lv_theme_material.h lv_theme_mono.c lv_theme_mono.h lv_theme_template.c lv_theme_template.h
  group littlevgl/lvgl/src/lv_widgets
    ../../../../../middleware/littlevgl/lvgl/src/lv_widgets/: lv_anim_img.c lv_anim_img.h lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnmatrix.c lv_btnmatrix.h lv_calendar.c lv_calendar.h lv_canvas.c lv_canvas.h lv_chart.c lv_chart.h lv_checkbox.c lv_checkbox.h lv_cont.c lv_cont.h lv_cpicker.c lv_cpicker.h lv_dropdown.c lv_dropdown.h lv_gauge.c lv_gauge.h lv_img.c lv_img.h lv_imgbtn.c lv_imgbtn.h lv_keyboard.c lv_keyboard.h lv_label.c lv_label.h lv_led.c lv_led.h lv_line.c lv_line.h lv_linemeter.c lv_linemeter.h lv_list.c lv_list.h lv_msgbox.c lv_msgbox.h lv_objmask.c lv_objmask.h lv_objx_templ.c lv_objx_templ.h lv_page.c lv_page.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_spinbox.c lv_spinbox.h lv_spinner.c lv_spinner.h lv_switch.c lv_switch.h lv_table.c lv_table.h lv_tabview.c lv_tabview.h lv_textarea.c lv_textarea.h lv_tileview.c lv_tileview.h lv_win.c lv_win.h
  group device
    ../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h
  group utilities
    ../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT685S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT685S/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group MIMXRT685S
    ../../../../../devices/MIMXRT685S/: system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group MIMXRT685S/arm
    ../../../../../devices/MIMXRT685S/arm/: startup_MIMXRT685S_cm33.S
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group CMSIS_driver
    ../../../../../CMSIS/Driver/Include/: Driver_I2C.h Driver_Common.h Driver_SPI.h
  group freertos/freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    ../../../../../rtos/freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos_kernel/portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
target littlevgl_guider flash_debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: littlevgl_guider.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, LV_CONF_INCLUDE_SIMPLE=1, LV_EX_CONF_INCLUDE_SIMPLE=1, SERIAL_PORT_TYPE_UART=1, SDK_OS_FREE_RTOS, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: DEBUG
  asm include: ..
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_flash.scf
  link misc: --remove --keep=*(CodeQuickAccess) --entry=Reset_Handler
target littlevgl_guider release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: littlevgl_guider.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, LV_CONF_INCLUDE_SIMPLE=1, LV_EX_CONF_INCLUDE_SIMPLE=1, SERIAL_PORT_TYPE_UART=1, SDK_OS_FREE_RTOS, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG
  asm include: ..
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_ram.scf
  link misc: --remove --entry=Reset_Handler
target littlevgl_guider flash_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: littlevgl_guider.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, LV_CONF_INCLUDE_SIMPLE=1, LV_EX_CONF_INCLUDE_SIMPLE=1, SERIAL_PORT_TYPE_UART=1, SDK_OS_FREE_RTOS, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG
  asm include: ..
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_flash.scf
  link misc: --remove --keep=*(CodeQuickAccess) --entry=Reset_Handler
