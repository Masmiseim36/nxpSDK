# IAR project erpc_server_matrix_multiply_uart_cm33.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT685SFVKB_cm33; MIMXRT685S_cm33_SERIES; BOOT_HEADER_ENABLE=1
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050  --enable_restrict
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../flash_config; ../../../../../CMSIS/Core/Include; ../../../../../CMSIS/Core/Include/m-profile; ../../../../../CMSIS/Driver/Include; ../../../../../devices/MIMXRT685S; ../../../../../devices/MIMXRT685S/periph; ../../../../../devices/MIMXRT685S/drivers; ../../../../../devices/MIMXRT685S/cmsis_drivers; ../../../../../devices/MIMXRT685S/utilities/debug_console_lite; ../../../../../devices/MIMXRT685S/utilities/str; ../../../../../components/uart; ../../../../../middleware/multicore/erpc/erpc_c/infra; ../../../../../middleware/multicore/erpc/erpc_c/setup; ../../../../../middleware/multicore/erpc/erpc_c/port; ../../../../../middleware/multicore/erpc/erpc_c/transports; ../../../../../middleware/multicore/erpc/erpc_c/config; ../../../../../middleware/multicore/erpc/examples/MCUXPRESSO_SDK; ../../../../../middleware/multicore/erpc/examples/MCUXPRESSO_SDK/erpc_matrix_multiply/service
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT685SFVKB_cm33; MIMXRT685S_cm33_SERIES
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: erpc_server_matrix_multiply_uart_cm33.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x2000
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT685SFVKB_cm33; MIMXRT685S_cm33_SERIES; BOOT_HEADER_ENABLE=1
  ICCARM.CCOptLevel: 3
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
  group source
    ../: run_uart.py RTE_Device.h main_server.c erpc_config_gen.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group CMSIS_driver/Include
    ../../../../../CMSIS/Driver/Include/: Driver_USART.h Driver_Common.h
  group device
    ../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S_cm33.h MIMXRT685S_cm33_COMMON.h MIMXRT685S_cm33_features.h system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group device/periph
    ../../../../../devices/MIMXRT685S/periph/: PERI_ADC.h PERI_AHB_SECURE_CTRL.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CASPER.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CMP.h PERI_CRC.h PERI_CTIMER.h PERI_DMA.h PERI_DMIC.h PERI_ESPI.h PERI_FLEXCOMM.h PERI_FLEXSPI.h PERI_FREQME.h PERI_GPIO.h PERI_HASHCRYPT.h PERI_I2C.h PERI_I2S.h PERI_I3C.h PERI_INPUTMUX.h PERI_IOPCTL.h PERI_MRT.h PERI_MU.h PERI_OCOTP.h PERI_OSTIMER.h PERI_OTFAD.h PERI_PINT.h PERI_PMC.h PERI_POWERQUAD.h PERI_PUF.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RTC.h PERI_SCT.h PERI_SEMA42.h PERI_SPI.h PERI_SYSCTL0.h PERI_SYSCTL1.h PERI_TRNG.h PERI_USART.h PERI_USBHSD.h PERI_USBHSDCD.h PERI_USBHSH.h PERI_USBPHY.h PERI_USDHC.h PERI_UTICK.h PERI_WWDT.h
  group startup/iar
    ../../../../../devices/MIMXRT685S/iar/: startup_MIMXRT685S_cm33.s
  group drivers
    ../../../../../devices/MIMXRT685S/drivers/: fsl_clock.c fsl_clock.h fsl_dsp.c fsl_dsp.h fsl_i2s_bridge.c fsl_i2s_bridge.h fsl_inputmux_connections.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_flexcomm.h fsl_flexcomm.c fsl_usart_dma.h fsl_usart_dma.c fsl_usart.h fsl_usart.c fsl_flexspi.c fsl_flexspi.h fsl_dma.c fsl_dma.h fsl_gpio.h fsl_gpio.c fsl_iopctl.h
    ../../../../../devices/MIMXRT685S/cmsis_drivers/: fsl_usart_cmsis.h fsl_usart_cmsis.c
  group utilities
    ../../../../../devices/MIMXRT685S/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../devices/MIMXRT685S/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group erpc/erpc/erpc_c/infra
    ../../../../../middleware/multicore/erpc/erpc_c/infra/: erpc_version.h erpc_codec.hpp erpc_basic_codec.hpp erpc_transport.hpp erpc_message_buffer.hpp erpc_message_loggers.hpp erpc_common.h erpc_manually_constructed.hpp erpc_crc16.hpp erpc_basic_codec.cpp erpc_message_buffer.cpp erpc_message_loggers.cpp erpc_crc16.cpp erpc_client_server_common.hpp erpc_pre_post_action.h erpc_pre_post_action.cpp erpc_utils.hpp erpc_utils.cpp erpc_simple_server.hpp erpc_simple_server.cpp erpc_server.hpp erpc_server.cpp erpc_framed_transport.hpp erpc_framed_transport.cpp
  group erpc/erpc/erpc_c/setup
    ../../../../../middleware/multicore/erpc/erpc_c/setup/: erpc_transport_setup.h erpc_mbf_setup.h erpc_server_setup.h erpc_server_setup.cpp erpc_setup_mbf_dynamic.cpp erpc_setup_uart_cmsis.cpp
  group erpc/erpc/erpc_c/port
    ../../../../../middleware/multicore/erpc/erpc_c/port/: erpc_setup_extensions.h erpc_endianness_agnostic_example.h erpc_endianness_undefined.h erpc_config_internal.h erpc_port.h erpc_port_stdlib.cpp
  group erpc/erpc/erpc_c/config
    ../../../../../middleware/multicore/erpc/erpc_c/config/: erpc_config.h
  group erpc/erpc/erpc_c/transports
    ../../../../../middleware/multicore/erpc/erpc_c/transports/: erpc_uart_cmsis_transport.hpp erpc_uart_cmsis_transport.cpp
  group erpc/erpc/examples/MCUXPRESSO_SDK
    ../../../../../middleware/multicore/erpc/examples/MCUXPRESSO_SDK/: erpc_error_handler.h erpc_error_handler.cpp
  group erpc/erpc/examples/MCUXPRESSO_SDK/erpc_matrix_multiply/service
    ../../../../../middleware/multicore/erpc/examples/MCUXPRESSO_SDK/erpc_matrix_multiply/service/: erpc_matrix_multiply_common.h erpc_matrix_multiply_common.hpp erpc_matrix_multiply_server.hpp erpc_matrix_multiply_server.cpp erpc_matrix_multiply_interface.hpp erpc_matrix_multiply_interface.cpp c_erpc_matrix_multiply_server.h c_erpc_matrix_multiply_server.cpp
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
