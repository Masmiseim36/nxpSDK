# Keil uVision project sdio.uvprojx, settings and files
target sdio debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: sdio.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, SDIO_ENABLED, SDK_I2C_BASED_COMPONENT_USED=1, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../src/sdmmc_examples/sdio;..;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../devices/MIMXRT685S/drivers;../../../../../middleware/sdmmc/sdio;../../../../../middleware/sdmmc/common;../../../../../middleware/sdmmc/host/usdhc;../../../../../components/pca9420;../../../../../devices/MIMXRT685S;../../../../../devices/MIMXRT685S/utilities/str;../../../../../devices/MIMXRT685S/utilities/debug_console;../../../../../components/uart;../../../flash_config;../../../../../components/serial_manager;../../../../../components/lists;../../../../../middleware/sdmmc/osa;../../../../../components/osa;../../../../../devices/MIMXRT685S/utilities
  asm define: DEBUG
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_ram.scf
  link misc: ../../../../../devices/MIMXRT685S/arm/keil_lib_power.lib --remove --keep=*(.flash_conf)
  group source
    ../: sdio.c
  group board
    ../: pin_mux.c pin_mux.h sdmmc_config.c sdmmc_config.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT685S/drivers/: fsl_gpio.c fsl_gpio.h fsl_usdhc.c fsl_usdhc.h fsl_i2c.c fsl_i2c.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_power.c fsl_power.h fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_iopctl.h fsl_reset.c fsl_reset.h
  group sdmmc
    ../../../../../middleware/sdmmc/sdio/: ChangeLogKSDK.txt
  group sdmmc-src
    ../../../../../middleware/sdmmc/sdio/: fsl_sdio.c
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc-inc
    ../../../../../middleware/sdmmc/sdio/: fsl_sdio.h
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.h fsl_sdmmc_spec.h
  group sdmmc-host
    ../../../../../middleware/sdmmc/host/usdhc/: ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h
    ../../../../../middleware/sdmmc/host/usdhc/blocking/: fsl_sdmmc_host.c
  group pmic_driver
    ../../../../../components/pca9420/: fsl_pca9420.c fsl_pca9420.h
  group device
    ../../../../../devices/MIMXRT685S/: MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h fsl_device_registers.h system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group utilities
    ../../../../../devices/MIMXRT685S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT685S/utilities/: fsl_assert.c
  group component-uart
    ../../../../../components/uart/: uart.h usart_adapter.c
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MIMXRT685S/arm/: startup_MIMXRT685S_cm33.S
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
  group sdmmc-osa
    ../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.c fsl_sdmmc_osa.h
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
target sdio flash_debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: sdio.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, SDIO_ENABLED, SDK_I2C_BASED_COMPONENT_USED=1, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: DEBUG
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_flash.scf
  link misc: ../../../../../devices/MIMXRT685S/arm/keil_lib_power.lib --remove --keep=*(CodeQuickAccess) --keep=*(.flash_conf)
target sdio release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: sdio.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, SDIO_ENABLED, SDK_I2C_BASED_COMPONENT_USED=1, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_ram.scf
  link misc: as above
target sdio flash_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: sdio.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, SDIO_ENABLED, SDK_I2C_BASED_COMPONENT_USED=1, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_flash.scf
  link misc: as above
