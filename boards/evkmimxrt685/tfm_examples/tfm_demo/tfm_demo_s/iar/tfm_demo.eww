<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>tfm_demo_s</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>tfm_demo_s</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>tfm_demo_ns</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>tfm_demo_ns</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>tfm_demo_s</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>tfm_demo_ns</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>tfm_demo_s</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>tfm_demo_ns</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/tfm_demo_s.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../../tfm_demo_ns/iar/tfm_demo_ns.ewp</path>
  </project>
</workspace>
