# IAR project hello_world_ns.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../hello_world_s; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S; ../../../../../../devices/MIMXRT685S/utilities/str; ../../../../../../devices/MIMXRT685S/utilities/debug_console; ../../../../../../components/uart; ../../../../flash_config; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../devices/MIMXRT685S/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: hello_world_ns.out
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_ram_ns.icf
  ILINK.IlinkAdditionalLibs: ../../hello_world_s/iar/debug/hello_world_s_import_lib.o; ../../../../../../devices/MIMXRT685S/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; SERIAL_PORT_TYPE_UART=1
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash_ns.icf
  ILINK.IlinkAdditionalLibs: ../../hello_world_s/iar/flash_debug/hello_world_s_import_lib.o; ../../../../../../devices/MIMXRT685S/iar/iar_lib_power.a
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  ILINK.IlinkAdditionalLibs: ../../hello_world_s/iar/release/hello_world_s_import_lib.o; ../../../../../../devices/MIMXRT685S/iar/iar_lib_power.a
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash_ns.icf
  ILINK.IlinkAdditionalLibs: ../../hello_world_s/iar/flash_release/hello_world_s_import_lib.o; ../../../../../../devices/MIMXRT685S/iar/iar_lib_power.a
  group source
    ../: hello_world_ns.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group trustzone
    ../../hello_world_s/: veneer_table.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MIMXRT685S/drivers/: fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_iopctl.h fsl_gpio.c fsl_gpio.h
  group device
    ../../../../../../devices/MIMXRT685S/: MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h fsl_device_registers.h system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group utilities
    ../../../../../../devices/MIMXRT685S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT685S/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../components/uart/: uart.h usart_adapter.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group startup
    ../../../../../../devices/MIMXRT685S/iar/: startup_MIMXRT685S_cm33.s
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
