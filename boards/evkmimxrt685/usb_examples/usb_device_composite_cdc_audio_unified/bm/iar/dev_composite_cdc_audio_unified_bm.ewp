# IAR project dev_composite_cdc_audio_unified_bm.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: _DEBUG=1; DEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; HAL_AUDIO_ISR_PRIORITY=0; USB_STACK_BM; CPU_MIMXRT685SFVKB=1; USB_STACK_USE_DEDICATED_RAM=1; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8904_ENABLE; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../middleware/usb/device; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/phy; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../components/codec/wm8904; ../../../../../../components/codec; ../../../../../../components/codec/port/wm8904; ../../../../../../components/codec/port; ../../../../../../components/audio; ../../../../../../components/codec/i2c; ../../../../../../components/i2c; ../../../../../../devices/MIMXRT685S/utilities/debug_console_lite; ../../../../../../devices/MIMXRT685S; ../../../../../../components/uart; ../../../../flash_config; ../../../../../../components/lists; ../../../../../../components/osa; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: dev_composite_cdc_audio_unified_bm.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; HAL_AUDIO_ISR_PRIORITY=0; USB_STACK_BM; CPU_MIMXRT685SFVKB=1; USB_STACK_USE_DEDICATED_RAM=1; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8904_ENABLE; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; NDEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; HAL_AUDIO_ISR_PRIORITY=0; USB_STACK_BM; CPU_MIMXRT685SFVKB=1; USB_STACK_USE_DEDICATED_RAM=1; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8904_ENABLE; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; HAL_AUDIO_ISR_PRIORITY=0; USB_STACK_BM; CPU_MIMXRT685SFVKB=1; USB_STACK_USE_DEDICATED_RAM=1; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8904_ENABLE; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
  group source
    ../: audio_data_dmic.c audio_data_dmic.h usb_audio_config.h audio_unified.c audio_unified.h composite.c composite.h virtual_com.c virtual_com.h usb_device_descriptor.c usb_device_descriptor.h usb_device_config.h
  group doc
    ../: readme.txt
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h usb_device_dci.h
  group usb/device/source/lpcip3511
    ../../../../../../middleware/usb/device/: usb_device_lpcip3511.c usb_device_lpcip3511.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/audio
    ../: usb_device_audio.c usb_device_audio.h
  group usb/device/class/cdc
    ../: usb_device_cdc_acm.c usb_device_cdc_acm.h
  group usb/device/include
    ../../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group usb/phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group drivers
    ../../../../../../devices/MIMXRT685S/drivers/: fsl_i2c.h fsl_i2c.c fsl_i2s.h fsl_i2s.c fsl_i2s_dma.h fsl_i2s_dma.c fsl_dma.c fsl_dma.h fsl_usart.h fsl_usart.c fsl_i3c.h fsl_i3c.c fsl_ctimer.h fsl_ctimer.c fsl_dmic.c fsl_dmic.h fsl_dmic_dma.c fsl_dmic_dma.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_cache.c fsl_cache.h fsl_flexspi.c fsl_flexspi.h fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c
  group codec
    ../../../../../../components/codec/wm8904/: fsl_wm8904.h fsl_wm8904.c
    ../../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
  group codec/port
    ../../../../../../components/codec/port/: fsl_codec_adapter.h
  group codec/port/wm8904
    ../../../../../../components/codec/port/wm8904/: fsl_codec_wm8904_adapter.c fsl_codec_wm8904_adapter.h
  group component/audio
    ../../../../../../components/audio/: fsl_adapter_audio.h fsl_adapter_flexcomm_i2s.c
  group component/i2c
    ../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_i3c.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c
  group utilities
    ../../../../../../devices/MIMXRT685S/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group device
    ../../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group MIMXRT685S
    ../../../../../../devices/MIMXRT685S/: system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group MIMXRT685S/iar
    ../../../../../../devices/MIMXRT685S/iar/: startup_MIMXRT685S_cm33.s
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
