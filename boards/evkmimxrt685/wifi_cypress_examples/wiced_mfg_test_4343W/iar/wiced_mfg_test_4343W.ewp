# IAR project wiced_mfg_test_4343W.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; HIGH_SPEED_SDIO_CLOCK; PRINTF_ADVANCED_ENABLE=1; TARGET_wiced; RWL_SERIAL; LWIP_NETIF_API=1; WICED_MFG_TEST_APP; WICED_PAYLOAD_MTU=8320; PBUF_POOL_BUFSIZE=8320; SDK_I2C_BASED_COMPONENT_USED=1; SDIO_ENABLED; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS; WIFI_WICED; SDK_DEBUGCONSOLE_UART
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../..; ../../wiced_mfg_test; ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../devices/MIMXRT685S/drivers; ../../../../../components/pca9420; ../../../../../middleware/lwip/port; ../../../../../middleware/lwip/src; ../../../../../middleware/lwip/src/include; ../../../../../devices/MIMXRT685S/utilities/str; ../../../../../devices/MIMXRT685S/utilities/debug_console; ../../../../../middleware/wiced/43xxx_Wi-Fi/platforms/MURATA_TYPE1DX; ../../../../../middleware/sdmmc/sdio; ../../../../../middleware/sdmmc/common; ../../../../../middleware/sdmmc/host/usdhc; ../../../../../middleware/wiced/43xxx_Wi-Fi/app; ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/common/include/devctrl_if; ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/common/include/proto; ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/include; ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/shared/bcmwifi/include; ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/wl/exe; ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/dummy/arpa; ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/dummy/net; ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/dummy; ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/dummy/sys; ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool; ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/common/include; ../../../../../devices/MIMXRT685S; ../../../../../components/uart; ../../../flash_config; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../rtos/freertos/freertos_kernel/include; ../../../../../CMSIS/Include; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/chips/4343W; ../../../../../middleware/wiced/43xxx_Wi-Fi/include; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/network/LwIP/WWD; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/include; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/RTOS/FreeRTOS/WWD; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/network; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/platform; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/RTOS; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/SDIO; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD; ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/WWD; ../../../../../middleware/sdmmc/osa; ../../../../../components/osa
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: wiced_mfg_test_4343W.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x2800
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; HIGH_SPEED_SDIO_CLOCK; PRINTF_ADVANCED_ENABLE=1; TARGET_wiced; RWL_SERIAL; LWIP_NETIF_API=1; WICED_MFG_TEST_APP; WICED_PAYLOAD_MTU=8320; PBUF_POOL_BUFSIZE=8320; SDK_I2C_BASED_COMPONENT_USED=1; SDIO_ENABLED; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS; WIFI_WICED; SDK_DEBUGCONSOLE_UART
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; HIGH_SPEED_SDIO_CLOCK; PRINTF_ADVANCED_ENABLE=1; TARGET_wiced; RWL_SERIAL; LWIP_NETIF_API=1; WICED_MFG_TEST_APP; WICED_PAYLOAD_MTU=8320; PBUF_POOL_BUFSIZE=8320; SDK_I2C_BASED_COMPONENT_USED=1; SDIO_ENABLED; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS; WIFI_WICED; SDK_DEBUGCONSOLE_UART
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; HIGH_SPEED_SDIO_CLOCK; PRINTF_ADVANCED_ENABLE=1; TARGET_wiced; RWL_SERIAL; LWIP_NETIF_API=1; WICED_MFG_TEST_APP; WICED_PAYLOAD_MTU=8320; PBUF_POOL_BUFSIZE=8320; SDK_I2C_BASED_COMPONENT_USED=1; SDIO_ENABLED; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS; WIFI_WICED; SDK_DEBUGCONSOLE_UART
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
    ../../../: sdmmc_config.c sdmmc_config.h
  group source
    ../: lwipopts.h mfg_test.c mfg_test.h FreeRTOSConfig.h
  group doc
    ../: readme.txt
  group freertos/freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s portmacro.h portasm.h
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos_kernel/include
    ../../../../../rtos/freertos/freertos_kernel/include/: croutine.h StackMacros.h atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group drivers
    ../../../../../devices/MIMXRT685S/drivers/: fsl_i2c.h fsl_i2c.c fsl_clock.h fsl_clock.c fsl_usdhc.c fsl_usdhc.h fsl_common.h fsl_common.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c
  group drivers/freertos
    ../../../../../devices/MIMXRT685S/drivers/: fsl_usart_freertos.h fsl_usart_freertos.c
  group pmic_driver
    ../../../../../components/pca9420/: fsl_pca9420.h fsl_pca9420.c
  group lwip/port
    ../../../../../middleware/lwip/port/: sys_arch.c
  group lwip/port/arch
    ../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src/api
    ../../../../../middleware/lwip/src/api/: api_lib.c tcpip.c netdb.c sockets.c if_api.c netbuf.c netifapi.c api_msg.c err.c
  group lwip/src/core
    ../../../../../middleware/lwip/src/core/: altcp.c sys.c stats.c def.c ip.c netif.c dns.c tcp_out.c pbuf.c timeouts.c init.c tcp_in.c altcp_tcp.c raw.c tcp.c udp.c altcp_alloc.c mem.c inet_chksum.c memp.c
  group lwip/src/core/ipv6
    ../../../../../middleware/lwip/src/core/ipv6/: icmp6.c ethip6.c nd6.c ip6_frag.c inet6.c ip6.c dhcp6.c mld6.c ip6_addr.c
  group lwip/src/core/ipv4
    ../../../../../middleware/lwip/src/core/ipv4/: igmp.c ip4.c dhcp.c etharp.c ip4_frag.c icmp.c autoip.c acd.c ip4_addr.c
  group lwip/src/include/compat/stdc
    ../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/compat/posix
    ../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/sys
    ../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/compat/posix/net
    ../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/lwip
    ../../../../../middleware/lwip/src/include/lwip/: err.h sio.h ip6.h netdb.h altcp_tcp.h arch.h debug.h ip6_addr.h sockets.h if_api.h init.h tcpbase.h tcpip.h def.h inet_chksum.h snmp.h api.h ip4.h inet.h igmp.h altcp_tls.h netif.h opt.h ip.h acd.h tcp.h ip6_frag.h altcp.h ip4_addr.h ip4_frag.h netbuf.h autoip.h dns.h sys.h dhcp.h ip_addr.h icmp6.h mem.h raw.h ip6_zone.h stats.h ethip6.h icmp.h pbuf.h netifapi.h nd6.h etharp.h errno.h mld6.h timeouts.h dhcp6.h udp.h memp.h
  group lwip/src/include/lwip/priv
    ../../../../../middleware/lwip/src/include/lwip/priv/: api_msg.h tcpip_priv.h mem_priv.h altcp_priv.h nd6_priv.h tcp_priv.h memp_std.h sockets_priv.h raw_priv.h memp_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../middleware/lwip/src/include/lwip/prot/: ip6.h ethernet.h ip4.h igmp.h ip.h acd.h tcp.h ieee.h iana.h autoip.h dns.h dhcp.h icmp6.h icmp.h nd6.h etharp.h mld6.h dhcp6.h udp.h
  group lwip/src/include/netif
    ../../../../../middleware/lwip/src/include/netif/: bridgeif_opts.h ethernet.h zepif.h ieee802154.h lowpan6.h lowpan6_common.h lowpan6_ble.h lowpan6_opts.h bridgeif.h slipif.h etharp.h
  group lwip/src/include/netif/ppp
    ../../../../../middleware/lwip/src/include/netif/ppp/: eap.h pppol2tp.h chap-md5.h pppcrypt.h ppp.h upap.h pppapi.h ipv6cp.h pppdebug.h pppoe.h mppe.h pppos.h ppp_opts.h chap-new.h ipcp.h lcp.h ccp.h ppp_impl.h eui64.h vj.h ecp.h magic.h fsm.h chap_ms.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: sha1.h md5.h arc4.h md4.h des.h
  group lwip/src/netif
    ../../../../../middleware/lwip/src/netif/: lowpan6.c lowpan6_ble.c ethernet.c lowpan6_common.c slipif.c bridgeif.c bridgeif_fdb.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../middleware/lwip/src/netif/ppp/: utils.c pppol2tp.c chap_ms.c vj.c pppos.c lwip_ecp.c magic.c eui64.c chap-md5.c auth.c ppp.c ccp.c pppapi.c eap.c mppe.c ipv6cp.c ipcp.c lcp.c pppcrypt.c pppoe.c chap-new.c demand.c upap.c multilink.c fsm.c
  group utilities
    ../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT685S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT685S/utilities/: fsl_assert.c
  group wiced/43xxx_Wi-Fi
    ../../../../../middleware/wiced/43xxx_Wi-Fi/: generated_mac_address.txt
  group wiced/43xxx_Wi-Fi/platforms/MURATA_TYPE1DX
    ../../../../../middleware/wiced/43xxx_Wi-Fi/platforms/MURATA_TYPE1DX/: wifi_nvram_image.h
  group wiced/43xxx_Wi-Fi/app
    ../../../../../middleware/wiced/43xxx_Wi-Fi/app/: dhcp_server.c dhcp_server.h test_apsta.c test_scan.c wlanif_add.c
  group wiced/43xxx_Wi-Fi/libraries/test/wl_tool
    ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/: wl_tool.h wlu_server.c
  group wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/common/include/devctrl_if
    ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/common/include/devctrl_if/: phyioctl_defs.h wlioctl_defs.h
  group wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/common/include/proto
    ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/common/include/proto/: 802.11.h 802.11e.h 802.1d.h bcmeth.h bcmevent.h bcmip.h bcmipv6.h ethernet.h vlan.h wpa.h wps.h
  group wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/include
    ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/include/: bcm_cfg.h bcm_mpool_pub.h bcmcdc.h bcmdefs.h bcmdevs.h bcmendian.h bcmnvram.h bcmsrom_fmt.h bcmsrom_tbl.h bcmstdlib.h bcmutils.h dhdioctl.h epictrl.h epiioctl.h epivers.h irelay.h miniopt.h packed_section_end.h packed_section_start.h sbpcmcia.h trxhdr.h typedefs.h usbrdl.h wl_drv.h wlioctl.h
  group wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/shared/bcmwifi/include
    ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/shared/bcmwifi/include/: bcmwifi_channels.h bcmwifi_rates.h
  group wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/wl/exe
    ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/4343WA1/wl/exe/: wlu.h wlu_client_shared.h wlu_cmd.h wlu_common.h wlu_pipe.c wlu_pipe.h wlu_remote.h wlu_server_shared.c wlu_server_shared.h
  group wiced/43xxx_Wi-Fi/libraries/test/wl_tool/dummy
    ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/dummy/: netdb.h ntddndis.h nuiouser.h
  group wiced/43xxx_Wi-Fi/libraries/test/wl_tool/dummy/arpa
    ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/dummy/arpa/: inet.h
  group wiced/43xxx_Wi-Fi/libraries/test/wl_tool/dummy/net
    ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/dummy/net/: if.h
  group wiced/43xxx_Wi-Fi/libraries/test/wl_tool/dummy/sys
    ../../../../../middleware/wiced/43xxx_Wi-Fi/libraries/test/wl_tool/dummy/sys/: socket.h
  group wiced/43xxx_Wi-Fi/WICED/WWD
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/: wwd.h wwd_wiced.h
  group wiced/43xxx_Wi-Fi/WICED/WWD/internal
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/: tlv.c tlv.h wwd_ap.h wwd_ap_common.c wwd_ap_common.h wwd_bcmendian.h wwd_clm.c wwd_clm.h wwd_debug.c wwd_eapol.c wwd_internal.c wwd_internal.h wwd_logging.h wwd_management.c wwd_rtos_interface.c wwd_sdpcm.c wwd_sdpcm.h wwd_thread.c wwd_thread.h wwd_thread_internal.c wwd_thread_internal.h wwd_wifi.c wwd_wifi_chip_common.c wwd_wifi_chip_common.h wwd_wifi_sleep.c
  group wiced/43xxx_Wi-Fi/WICED/WWD/internal/chips/4343W
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/chips/4343W/: 4343WA1.h 4343WA1_clm.h 4343WA1_mfg.h 4343WA1_clm_mfg.h chip_constants.h resources.c resources.h wwd_ap.c wwd_chip_specific_functions.c
  group wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/: wwd_bus_common.c wwd_bus_protocol_interface.h
  group wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/SDIO
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/SDIO/: wwd_bus_protocol.c wwd_bus_protocol.h
  group wiced/43xxx_Wi-Fi/WICED/WWD/include
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/: wwd_assert.h wwd_constants.h wwd_debug.h wwd_eapol.h wwd_events.h wwd_management.h wwd_poll.h wwd_structures.h wwd_wifi.h wwd_wifi_sleep.h wwd_wlioctl.h
  group wiced/43xxx_Wi-Fi/WICED/WWD/include/network
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/network/: wwd_buffer_interface.h wwd_network_constants.h wwd_network_interface.h
  group wiced/43xxx_Wi-Fi/WICED/WWD/include/platform
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/platform/: wwd_bus_interface.h wwd_platform_interface.h wwd_resource_interface.h wwd_sdio_interface.h wwd_spi_interface.h
  group wiced/43xxx_Wi-Fi/WICED/WWD/include/RTOS
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/RTOS/: wwd_rtos_interface.h
  group wiced/43xxx_Wi-Fi/WICED/internal
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/internal/: wifi.c
  group wiced/43xxx_Wi-Fi/WICED/network/LwIP/WWD
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/network/LwIP/WWD/: wwd_buffer.c wwd_buffer.h wwd_network.c wwd_network.h
  group wiced/43xxx_Wi-Fi/WICED/platform
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/: platform_toolchain.h
  group wiced/43xxx_Wi-Fi/WICED/platform/include
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/include/: platform_cache_def.h platform_peripheral.h
  group wiced/43xxx_Wi-Fi/WICED/platform/MCU
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/: wwd_platform_common.h wwd_platform_separate_mcu.c wwd_resources.c
  group wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/: platform_mcu_peripheral.h
  group wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/WWD
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/WWD/: wwd_platform.c wwd_SDIO.c
  group wiced/43xxx_Wi-Fi/WICED/RTOS/FreeRTOS/WWD
    ../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/RTOS/FreeRTOS/WWD/: wwd_FreeRTOS_systick.h wwd_rtos.c wwd_rtos.h
  group wiced/43xxx_Wi-Fi/include
    ../../../../../middleware/wiced/43xxx_Wi-Fi/include/: wiced_resource.h
  group sdmmc/src
    ../../../../../middleware/sdmmc/sdio/: fsl_sdio.c
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc/sdio/: fsl_sdio.h
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sdio
    ../../../../../middleware/sdmmc/sdio/: ChangeLogKSDK.txt
  group sdmmc/host
    ../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt
    ../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group sdmmc/osa
    ../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group MIMXRT685S
    ../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group MIMXRT685S/iar
    ../../../../../devices/MIMXRT685S/iar/: startup_MIMXRT685S_cm33.s
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm33.h tz_context.h mpu_armv8.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
