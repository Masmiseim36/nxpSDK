# IAR project wiced_nghttp2cli_mbedTLS_freertos.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; HIGH_SPEED_SDIO_CLOCK; PRINTF_ADVANCED_ENABLE=1; USE_RTOS=1; LWIP_DNS=1; MBEDTLS_CONFIG_FILE="nghttp2_mbedtls_config.h"; HAVE_CONFIG_H; LWIP_NETIF_API=1; SDK_I2C_BASED_COMPONENT_USED=1; SDIO_ENABLED; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS; WIFI_WICED; SDK_DEBUGCONSOLE_UART
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.IExtraOptions: --diag_suppress Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ..; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../middleware/mbedtls/include; ../../../../../../middleware/mbedtls/port/ksdk; ../../../../../../middleware/nghttp2/lib; ../../../../../../middleware/nghttp2/lib/includes; ../../../../../../rtos/freertos/freertos_kernel/include; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../components/pca9420; ../../../../../../middleware/lwip/port; ../../../../../../middleware/lwip/src; ../../../../../../middleware/lwip/src/include; ../../../../../../devices/MIMXRT685S/utilities/str; ../../../../../../devices/MIMXRT685S/utilities/debug_console; ../../../../../../middleware/wiced/43xxx_Wi-Fi/platforms/MURATA_TYPE1DX; ../../../../../../middleware/sdmmc/sdio; ../../../../../../middleware/sdmmc/common; ../../../../../../middleware/sdmmc/host/usdhc; ../../../../../../middleware/wiced/43xxx_Wi-Fi/app; ../../../../../../devices/MIMXRT685S; ../../../../../../components/uart; ../../../../flash_config; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/chips/4343W; ../../../../../../middleware/wiced/43xxx_Wi-Fi/include; ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/network/LwIP/WWD; ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform; ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/include; ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU; ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC; ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/WWD; ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/RTOS/FreeRTOS/WWD; ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD; ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include; ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/network; ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/platform; ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/RTOS; ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal; ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/SDIO; ../../../../../../middleware/lwip/src/include/lwip; ../../../../../../middleware/sdmmc/osa; ../../../../../../components/osa; ../../../../../../devices/MIMXRT685S/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../..; ../../../../../src/wifi_cypress_examples/wiced_nghttp2cli_mbedTLS/freertos; ..
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: wiced_nghttp2cli_mbedTLS_freertos.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x600
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; HIGH_SPEED_SDIO_CLOCK; PRINTF_ADVANCED_ENABLE=1; USE_RTOS=1; LWIP_DNS=1; MBEDTLS_CONFIG_FILE="nghttp2_mbedtls_config.h"; HAVE_CONFIG_H; LWIP_NETIF_API=1; SDK_I2C_BASED_COMPONENT_USED=1; SDIO_ENABLED; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS; WIFI_WICED; SDK_DEBUGCONSOLE_UART
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; HIGH_SPEED_SDIO_CLOCK; PRINTF_ADVANCED_ENABLE=1; USE_RTOS=1; LWIP_DNS=1; MBEDTLS_CONFIG_FILE="nghttp2_mbedtls_config.h"; HAVE_CONFIG_H; LWIP_NETIF_API=1; SDK_I2C_BASED_COMPONENT_USED=1; SDIO_ENABLED; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS; WIFI_WICED; SDK_DEBUGCONSOLE_UART
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; HIGH_SPEED_SDIO_CLOCK; PRINTF_ADVANCED_ENABLE=1; USE_RTOS=1; LWIP_DNS=1; MBEDTLS_CONFIG_FILE="nghttp2_mbedtls_config.h"; HAVE_CONFIG_H; LWIP_NETIF_API=1; SDK_I2C_BASED_COMPONENT_USED=1; SDIO_ENABLED; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS; WIFI_WICED; SDK_DEBUGCONSOLE_UART
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
  group source
    ../: wiced_nghttp2cli_mbedTLS_freertos.c lwipopts.h FreeRTOSConfig.h
  group wiced_nghttp2cli_mbedTLS
    ../: config.h nghttp2_mbedtls_config.h nghttp2client.c nghttp2client.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
    ../../../../: sdmmc_config.c sdmmc_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MIMXRT685S/drivers/: fsl_casper.c fsl_casper.h fsl_hashcrypt.c fsl_hashcrypt.h fsl_trng.c fsl_trng.h fsl_i2c.c fsl_i2c.h fsl_clock.c fsl_clock.h fsl_usdhc.c fsl_usdhc.h fsl_common.c fsl_common.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_iopctl.h fsl_gpio.c fsl_gpio.h
  group freertos/freertos_kernel
    ../../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.h portasm.s portmacro.h
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos_kernel/include
    ../../../../../../rtos/freertos/freertos_kernel/include/: FreeRTOS.h StackMacros.h atomic.h croutine.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group pmic_driver
    ../../../../../../components/pca9420/: fsl_pca9420.c fsl_pca9420.h
  group lwip/port
    ../../../../../../middleware/lwip/port/: sys_arch.c
  group lwip/port/arch
    ../../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src/api
    ../../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/core
    ../../../../../../middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/src/core/ipv4
    ../../../../../../middleware/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/src/core/ipv6
    ../../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip/src/include/compat/posix
    ../../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/compat/posix/net
    ../../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/sys
    ../../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/stdc
    ../../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/lwip
    ../../../../../../middleware/lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/priv
    ../../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../../middleware/lwip/src/include/lwip/prot/: acd.h autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip/src/include/netif
    ../../../../../../middleware/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lwip/src/include/netif/ppp
    ../../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip/src/netif
    ../../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group utilities
    ../../../../../../devices/MIMXRT685S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT685S/utilities/: fsl_assert.c
  group wiced/43xxx_Wi-Fi
    ../../../../../../middleware/wiced/43xxx_Wi-Fi/: generated_mac_address.txt
  group wiced/43xxx_Wi-Fi/platforms/MURATA_TYPE1DX
    ../../../../../../middleware/wiced/43xxx_Wi-Fi/platforms/MURATA_TYPE1DX/: wifi_nvram_image.h
  group wiced/43xxx_Wi-Fi/app
    ../../../../../../middleware/wiced/43xxx_Wi-Fi/app/: dhcp_server.c dhcp_server.h test_apsta.c test_scan.c wlanif_add.c
  group wiced/43xxx_Wi-Fi/WICED/WWD
    ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/: wwd.h wwd_wiced.h
  group wiced/43xxx_Wi-Fi/WICED/WWD/internal
    ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/: tlv.c tlv.h wwd_ap.h wwd_ap_common.c wwd_ap_common.h wwd_bcmendian.h wwd_clm.c wwd_clm.h wwd_debug.c wwd_eapol.c wwd_internal.c wwd_internal.h wwd_logging.h wwd_management.c wwd_rtos_interface.c wwd_sdpcm.c wwd_sdpcm.h wwd_thread.c wwd_thread.h wwd_thread_internal.c wwd_thread_internal.h wwd_wifi.c wwd_wifi_chip_common.c wwd_wifi_chip_common.h wwd_wifi_sleep.c
  group wiced/43xxx_Wi-Fi/WICED/WWD/internal/chips/4343W
    ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/chips/4343W/: 4343WA1.h 4343WA1_clm.h 4343WA1_clm_mfg.h 4343WA1_mfg.h chip_constants.h resources.c resources.h wwd_ap.c wwd_chip_specific_functions.c
  group wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols
    ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/: wwd_bus_common.c wwd_bus_protocol_interface.h
  group wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/SDIO
    ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/SDIO/: wwd_bus_protocol.c wwd_bus_protocol.h
  group wiced/43xxx_Wi-Fi/WICED/WWD/include
    ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/: wwd_assert.h wwd_constants.h wwd_debug.h wwd_eapol.h wwd_events.h wwd_management.h wwd_poll.h wwd_structures.h wwd_wifi.h wwd_wifi_sleep.h wwd_wlioctl.h
  group wiced/43xxx_Wi-Fi/WICED/WWD/include/RTOS
    ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/RTOS/: wwd_rtos_interface.h
  group wiced/43xxx_Wi-Fi/WICED/WWD/include/network
    ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/network/: wwd_buffer_interface.h wwd_network_constants.h wwd_network_interface.h
  group wiced/43xxx_Wi-Fi/WICED/WWD/include/platform
    ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/platform/: wwd_bus_interface.h wwd_platform_interface.h wwd_resource_interface.h wwd_sdio_interface.h wwd_spi_interface.h
  group wiced/43xxx_Wi-Fi/WICED/RTOS/FreeRTOS/WWD
    ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/RTOS/FreeRTOS/WWD/: wwd_FreeRTOS_systick.h wwd_rtos.c wwd_rtos.h
  group wiced/43xxx_Wi-Fi/WICED/internal
    ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/internal/: wifi.c
  group wiced/43xxx_Wi-Fi/WICED/network/LwIP/WWD
    ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/network/LwIP/WWD/: wwd_buffer.c wwd_buffer.h wwd_network.c wwd_network.h
  group wiced/43xxx_Wi-Fi/WICED/platform
    ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/: platform_toolchain.h
  group wiced/43xxx_Wi-Fi/WICED/platform/MCU
    ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/: wwd_platform_common.h wwd_platform_separate_mcu.c wwd_resources.c
  group wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC
    ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/: platform_mcu_peripheral.h
  group wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/WWD
    ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/WWD/: wwd_SDIO.c wwd_platform.c
  group wiced/43xxx_Wi-Fi/WICED/platform/include
    ../../../../../../middleware/wiced/43xxx_Wi-Fi/WICED/platform/include/: platform_cache_def.h platform_peripheral.h
  group wiced/43xxx_Wi-Fi/include
    ../../../../../../middleware/wiced/43xxx_Wi-Fi/include/: wiced_resource.h
  group sdmmc
    ../../../../../../middleware/sdmmc/sdio/: ChangeLogKSDK.txt
  group sdmmc/src
    ../../../../../../middleware/sdmmc/sdio/: fsl_sdio.c
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../../middleware/sdmmc/sdio/: fsl_sdio.h
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.h fsl_sdmmc_spec.h
  group sdmmc/host
    ../../../../../../middleware/sdmmc/host/usdhc/: ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h
    ../../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group sdmmc/osa
    ../../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.c fsl_sdmmc_osa.h
  group mbedtls/include/mbedtls
    ../../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/library
    ../../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/port/ksdk
    ../../../../../../middleware/mbedtls/port/ksdk/: aes_alt.c aes_alt.h des_alt.c des_alt.h ecp_alt.c ecp_alt.h ecp_alt_ksdk.c ecp_curves_alt.c ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h
  group nghttp2/nghttp2_include
    ../../../../../../middleware/nghttp2/lib/includes/nghttp2/: nghttp2.h nghttp2ver.h
    ../../../../../../middleware/nghttp2/lib/: nghttp2_buf.h nghttp2_callbacks.h nghttp2_debug.h nghttp2_frame.h nghttp2_hd.h nghttp2_hd_huffman.h nghttp2_helper.h nghttp2_http.h nghttp2_int.h nghttp2_map.h nghttp2_mem.h nghttp2_net.h nghttp2_npn.h nghttp2_option.h nghttp2_outbound_item.h nghttp2_pq.h nghttp2_priority_spec.h nghttp2_queue.h nghttp2_rcbuf.h nghttp2_session.h nghttp2_stream.h nghttp2_submit.h
  group nghttp2/nghttp2_source
    ../../../../../../middleware/nghttp2/lib/: nghttp2_buf.c nghttp2_callbacks.c nghttp2_debug.c nghttp2_frame.c nghttp2_hd.c nghttp2_hd_huffman.c nghttp2_hd_huffman_data.c nghttp2_helper.c nghttp2_http.c nghttp2_map.c nghttp2_mem.c nghttp2_npn.c nghttp2_option.c nghttp2_outbound_item.c nghttp2_pq.c nghttp2_priority_spec.c nghttp2_queue.c nghttp2_rcbuf.c nghttp2_session.c nghttp2_stream.c nghttp2_submit.c nghttp2_version.c
  group device
    ../../../../../../devices/MIMXRT685S/: MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h fsl_device_registers.h system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group component/uart
    ../../../../../../components/uart/: uart.h usart_adapter.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction_free_rtos.h
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group startup
    ../../../../../../devices/MIMXRT685S/iar/: startup_MIMXRT685S_cm33.s
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
