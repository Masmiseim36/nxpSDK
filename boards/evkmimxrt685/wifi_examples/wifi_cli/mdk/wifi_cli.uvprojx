# Keil uVision project wifi_cli.uvprojx, settings and files
target wifi_cli debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: wifi_cli.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, USE_RTOS=1, WIFI_BOARD_PAN9026_SDIO, PRINTF_ADVANCED_ENABLE=1, FSL_RTOS_FREE_RTOS, SDIO_ENABLED, SDK_I2C_BASED_COMPONENT_USED=1, SERIAL_PORT_TYPE_UART=1
  c misc: -include ../../../../../boards/evkmimxrt685/wifi_examples/wifi_cli/wifi_config.h -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM33_NTZ/non_secure;..;../../..;../../common;../../../../../CMSIS/Include;../../../../../devices;../../../../../rtos/freertos/freertos_kernel/include;../../../../../middleware/lwip/port;../../../../../middleware/lwip/src;../../../../../middleware/lwip/src/include;../../../../../devices/MIMXRT685S/utilities/str;../../../../../devices/MIMXRT685S/utilities/debug_console;../../../../../middleware/wifi/dhcpd;../../../../../middleware/wifi/incl;../../../../../middleware/wifi/incl/port/lwip;../../../../../middleware/wifi/incl/port/os;../../../../../middleware/wifi/incl/wifidriver;../../../../../middleware/wifi/incl/wlcmgr;../../../../../middleware/wifi/port/lwip;../../../../../middleware/wifi/wifidriver;../../../../../middleware/wifi/wifidriver/incl;../../../../../middleware/wifi/wifi_bt_firmware;../../../../../middleware/lwip/src/include/lwip/apps;../../../../../middleware/wifi/cli;../../../../../devices/MIMXRT685S/drivers;../../../../../middleware/sdmmc/sdio;../../../../../middleware/sdmmc/common;../../../../../middleware/sdmmc/host/usdhc;../../../../../components/pca9420;../../../../../devices/MIMXRT685S;../../../../../components/uart;../../../flash_config;../../../../../components/serial_manager;../../../../../components/lists;../../../../../middleware/sdmmc/osa;../../../../../components/osa;../../../../../devices/MIMXRT685S/utilities
  asm define: DEBUG
  asm include: ../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM33_NTZ/non_secure;..;../../..;../../common
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_ram.scf
  link misc: --remove --keep=*(.flash_conf) --predefine="-D__stack_size__=0x400" --predefine="-D__heap_size__=0x400"
  group source
    ../: main.c lwipopts.h lwippools.h wifi_config.h FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
    ../../../: sdmmc_config.c sdmmc_config.h
  group doc
    ../: readme.txt
  group freertos-freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos-freertos_kernel-include
    ../../../../../rtos/freertos/freertos_kernel/include/: FreeRTOS.h StackMacros.h atomic.h croutine.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos-freertos_kernel-portable-MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos-freertos_kernel-portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group lwip-port-arch
    ../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip-port
    ../../../../../middleware/lwip/port/: sys_arch.c
  group lwip-src-api
    ../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-src-core
    ../../../../../middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip-src-core-ipv4
    ../../../../../middleware/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip-src-core-ipv6
    ../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip-src-include-compat-posix-arpa
    ../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip-src-include-compat-posix-net
    ../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip-src-include-compat-posix
    ../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip-src-include-compat-posix-sys
    ../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip-src-include-compat-stdc
    ../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip-src-include-lwip
    ../../../../../middleware/lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip-src-include-lwip-priv
    ../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group lwip-src-include-lwip-prot
    ../../../../../middleware/lwip/src/include/lwip/prot/: acd.h autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip-src-include-netif
    ../../../../../middleware/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lwip-src-include-netif-ppp
    ../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip-src-include-netif-ppp-polarssl
    ../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip-src-netif
    ../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip-src-netif-ppp
    ../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group utilities
    ../../../../../devices/MIMXRT685S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT685S/utilities/: fsl_assert.c
  group wifi-dhcpd
    ../../../../../middleware/wifi/dhcpd/: dhcp-bootp.h dhcp-priv.h dhcp-server-cli.c dhcp-server-main.c dhcp-server.c dns-server.c dns.h
  group wifi-incl
    ../../../../../middleware/wifi/incl/: dhcp-server.h wm_utils.h wmerrno.h wmlog.h wmtypes.h cli.h cli_utils.h iperf.h ping.h
  group wifi-incl-port-lwip
    ../../../../../middleware/wifi/incl/port/lwip/: wm_net.h
  group wifi-incl-port-os
    ../../../../../middleware/wifi/incl/port/os/: wm_os.h
  group wifi-incl-wifidriver
    ../../../../../middleware/wifi/incl/wifidriver/: mdev.h mdev_sdio.h wifi-decl.h wifi.h wifi_events.h
  group wifi-incl-wlcmgr
    ../../../../../middleware/wifi/incl/wlcmgr/: wlan.h wlan_11d.h wlan_tests.h
  group wifi-port-lwip
    ../../../../../middleware/wifi/port/lwip/: net.c netif_decl.h wifi_netif.c
  group wifi-port-os
    ../../../../../middleware/wifi/port/os/: os.c
  group wifi-wifi_bt_firmware
    ../../../../../middleware/wifi/wifi_bt_firmware/: sd8801_wlan.h sduart8977_wlan_bt.h
  group wifi-wifidriver-incl
    ../../../../../middleware/wifi/wifidriver/incl/: mlan.h mlan_11ac.h mlan_11h.h mlan_11n.h mlan_11n_aggr.h mlan_11n_rxreorder.h mlan_decl.h mlan_fw.h mlan_ieee.h mlan_init.h mlan_ioctl.h mlan_join.h mlan_main.h mlan_meas.h mlan_remap_mem_operations.h mlan_sdio.h mlan_uap.h mlan_util.h mlan_wmm.h mlan_wmsdk.h
  group wifi-wifidriver
    ../../../../../middleware/wifi/wifidriver/: mdev_sdio.c mlan_11ac.c mlan_11d.c mlan_11h.c mlan_11n.c mlan_11n_aggr.c mlan_11n_rxreorder.c mlan_cfp.c mlan_cmdevt.c mlan_glue.c mlan_init.c mlan_join.c mlan_misc.c mlan_scan.c mlan_shim.c mlan_sta_cmd.c mlan_sta_cmdresp.c mlan_sta_event.c mlan_sta_ioctl.c mlan_sta_rx.c mlan_txrx.c mlan_uap_cmdevent.c mlan_uap_ioctl.c mlan_wmm.c mlan_wmsdk.c wifi-debug.c wifi-debug.h wifi-internal.h wifi-mem.c wifi-sdio.c wifi-sdio.h wifi-uap.c wifi.c wifi_common.h wifi_pwrmgr.c
  group wifi-wlcmgr
    ../../../../../middleware/wifi/wlcmgr/: wlan.c wlan_txpwrlimit_cfg.c wlan_basic_cli.c wlan_tests.c
  group lwip-src-apps-lwiperf
    ../../../../../middleware/lwip/src/apps/lwiperf/: lwiperf.c
  group lwip-src-include-lwip-apps
    ../../../../../middleware/lwip/src/include/lwip/apps/: lwiperf.h
  group wifi-cli
    ../../../../../middleware/wifi/cli/: cli.c cli_mem.h cli_mem_simple.c cli_utils.c
  group wifi-nw_utils
    ../../../../../middleware/wifi/nw_utils/: iperf.c ping.c
  group drivers
    ../../../../../devices/MIMXRT685S/drivers/: fsl_usdhc.c fsl_usdhc.h fsl_i2c.c fsl_i2c.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_power.c fsl_power.h fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_iopctl.h fsl_gpio.c fsl_gpio.h fsl_reset.c fsl_reset.h
  group sdmmc
    ../../../../../middleware/sdmmc/sdio/: ChangeLogKSDK.txt
  group sdmmc-src
    ../../../../../middleware/sdmmc/sdio/: fsl_sdio.c
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc-inc
    ../../../../../middleware/sdmmc/sdio/: fsl_sdio.h
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.h fsl_sdmmc_spec.h
  group sdmmc-host
    ../../../../../middleware/sdmmc/host/usdhc/: ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h
    ../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group freertos-freertos_kernel-portable-GCC-ARM_CM33_NTZ-non_secure
    ../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c portasm.h portmacro.h
  group pmic_driver
    ../../../../../components/pca9420/: fsl_pca9420.c fsl_pca9420.h
  group device
    ../../../../../devices/MIMXRT685S/: MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h fsl_device_registers.h system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group component-uart
    ../../../../../components/uart/: uart.h usart_adapter.c
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MIMXRT685S/arm/: startup_MIMXRT685S_cm33.S
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
  group sdmmc-osa
    ../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.c fsl_sdmmc_osa.h
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction_free_rtos.h
target wifi_cli flash_debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: wifi_cli.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, USE_RTOS=1, WIFI_BOARD_PAN9026_SDIO, PRINTF_ADVANCED_ENABLE=1, FSL_RTOS_FREE_RTOS, SDIO_ENABLED, SDK_I2C_BASED_COMPONENT_USED=1, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: DEBUG
  asm include: as above
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_flash.scf
  link misc: --remove --keep=*(CodeQuickAccess) --keep=*(.flash_conf) --predefine="-D__stack_size__=0x400" --predefine="-D__heap_size__=0x400"
target wifi_cli release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: wifi_cli.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, USE_RTOS=1, WIFI_BOARD_PAN9026_SDIO, PRINTF_ADVANCED_ENABLE=1, FSL_RTOS_FREE_RTOS, SDIO_ENABLED, SDK_I2C_BASED_COMPONENT_USED=1, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG
  asm include: as above
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_ram.scf
  link misc: as above
target wifi_cli flash_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: wifi_cli.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, USE_RTOS=1, WIFI_BOARD_PAN9026_SDIO, PRINTF_ADVANCED_ENABLE=1, FSL_RTOS_FREE_RTOS, SDIO_ENABLED, SDK_I2C_BASED_COMPONENT_USED=1, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG
  asm include: as above
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_flash.scf
  link misc: as above
