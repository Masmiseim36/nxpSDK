<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>wifi_ipv4_ipv6_echo_cm33</project>
        <configuration>flash_debug</configuration>
      </member>
      <member>
        <project>wifi_ipv4_ipv6_echo_cm33</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_debug</name>
      <member>
        <project>wifi_ipv4_ipv6_echo_cm33</project>
        <configuration>flash_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_release</name>
      <member>
        <project>wifi_ipv4_ipv6_echo_cm33</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/wifi_ipv4_ipv6_echo_cm33.ewp</path>
  </project>
</workspace>
