# IAR project fxas21002_poll.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../..; ..; ../../../../../../evkmimxrt685; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../devices/MIMXRT685S/drivers; ../../../../../../../devices/MIMXRT685S/cmsis_drivers; ../../../../../../../middleware/issdk/drivers/systick; ../../../../../../../middleware/issdk/drivers/gpio; ../../../../../../../middleware/issdk/drivers/gpio/i.mx/i.mxrt600; ../../../../../../../middleware/issdk/sensors; ../../../../../../../devices/MIMXRT685S; ../../../../../../../devices/MIMXRT685S/utilities/str; ../../../../../../../devices/MIMXRT685S/utilities/debug_console; ../../../../../../../components/uart; ../../../../../../evkmimxrt685/flash_config; ../../../../../../../components/serial_manager; ../../../../../../../components/lists; ../../../../../../../CMSIS/Driver/Include; ../../../../../../../devices/MIMXRT685S/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: EVKMIMXRT685-AGM01-FXAS21002-POLL.bin
  ILINK.IlinkOutputFile: fxas21002_poll.out
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_ram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../devices/MIMXRT685S/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
  group board
    ../../../../../: evkmimxrt685.c evkmimxrt685.h frdm_stbc_agm01_shield.h issdk_hal.h RTE_Device.h
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source
    ../: fxas21002_poll.c
  group doc
    ../: readme.txt readme.txt
  group drivers
    ../../../../../../../devices/MIMXRT685S/drivers/: fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_power.c fsl_power.h fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h fsl_dma.c fsl_dma.h fsl_i2c.c fsl_i2c.h fsl_i2c_dma.c fsl_i2c_dma.h fsl_spi.c fsl_spi.h fsl_spi_dma.c fsl_spi_dma.h fsl_usart.c fsl_usart.h fsl_usart_dma.c fsl_usart_dma.h fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_flexcomm.c fsl_flexcomm.h fsl_iopctl.h fsl_gpio.c fsl_gpio.h fsl_reset.c fsl_reset.h
    ../../../../../../../devices/MIMXRT685S/cmsis_drivers/: fsl_i2c_cmsis.c fsl_i2c_cmsis.h fsl_spi_cmsis.c fsl_spi_cmsis.h fsl_usart_cmsis.c fsl_usart_cmsis.h
  group utilities
    ../../../../../../../middleware/issdk/drivers/systick/: systick_utils.c systick_utils.h
    ../../../../../../../devices/MIMXRT685S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MIMXRT685S/utilities/: fsl_assert.c
  group gpio_driver
    ../../../../../../../middleware/issdk/drivers/gpio/: Driver_GPIO.h
    ../../../../../../../middleware/issdk/drivers/gpio/i.mx/i.mxrt600/: gpio_driver.c gpio_driver.h
  group interfaces
    ../../../../../../../middleware/issdk/sensors/: register_io_i2c.c register_io_i2c.h register_io_spi.c register_io_spi.h sensor_drv.h sensor_io_i2c.c sensor_io_i2c.h sensor_io_spi.c sensor_io_spi.h
  group sensors
    ../../../../../../../middleware/issdk/sensors/: fxas21002.h fxas21002_drv.c fxas21002_drv.h
  group device
    ../../../../../../../devices/MIMXRT685S/: MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h fsl_device_registers.h system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group component/uart
    ../../../../../../../components/uart/: uart.h usart_adapter.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
  group flash_config
    ../../../../../../evkmimxrt685/flash_config/: flash_config.c flash_config.h
  group startup
    ../../../../../../../devices/MIMXRT685S/iar/: startup_MIMXRT685S_cm33.s
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_I2C.h Driver_Common.h Driver_SPI.h Driver_USART.h
