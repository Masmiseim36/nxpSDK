# Keil uVision project fxos8700_fifo.uvprojx, settings and files
target fxos8700_fifo debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: fxos8700_fifo.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../..;..;../../../../../../../middleware/issdk/drivers/gpio/i.mx/i.mxrt600;../../../../../../../middleware/issdk/drivers/gpio;../../../../../../../devices/MIMXRT685S/drivers;../../../../../../../devices/MIMXRT685S/cmsis_drivers;../../../../../../../middleware/issdk/drivers/systick;../../../../../../../middleware/issdk/sensors;../../../../../../../devices/MIMXRT685S;../../../../../../../devices/MIMXRT685S/utilities/str;../../../../../../../devices/MIMXRT685S/utilities/debug_console;../../../../../../../components/uart;../../../../../../evkmimxrt685/flash_config;../../../../../../../components/serial_manager;../../../../../../../components/lists;../../../../../../../CMSIS/Core/Include;../../../../../../../CMSIS/Driver/Include
  asm define: DEBUG
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_ram.scf
  link misc: --remove --entry=Reset_Handler
  group board
    ../../../../../: evkmimxrt685.c evkmimxrt685.h frdm_stbc_agm01_shield.h issdk_hal.h RTE_Device.h
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source
    ../: fxos8700_fifo.c
  group doc
    ../: readme.txt readme.txt
  group gpio_driver
    ../../../../../../../middleware/issdk/drivers/gpio/i.mx/i.mxrt600/: gpio_driver.c gpio_driver.h
    ../../../../../../../middleware/issdk/drivers/gpio/: Driver_GPIO.h
  group drivers
    ../../../../../../../devices/MIMXRT685S/drivers/: fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_inputmux.h fsl_inputmux.c fsl_inputmux_connections.h fsl_dma.c fsl_dma.h fsl_i2c.h fsl_i2c.c fsl_i2c_dma.c fsl_i2c_dma.h fsl_spi.c fsl_spi.h fsl_spi_dma.c fsl_spi_dma.h fsl_usart.h fsl_usart.c fsl_usart_dma.h fsl_usart_dma.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c
    ../../../../../../../devices/MIMXRT685S/cmsis_drivers/: fsl_i2c_cmsis.h fsl_i2c_cmsis.c fsl_spi_cmsis.h fsl_spi_cmsis.c fsl_usart_cmsis.h fsl_usart_cmsis.c
  group utilities
    ../../../../../../../middleware/issdk/drivers/systick/: systick_utils.c systick_utils.h
    ../../../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MIMXRT685S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/MIMXRT685S/utilities/: fsl_assert.c
  group interfaces
    ../../../../../../../middleware/issdk/sensors/: register_io_i2c.c register_io_spi.c sensor_io_spi.c sensor_io_i2c.c register_io_i2c.h register_io_spi.h sensor_io_spi.h sensor_io_i2c.h sensor_drv.h
  group sensors
    ../../../../../../../middleware/issdk/sensors/: fxos8700.h fxos8700_drv.h fxos8700_drv.c
  group device
    ../../../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group flash_config
    ../../../../../../evkmimxrt685/flash_config/: flash_config.c flash_config.h
  group component/serial_manager
    ../../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group MIMXRT685S
    ../../../../../../../devices/MIMXRT685S/: system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group MIMXRT685S/arm
    ../../../../../../../devices/MIMXRT685S/arm/: startup_MIMXRT685S_cm33.S
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_I2C.h Driver_Common.h Driver_SPI.h Driver_USART.h
target fxos8700_fifo flash_debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: fxos8700_fifo.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: DEBUG
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_flash.scf
  link misc: --remove --keep=*(CodeQuickAccess) --entry=Reset_Handler
target fxos8700_fifo release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: fxos8700_fifo.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_ram.scf
  link misc: --remove --entry=Reset_Handler
target fxos8700_fifo flash_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: fxos8700_fifo.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_flash.scf
  link misc: --remove --keep=*(CodeQuickAccess) --entry=Reset_Handler
