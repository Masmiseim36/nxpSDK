# IAR project usb_pd_charger_battery_freertos.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: _DEBUG=1; DEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; SDK_OS_FREE_RTOS; USB_STACK_FREERTOS_HEAP_SIZE=8192; I2C_RETRY_TIMES=40000; SERIAL_PORT_TYPE_UART=1; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../evkmimxrt685; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../middleware/usb/pd/ptn5110; ../../../../../../middleware/usb/pd; ../../../../../../middleware/usb/pd/phy_interface; ../../../../../../components/osa; ../../../../../../devices/MIMXRT685S; ../../../../../../devices/MIMXRT685S/utilities/str; ../../../../../../devices/MIMXRT685S/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../evkmimxrt685/flash_config; ../../../../../../components/i2c; ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../../components/gpio; ../../../../../../components/timer; ../../../../../../CMSIS/Core/Include; ../../../../../../middleware/usb/include; ../../../../../../rtos/freertos/freertos_kernel/include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..; ../../../../../evkmimxrt685
  ILINK.IlinkOutputFile: usb_pd_charger_battery_freertos.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x1000
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; SDK_OS_FREE_RTOS; USB_STACK_FREERTOS_HEAP_SIZE=8192; I2C_RETRY_TIMES=40000; SERIAL_PORT_TYPE_UART=1; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; NDEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; SDK_OS_FREE_RTOS; USB_STACK_FREERTOS_HEAP_SIZE=8192; I2C_RETRY_TIMES=40000; SERIAL_PORT_TYPE_UART=1; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; SDK_OS_FREE_RTOS; USB_STACK_FREERTOS_HEAP_SIZE=8192; I2C_RETRY_TIMES=40000; SERIAL_PORT_TYPE_UART=1; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
  group doc
    ../: readme.txt
  group source
    ../: pd_board_config.h pd_app_demo.c pd_app.c pd_app.h pd_command_app.c pd_command_interface.c pd_command_interface.h pd_power_app.c pd_power_interface.c pd_power_interface.h usb_pd_config.h pd_power_nx20p3483.c pd_power_nx20p3483.h FreeRTOSConfig.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group drivers
    ../../../../../../devices/MIMXRT685S/drivers/: fsl_mrt.h fsl_mrt.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c fsl_pint.h fsl_pint.c fsl_power.h fsl_power.c fsl_cache.c fsl_cache.h fsl_inputmux.h fsl_inputmux.c fsl_i2c.h fsl_i2c.c fsl_reset.h fsl_reset.c fsl_flexspi.c fsl_flexspi.h fsl_inputmux_connections.h
  group usb/ptn5110
    ../../../../../../middleware/usb/pd/ptn5110/: usb_pd_ptn5110.h usb_pd_ptn5110_connect.c usb_pd_ptn5110_hal.c usb_pd_ptn5110_interface.c usb_pd_ptn5110_msg.c usb_pd_ptn5110_register.h
  group usb/pd
    ../../../../../../middleware/usb/pd/: usb_pd.h usb_pd_interface.h usb_pd_phy.h usb_pd_spec.h usb_pd_timer.c usb_pd_timer.h usb_pd.h usb_pd_connect.c usb_pd_interface.h usb_pd_interface.c usb_pd_msg.c usb_pd_phy.h usb_pd_policy.c usb_pd_spec.h usb_pd_timer.c usb_pd_timer.h usb_pd_auto_policy.h
  group usb/phy_interface
    ../../../../../../middleware/usb/pd/phy_interface/: usb_pd_i2c.h usb_pd_i2c.c
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group freertos/freertos_kernel
    ../../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.h portasm.s portmacro.h
  group freertos/freertos_kernel/include
    ../../../../../../rtos/freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/i2c
    ../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_flexcomm_i2c.c
  group component/gpio
    ../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_lpc_gpio.c
  group component/timer
    ../../../../../../components/timer/: fsl_adapter_timer.h fsl_adapter_mrt.c
  group device
    ../../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h
  group utilities
    ../../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT685S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT685S/utilities/: fsl_assert.c
  group flash_config
    ../../../../../evkmimxrt685/flash_config/: flash_config.c flash_config.h
  group MIMXRT685S
    ../../../../../../devices/MIMXRT685S/: system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group MIMXRT685S/iar
    ../../../../../../devices/MIMXRT685S/iar/: startup_MIMXRT685S_cm33.s
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
