# Keil uVision project led_control_bm.uvprojx, settings and files
target led_control_bm debug (ARM-ADS)
  device: MK22FN512VLH12 NXP
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: led_control_bm.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MK22FN512VLH12, USB_STACK_BM=1, FSL_OSA_TASK_ENABLE=1, FRDM_K22F, FREEDOM, DEBUG_CONSOLE_RX_ENABLE=0, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../devices/MK22F51212/drivers;../../../../../../components/pwm;../../../../../../devices/MK22F51212/utilities;../../../../../../components/led;../../../../../../components/timer_manager;../../../../../../components/gpio;../../../../../../components/button;../../../../../../components/lists;../../../../../../components/timer;../../../../../../components/panic;../../../../../../components/serial_manager;../../../../../../components/osa;../../../../../../devices/MK22F51212;../../../../../../devices/MK22F51212/utilities/str;../../../../../../devices/MK22F51212/utilities/debug_console;../../../../../../components/uart;../../../../../../CMSIS/Include
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
  group source
    ../: led_control.c
  group board
    ../: pin_mux.c pin_mux.h hardware_init.c app.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MK22F51212/drivers/: fsl_pit.c fsl_pit.h fsl_ftm.c fsl_ftm.h fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_smc.h fsl_smc.c
  group component/pwm
    ../../../../../../components/pwm/: fsl_adapter_pwm.h fsl_adapter_pwm_ftm.c
  group utilities
    ../../../../../../devices/MK22F51212/utilities/: fsl_shell.c fsl_shell.h fsl_assert.c
    ../../../../../../devices/MK22F51212/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MK22F51212/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group component/led
    ../../../../../../components/led/: fsl_component_led.h fsl_component_led.c
  group component/timer_manager
    ../../../../../../components/timer_manager/: fsl_component_timer_manager.h fsl_component_timer_manager.c
  group component/gpio
    ../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_gpio.c
  group component/button
    ../../../../../../components/button/: fsl_component_button.h fsl_component_button.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/timer
    ../../../../../../components/timer/: fsl_adapter_timer.h fsl_adapter_pit.c
  group component/panic
    ../../../../../../components/panic/: fsl_component_panic.h fsl_component_panic.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.c
  group device
    ../../../../../../devices/MK22F51212/: fsl_device_registers.h MK22F51212.h MK22F51212_features.h system_MK22F51212.c system_MK22F51212.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group startup
    ../../../../../../devices/MK22F51212/arm/: startup_MK22F51212.S
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
target led_control_bm release (ARM-ADS)
  device: MK22FN512VLH12 NXP
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: led_control_bm.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MK22FN512VLH12, USB_STACK_BM=1, FSL_OSA_TASK_ENABLE=1, FRDM_K22F, FREEDOM, DEBUG_CONSOLE_RX_ENABLE=0, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
