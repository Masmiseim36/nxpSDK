# Keil uVision project littlevgl_demo.uvprojx, settings and files
target littlevgl_demo debug (ARM-ADS)
  device: MK22FN512VLH12 NXP
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: littlevgl_demo.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MK22FN512VLH12, LV_CONF_INCLUDE_SIMPLE=1, FRDM_K22F, FREEDOM, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../rtos/amazon-freertos/freertos_kernel/portable/GCC/ARM_CM4F;..;../..;../../..;../../../../../middleware/littlevgl;../../../../../CMSIS/Include;../../../../../devices;../../../../../rtos/amazon-freertos/freertos_kernel/include;../../../../../components/ili9341;../../../../../components/ft6x06;../../../../../devices/MK22F51212/drivers;../../../../../devices/MK22F51212/drivers;../../../../../devices/MK22F51212/drivers;../../../../../devices/MK22F51212/drivers;../../../../../devices/MK22F51212/drivers;../../../../../devices/MK22F51212/drivers;../../../../../devices/MK22F51212/drivers;../../../../../devices/MK22F51212/drivers;../../../../../devices/MK22F51212/cmsis_drivers;../../../../../devices/MK22F51212/drivers;../../../../../devices/MK22F51212/drivers;../../../../../devices/MK22F51212/cmsis_drivers;../../../../../devices/MK22F51212/drivers;../../../../../devices/MK22F51212;../../../../../devices/MK22F51212/utilities/str;../../../../../devices/MK22F51212/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../components/serial_manager;../../../../../devices/MK22F51212/drivers;../../../../../devices/MK22F51212/drivers;../../../../../CMSIS/Driver/Include;../../../../../CMSIS/Driver/Include;../../../../../CMSIS/Driver/Include;../../../../../devices/MK22F51212/utilities
  asm define: DEBUG
  asm include: ..;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
  group board
    ../../: RTE_Device.h littlevgl_support.h littlevgl_support.c
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source
    ../: littlevgl_demo.c FreeRTOSConfig.h lv_conf.h lv_ex_conf.h
  group littlevgl-lv_examples/demo
    ../../../../../middleware/littlevgl/lv_examples/demo/: demo.c demo.h img_bubble_pattern.c
  group doc
    ../: readme.txt
  group lcd
    ../../../../../components/ili9341/: fsl_ili9341.c fsl_ili9341.h
  group touchpanel
    ../../../../../components/ft6x06/: fsl_ft6x06.c fsl_ft6x06.h
  group drivers
    ../../../../../devices/MK22F51212/drivers/: fsl_port.h fsl_clock.c fsl_clock.h fsl_gpio.c fsl_gpio.h fsl_lpuart.c fsl_lpuart.h fsl_edma.c fsl_edma.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_i2c.c fsl_i2c.h fsl_i2c_edma.c fsl_i2c_edma.h fsl_common.c fsl_common.h fsl_uart.c fsl_uart.h fsl_smc.c fsl_smc.h
    ../../../../../devices/MK22F51212/cmsis_drivers/: fsl_dspi_cmsis.c fsl_dspi_cmsis.h fsl_i2c_cmsis.c fsl_i2c_cmsis.h
  group amazon-freertos-freertos_kernel-portable-MemMang
    ../../../../../rtos/amazon-freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group littlevgl
    ../../../../../middleware/littlevgl/: lv_conf_checker.h lv_version.h lvgl.h
  group littlevgl-lv_core
    ../../../../../middleware/littlevgl/lv_core/: lv_group.c lv_group.h lv_indev.c lv_indev.h lv_lang.c lv_lang.h lv_obj.c lv_obj.h lv_refr.c lv_refr.h lv_style.c lv_style.h lv_vdb.c lv_vdb.h
  group littlevgl-lv_draw
    ../../../../../middleware/littlevgl/lv_draw/: lv_draw.c lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_line.c lv_draw_line.h lv_draw_rbasic.c lv_draw_rbasic.h lv_draw_rect.c lv_draw_rect.h lv_draw_triangle.c lv_draw_triangle.h lv_draw_vbasic.c lv_draw_vbasic.h
  group littlevgl-lv_fonts
    ../../../../../middleware/littlevgl/lv_fonts/: lv_font_builtin.c lv_font_builtin.h lv_font_dejavu_10.c lv_font_dejavu_10_cyrillic.c lv_font_dejavu_10_latin_sup.c lv_font_dejavu_20.c lv_font_dejavu_20_cyrillic.c lv_font_dejavu_20_latin_sup.c lv_font_dejavu_30.c lv_font_dejavu_30_cyrillic.c lv_font_dejavu_30_latin_sup.c lv_font_dejavu_40.c lv_font_dejavu_40_cyrillic.c lv_font_dejavu_40_latin_sup.c lv_font_monospace_8.c lv_font_symbol_10.c lv_font_symbol_20.c lv_font_symbol_30.c lv_font_symbol_40.c
  group littlevgl-lv_hal
    ../../../../../middleware/littlevgl/lv_hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group littlevgl-lv_misc
    ../../../../../middleware/littlevgl/lv_misc/: lv_anim.c lv_anim.h lv_area.c lv_area.h lv_circ.c lv_circ.h lv_color.c lv_color.h lv_font.c lv_font.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_symbol_def.h lv_task.c lv_task.h lv_templ.c lv_templ.h lv_txt.c lv_txt.h lv_ufs.c lv_ufs.h
  group littlevgl-lv_objx
    ../../../../../middleware/littlevgl/lv_objx/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnm.c lv_btnm.h lv_calendar.c lv_calendar.h lv_canvas.c lv_canvas.h lv_cb.c lv_cb.h lv_chart.c lv_chart.h lv_cont.c lv_cont.h lv_ddlist.c lv_ddlist.h lv_gauge.c lv_gauge.h lv_img.c lv_img.h lv_imgbtn.c lv_imgbtn.h lv_kb.c lv_kb.h lv_label.c lv_label.h lv_led.c lv_led.h lv_line.c lv_line.h lv_list.c lv_list.h lv_lmeter.c lv_lmeter.h lv_mbox.c lv_mbox.h lv_objx_templ.c lv_objx_templ.h lv_page.c lv_page.h lv_preload.c lv_preload.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_spinbox.c lv_spinbox.h lv_sw.c lv_sw.h lv_ta.c lv_ta.h lv_table.c lv_table.h lv_tabview.c lv_tabview.h lv_tileview.c lv_tileview.h lv_win.c lv_win.h
  group littlevgl-lv_themes
    ../../../../../middleware/littlevgl/lv_themes/: lv_theme.c lv_theme.h lv_theme_alien.c lv_theme_alien.h lv_theme_default.c lv_theme_default.h lv_theme_material.c lv_theme_material.h lv_theme_mono.c lv_theme_mono.h lv_theme_nemo.c lv_theme_nemo.h lv_theme_night.c lv_theme_night.h lv_theme_templ.c lv_theme_templ.h lv_theme_zen.c lv_theme_zen.h
  group device
    ../../../../../devices/MK22F51212/: MK22F51212.h MK22F51212_features.h fsl_device_registers.h system_MK22F51212.c system_MK22F51212.h
  group utilities
    ../../../../../devices/MK22F51212/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MK22F51212/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK22F51212/utilities/: fsl_assert.c
  group component-uart
    ../../../../../components/uart/: uart.h uart_adapter.c
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MK22F51212/arm/: startup_MK22F51212.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
  group CMSIS_driver
    ../../../../../CMSIS/Driver/Include/: Driver_I2C.h Driver_Common.h Driver_SPI.h
  group amazon-freertos-freertos_kernel
    ../../../../../rtos/amazon-freertos/freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos-freertos_kernel-include
    ../../../../../rtos/amazon-freertos/freertos_kernel/include/: FreeRTOS.h atomic.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group amazon-freertos-freertos_kernel-portable-GCC-ARM_CM4F
    ../../../../../rtos/amazon-freertos/freertos_kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group amazon-freertos-freertos_kernel-portable
    ../../../../../rtos/amazon-freertos/freertos_kernel/portable/: readme.txt
target littlevgl_demo release (ARM-ADS)
  device: MK22FN512VLH12 NXP
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: littlevgl_demo.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MK22FN512VLH12, LV_CONF_INCLUDE_SIMPLE=1, FRDM_K22F, FREEDOM, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: NDEBUG
  asm include: ..;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
