# IAR project erpc_remote_control.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 NXP MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK22FN512VLH12; FRDM_K22F; FREEDOM; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos/Source/portable/IAR/ARM_CM4F; ../../../../../CMSIS/Include; ../../../../../devices; ..; ../service; ../../../../../CMSIS/Driver/Include; ../../..; ../../../../../rtos/freertos/Source/include; ../../../../../devices/MK22F51212/drivers; ../../../../../devices/MK22F51212/cmsis_drivers; ../../../../../devices/MK22F51212; ../../../../../devices/MK22F51212/utilities/io; ../../../../../devices/MK22F51212/utilities/str; ../../../../../devices/MK22F51212/utilities/log; ../../../../../devices/MK22F51212/utilities; ../../../../../middleware/multicore/erpc/erpc_c/infra; ../../../../../middleware/multicore/erpc/erpc_c/port; ../../../../../middleware/multicore/erpc/erpc_c/setup; ../../../../../middleware/multicore/erpc/erpc_c/transports
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..; ../service; ../../../../../CMSIS/Driver/Include; ../../..
  ILINK.IlinkOutputFile: erpc_remote_control.out
  ILINK.IlinkIcfFile: MK22FN512xxx12_flash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK22FN512VLH12; FRDM_K22F; FREEDOM; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: app.srec
  group drivers
    ../../../../../CMSIS/Driver/Include/: Driver_Common.h Driver_USART.h
    ../../../../../devices/MK22F51212/drivers/: fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_uart.h fsl_uart.c fsl_uart_edma.h fsl_uart_edma.c fsl_dac.c fsl_dac.h fsl_flash.c fsl_flash.h fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c fsl_i2c.h fsl_i2c.c fsl_adc16.c fsl_adc16.h
    ../../../../../devices/MK22F51212/cmsis_drivers/: fsl_uart_cmsis.h fsl_uart_cmsis.c
  group source
    ../: remote_control.c FreeRTOSConfig.h erpc_config.h
  group erpc/service
    ../service/: erpc_crc16.h erpc_remote_control.erpc erpc_remote_control.h erpc_remote_control_app_0.h erpc_remote_control_app_0_server.h erpc_remote_control_app_0_server.cpp erpc_remote_control_app_1.h erpc_remote_control_app_1_client.cpp
  group erpc/infra
    ../../../../../middleware/multicore/erpc/erpc_c/infra/: arbitrated_client_manager.h arbitrated_client_manager.cpp client_manager.h client_manager.cpp simple_server.h simple_server.cpp server.h server.cpp transport_arbitrator.h transport_arbitrator.cpp erpc_version.h codec.h basic_codec.h transport.h message_buffer.h message_loggers.h erpc_common.h manually_constructed.h crc16.h basic_codec.cpp message_buffer.cpp message_loggers.cpp crc16.cpp framed_transport.h framed_transport.cpp
  group erpc/setup
    ../../../../../middleware/multicore/erpc/erpc_c/setup/: erpc_arbitrated_client_setup.h erpc_arbitrated_client_setup.cpp erpc_server_setup.h erpc_server_setup.cpp erpc_transport_setup.h erpc_mbf_setup.h erpc_setup_uart_cmsis.cpp erpc_setup_mbf_dynamic.cpp
  group erpc/port
    ../../../../../middleware/multicore/erpc/erpc_c/port/: erpc_threading.h erpc_threading_freertos.cpp erpc_port.h erpc_port_freertos.cpp erpc_config_internal.h
  group erpc/transports
    ../../../../../middleware/multicore/erpc/erpc_c/transports/: uart_cmsis_transport.h uart_cmsis_transport.cpp
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group accel
    ../: fsl_fxos.h fsl_fxos.c
  group CMSIS_driver
    ../../../../../CMSIS/Driver/Include/: Driver_USART.h Driver_Common.h
  group startup
    ../../../../../devices/MK22F51212/: system_MK22F51212.c system_MK22F51212.h
    ../../../../../devices/MK22F51212/iar/: startup_MK22F51212.s
  group utilities
    ../../../../../devices/MK22F51212/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MK22F51212/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MK22F51212/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK22F51212/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group freertos
    ../../../../../rtos/freertos/: FreeRTOS_for_Kinetis_SDK_v2.0.txt
  group freertos/portable
    ../../../../../rtos/freertos/Source/portable/MemMang/: heap_4.c
    ../../../../../rtos/freertos/Source/portable/: readme.txt
    ../../../../../rtos/freertos/Source/portable/IAR/ARM_CM4F/: fsl_tickless_systick.c fsl_tickless_generic.h port.c portasm.s portmacro.h
  group freertos/license
    ../../../../../rtos/freertos/License/: license.txt
  group freertos/include
    ../../../../../rtos/freertos/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h stdint.readme task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
  group freertos/source
    ../../../../../rtos/freertos/Source/: croutine.c list.c queue.c readme.txt tasks.c timers.c event_groups.c
