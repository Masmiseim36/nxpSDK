# Keil uVision project erpc_remote_control.uvprojx, settings and files
target erpc_remote_control Debug (ARM-ADS)
  device: MK22FN512VLH12 NXP
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: erpc_remote_control.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MK22FN512VLH12, FRDM_K22F, FREEDOM, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../rtos/freertos/Source/portable/RVDS/ARM_CM4F;../../../../../CMSIS/Include;../../../../../devices;..;../service;../../../../../CMSIS/Driver/Include;../../..;../../../../../rtos/freertos/Source/include;../../../../../devices/MK22F51212/drivers;../../../../../devices/MK22F51212/cmsis_drivers;../../../../../devices/MK22F51212;../../../../../devices/MK22F51212/utilities/io;../../../../../devices/MK22F51212/utilities/str;../../../../../devices/MK22F51212/utilities/log;../../../../../devices/MK22F51212/utilities;../../../../../middleware/multicore/erpc/erpc_c/infra;../../../../../middleware/multicore/erpc/erpc_c/port;../../../../../middleware/multicore/erpc/erpc_c/setup;../../../../../middleware/multicore/erpc/erpc_c/transports
  asm define: DEBUG
  asm include: ..;../service;../../../../../CMSIS/Driver/Include;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: --remove 
--muldefweak
  group drivers
    ../../../../../CMSIS/Driver/Include/: Driver_Common.h Driver_USART.h
    ../../../../../devices/MK22F51212/drivers/: fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_uart.h fsl_uart.c fsl_uart_edma.h fsl_uart_edma.c fsl_dac.c fsl_dac.h fsl_flash.c fsl_flash.h fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c fsl_i2c.h fsl_i2c.c fsl_adc16.c fsl_adc16.h
    ../../../../../devices/MK22F51212/cmsis_drivers/: fsl_uart_cmsis.h fsl_uart_cmsis.c
  group source
    ../: remote_control.c FreeRTOSConfig.h erpc_config.h
  group erpc-service
    ../service/: erpc_crc16.h erpc_remote_control.erpc erpc_remote_control.h erpc_remote_control_app_0.h erpc_remote_control_app_0_server.h erpc_remote_control_app_0_server.cpp erpc_remote_control_app_1.h erpc_remote_control_app_1_client.cpp
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group accel
    ../: fsl_fxos.h fsl_fxos.c
  group CMSIS_driver
    ../../../../../CMSIS/Driver/Include/: Driver_USART.h Driver_Common.h
  group startup
    ../../../../../devices/MK22F51212/: system_MK22F51212.c system_MK22F51212.h
    ../../../../../devices/MK22F51212/arm/: startup_MK22F51212.s
  group utilities
    ../../../../../devices/MK22F51212/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MK22F51212/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MK22F51212/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK22F51212/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group erpc-infra
    ../../../../../middleware/multicore/erpc/erpc_c/infra/: arbitrated_client_manager.h arbitrated_client_manager.cpp client_manager.h client_manager.cpp simple_server.h simple_server.cpp server.h server.cpp transport_arbitrator.h transport_arbitrator.cpp erpc_version.h codec.h basic_codec.h transport.h message_buffer.h message_loggers.h erpc_common.h manually_constructed.h crc16.h basic_codec.cpp message_buffer.cpp message_loggers.cpp crc16.cpp framed_transport.h framed_transport.cpp
  group erpc-setup
    ../../../../../middleware/multicore/erpc/erpc_c/setup/: erpc_arbitrated_client_setup.h erpc_arbitrated_client_setup.cpp erpc_server_setup.h erpc_server_setup.cpp erpc_transport_setup.h erpc_mbf_setup.h erpc_setup_uart_cmsis.cpp erpc_setup_mbf_dynamic.cpp
  group erpc-port
    ../../../../../middleware/multicore/erpc/erpc_c/port/: erpc_threading.h erpc_threading_freertos.cpp erpc_port.h erpc_port_freertos.cpp erpc_config_internal.h
  group erpc-transports
    ../../../../../middleware/multicore/erpc/erpc_c/transports/: uart_cmsis_transport.h uart_cmsis_transport.cpp
  group freertos-portable
    ../../../../../rtos/freertos/Source/portable/MemMang/: heap_4.c
    ../../../../../rtos/freertos/Source/portable/: readme.txt
    ../../../../../rtos/freertos/Source/portable/RVDS/ARM_CM4F/: fsl_tickless_systick.c fsl_tickless_generic.h port.c portmacro.h
  group freertos
    ../../../../../rtos/freertos/: FreeRTOS_for_Kinetis_SDK_v2.0.txt
  group freertos-license
    ../../../../../rtos/freertos/License/: license.txt
  group freertos-include
    ../../../../../rtos/freertos/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h stdint.readme task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
  group freertos-source
    ../../../../../rtos/freertos/Source/: croutine.c list.c queue.c readme.txt tasks.c timers.c event_groups.c
target erpc_remote_control Release (ARM-ADS)
  device: MK22FN512VLH12 NXP
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: erpc_remote_control.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MK22FN512VLH12, FRDM_K22F, FREEDOM, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm include: ..;../service;../../../../../CMSIS/Driver/Include;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: --remove 
--muldefweak
