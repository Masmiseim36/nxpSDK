# Keil uVision project freertos_percepio_snapshot.uvprojx, settings and files
target freertos_percepio_snapshot Debug (ARM-ADS)
  device: MK22FN512VLH12 NXP
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: freertos_percepio_snapshot.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MK22FN512VLH12, FRDM_K22F, FREEDOM, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../rtos/freertos/Source/portable/RVDS/ARM_CM4F;../../../../../../CMSIS/Include;../../../../../../devices;..;../GenericRecorderLibSrc/Include;../../../..;../../../../../../rtos/freertos/Source/include;../../../../../../devices/MK22F51212/drivers;../../../../../../devices/MK22F51212;../../../../../../devices/MK22F51212/utilities/io;../../../../../../devices/MK22F51212/utilities/str;../../../../../../devices/MK22F51212/utilities/log;../../../../../../devices/MK22F51212/utilities
  asm define: DEBUG
  asm include: ..;../GenericRecorderLibSrc/Include;../../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: --remove
  group source
    ../: main.c FreeRTOSConfig.h trcConfig.h
  group percepio
    ../GenericRecorderLibSrc/: trcUser.c trcKernelPortFreeRTOS.c trcKernel.c trcHardwarePort.c trcBase.c
  group percepio-Include
    ../GenericRecorderLibSrc/Include/: trcUser.h trcTypes.h trcKernelPort.h trcKernelHooks.h trcKernel.h trcHardwarePort.h trcBase.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MK22F51212/drivers/: fsl_clock.h fsl_clock.c fsl_flash.c fsl_flash.h fsl_common.h fsl_common.c fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c
  group startup
    ../../../../../../devices/MK22F51212/: system_MK22F51212.c system_MK22F51212.h
    ../../../../../../devices/MK22F51212/arm/: startup_MK22F51212.s
  group utilities
    ../../../../../../devices/MK22F51212/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../devices/MK22F51212/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../devices/MK22F51212/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MK22F51212/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group freertos
    ../../../../../../rtos/freertos/: FreeRTOS_for_Kinetis_SDK_v2.0.txt
  group freertos-license
    ../../../../../../rtos/freertos/License/: license.txt
  group freertos-include
    ../../../../../../rtos/freertos/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h stdint.readme task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
  group freertos-source
    ../../../../../../rtos/freertos/Source/: croutine.c list.c queue.c readme.txt tasks.c timers.c event_groups.c
  group freertos-portable
    ../../../../../../rtos/freertos/Source/portable/: readme.txt
    ../../../../../../rtos/freertos/Source/portable/RVDS/ARM_CM4F/: fsl_tickless_systick.c fsl_tickless_generic.h port.c portmacro.h
    ../../../../../../rtos/freertos/Source/portable/MemMang/: heap_4.c
target freertos_percepio_snapshot Release (ARM-ADS)
  device: MK22FN512VLH12 NXP
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: freertos_percepio_snapshot.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MK22FN512VLH12, FRDM_K22F, FREEDOM, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm include: ..;../GenericRecorderLibSrc/Include;../../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: --remove
