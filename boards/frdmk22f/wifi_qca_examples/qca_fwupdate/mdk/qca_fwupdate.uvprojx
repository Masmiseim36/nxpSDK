# Keil uVision project qca_fwupdate.uvprojx, settings and files
target qca_fwupdate debug (ARM-ADS)
  device: MK22FN512VLH12 NXP
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: qca_fwupdate.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MK22FN512VLH12, FRDM_K22F, FREEDOM, FSL_RTOS_FREE_RTOS, A_LITTLE_ENDIAN
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F;../../../../../CMSIS/Include;../../../../../devices;../../..;..;../../../../../rtos/amazon-freertos/lib/include;../../../../../rtos/amazon-freertos/lib/include/private;../uart;../../../../../middleware/wifi_qca/port/boards/frdmk22f/freertos/gt202;../../../../../middleware/wifi_qca/port/boards/frdmk22f/freertos;../../../../../middleware/wifi_qca/port/env/freertos;../../../../../middleware/wifi_qca;../../../../../middleware/wifi_qca/include;../../../../../middleware/wifi_qca/include/AR6002;../../../../../middleware/wifi_qca/include/AR6002/hw2.0/hw;../../../../../middleware/wifi_qca/include/AR6002/hw4.0/hw;../../../../../middleware/wifi_qca/custom_src/stack_custom;../../../../../middleware/wifi_qca/custom_src/include;../../../../../middleware/wifi_qca/common_src/include;../../../../../middleware/wifi_qca/common_src/stack_common;../../../../../middleware/wifi_qca/common_src/hcd;../../../../../middleware/wifi_qca/common_src/wmi;../../../../../middleware/wifi_qca/port;../../../../../middleware/wifi_qca/port/drivers/dspi_edma_freertos;../../../../../devices/MK22F51212/drivers;../../../../../middleware/wifi_qca/port/boards/frdmk22f/freertos/silex2401;../../../../../devices/MK22F51212;../../../../../devices/MK22F51212/utilities/io;../../../../../devices/MK22F51212/utilities/str;../../../../../devices/MK22F51212/utilities/log;../../../../../devices/MK22F51212/utilities
  asm define: DEBUG
  asm include: ../../..;..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: --remove
  group source/uart
    ../uart/: fw_serial.c
  group source
    ../: fw_serial.h FreeRTOSConfig.h main.c wlan_qca400x.c
  group board
    ../: pin_mux.c pin_mux.h
  group board-src
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group wifi_qca-port-shields-gt202
    ../../../../../middleware/wifi_qca/port/boards/frdmk22f/freertos/gt202/: wifi_shield_gt202.h
  group wifi_qca-port-shields
    ../../../../../middleware/wifi_qca/port/boards/frdmk22f/freertos/: wifi_shield.h wifi_shield.c
  group wifi_qca-port-env-freertos
    ../../../../../middleware/wifi_qca/port/env/freertos/: wifi_port.h wifi_env_port.h wifi_env.c wifi_env.h
  group amazon-freertos-license
    ../../../../../rtos/amazon-freertos/: LICENSE
  group amazon-freertos-include
    ../../../../../rtos/amazon-freertos/lib/include/: event_groups.h FreeRTOS.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
    ../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_wrappers.h portable.h projdefs.h stack_macros.h
  group amazon-freertos-FreeRTOS
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos-FreeRTOS-portable
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
  group amazon-freertos-portable
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F/: fsl_tickless_systick.c fsl_tickless_generic.h
  group wifi_qca-common_src-wmi
    ../../../../../middleware/wifi_qca/common_src/wmi/: wmi.c wmi_host.h
  group wifi_qca-common_src-stack_common
    ../../../../../middleware/wifi_qca/common_src/storerecall/: dset_api.c
    ../../../../../middleware/wifi_qca/common_src/stack_common/: common_stack_offload.h
  group wifi_qca-common_src-qapi
    ../../../../../middleware/wifi_qca/common_src/stack_common/: api_stack_offload.c
    ../../../../../middleware/wifi_qca/common_src/qapi/: qcom_api.c qcom_dns.c qcom_legacy.c
  group wifi_qca-common_src-include
    ../../../../../middleware/wifi_qca/common_src/include/: dset_api.h driver_cxt.h a_drv_api.h wlan_api.h wmi_api.h hif_internal.h dset.h dbglog_api.h common_api.h bmi.h aggr_recv_api.h a_drv.h a_debug.h spi_hcd_if.h netbuf.h ieee80211.h htc_api.h
  group wifi_qca-common_src-htc
    ../../../../../middleware/wifi_qca/common_src/htc/: htc.c
    ../../../../../middleware/wifi_qca/common_src/hcd/: spi_hcd.c
  group wifi_qca-common_src-driver
    ../../../../../middleware/wifi_qca/common_src/driver/: driver_main.c driver_txrx.c driver_netbuf.c driver_init.c driver_diag.c
  group wifi_qca-common_src-api_interface
    ../../../../../middleware/wifi_qca/common_src/api_interface/: api_wmi_rx.c api_ioctl.c api_txrx.c api_init.c
  group wifi_qca-common_src-hw_interface
    ../../../../../middleware/wifi_qca/common_src/hw_interface/: hw_api.c
  group wifi_qca-common_src-storerecall
    ../../../../../middleware/wifi_qca/common_src/storerecall/: dset.c storerecall.c
  group wifi_qca-common_src-hcd
    ../../../../../middleware/wifi_qca/common_src/hcd/: hcd_api.h
  group wifi_qca-common_src-bmi
    ../../../../../middleware/wifi_qca/common_src/bmi/: bmi.c
  group wifi_qca-common_src-util
    ../../../../../middleware/wifi_qca/common_src/util/: util.c
  group wifi_qca-common_src-reorder
    ../../../../../middleware/wifi_qca/common_src/reorder/: rcv_aggr.c
  group wifi_qca-custom_src-stack_custom
    ../../../../../middleware/wifi_qca/custom_src/stack_custom/: cust_api_stack_offload.c qca_structs.h custom_stack_offload.h cust_api_stack_txrx.c
  group wifi_qca-custom_src-qapi
    ../../../../../middleware/wifi_qca/custom_src/qapi/: custom_qcom_api.c
  group wifi_qca-custom_src-include
    ../../../../../middleware/wifi_qca/custom_src/include/: cust_netbuf.h a_osapi.h a_config.h wlan_config.h custom_wlan_api.h a_types.h
  group wifi_qca-custom_src-api_interface
    ../../../../../middleware/wifi_qca/custom_src/api_interface/: cust_api_wmi_rx.c cust_api_ioctl.c cust_api_txrx.c cust_api_init.c
  group wifi_qca-custom_src-driver
    ../../../../../middleware/wifi_qca/custom_src/driver/: cust_driver_netbuf.c cust_driver_main.c
  group wifi_qca-custom_src-hw_interface
    ../../../../../middleware/wifi_qca/custom_src/hw_interface/: cust_spi_hcd.c
  group wifi_qca-include
    ../../../../../middleware/wifi_qca/include/: wmi.h dbglog.h athdefs.h dbglog_id.h bmi_msg.h wlan_defs.h targaddrs.h pmu.h pkt_log.h p2p.h htc_services.h htc.h
    ../../../../../middleware/wifi_qca/: qcom_api.h atheros_stack_offload.h atheros_wifi_internal.h atheros_wifi_api.h atheros_wifi.h
  group wifi_qca-include-AR6002-hw2.0-hw
    ../../../../../middleware/wifi_qca/include/AR6002/hw2.0/hw/: hw20_gpio_reg.h hw20_apb_map.h hw20_vmc_reg.h hw20_uart_reg.h hw20_si_reg.h hw20_rtc_reg.h hw20_mbox_reg.h hw20_mbox_host_reg.h
  group wifi_qca-include-AR6002
    ../../../../../middleware/wifi_qca/include/AR6002/: AR6K_version.h
  group wifi_qca-include-AR6002-hw4.0-hw
    ../../../../../middleware/wifi_qca/include/AR6002/hw4.0/hw/: hw40_rtc_wlan_reg.h hw40_rtc_reg.h
  group wifi_qca-port
    ../../../../../middleware/wifi_qca/port/: wifi_common.h
  group wifi_qca-port-drivers-dspi_edma_freertos
    ../../../../../middleware/wifi_qca/port/drivers/dspi_edma_freertos/: wifi_spi.h wifi_spi.c
  group drivers
    ../../../../../devices/MK22F51212/drivers/: fsl_dspi.h fsl_dspi.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_dspi_edma.h fsl_dspi_edma.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_uart.h fsl_uart.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_lpuart.h fsl_lpuart.c fsl_smc.h fsl_smc.c
  group wifi_qca-port-shields-silex2401
    ../../../../../middleware/wifi_qca/port/boards/frdmk22f/freertos/silex2401/: wifi_shield_silex2401.h
  group drivers-freertos
    ../../../../../devices/MK22F51212/drivers/: fsl_uart_freertos.h fsl_uart_freertos.c
  group startup
    ../../../../../devices/MK22F51212/: system_MK22F51212.c system_MK22F51212.h
    ../../../../../devices/MK22F51212/arm/: startup_MK22F51212.s
  group utilities
    ../../../../../devices/MK22F51212/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MK22F51212/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MK22F51212/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK22F51212/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
target qca_fwupdate release (ARM-ADS)
  device: MK22FN512VLH12 NXP
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: qca_fwupdate.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MK22FN512VLH12, FRDM_K22F, FREEDOM, FSL_RTOS_FREE_RTOS, A_LITTLE_ENDIAN
  c misc: as above
  c include: as above
  asm define: NDEBUG
  asm include: ../../..;..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: --remove
