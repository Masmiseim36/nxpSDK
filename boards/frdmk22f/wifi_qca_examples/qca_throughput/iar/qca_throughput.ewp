# IAR project qca_throughput.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 NXP MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK22FN512VLH12; SHELL_MAX_CMD=24; SHELL_NON_BLOCKING_MODE=0; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING=1; FRDM_K22F; FREEDOM; A_LITTLE_ENDIAN; SDK_DEBUGCONSOLE_UART; DEBUG_CONSOLE_RX_ENABLE=0; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/amazon-freertos/freertos_kernel/portable/IAR/ARM_CM4F; ../../..; ..; ../custom; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../rtos/amazon-freertos/freertos_kernel/include; ../../../../../middleware/wifi_qca/port/boards/frdmk22f/freertos/gt202; ../../../../../middleware/wifi_qca/port/boards/frdmk22f/freertos/silex2401; ../../../../../middleware/wifi_qca; ../../../../../middleware/wifi_qca/include; ../../../../../middleware/wifi_qca/include/AR6002; ../../../../../middleware/wifi_qca/include/AR6002/hw2.0/hw; ../../../../../middleware/wifi_qca/include/AR6002/hw4.0/hw; ../../../../../middleware/wifi_qca/custom_src/stack_custom; ../../../../../middleware/wifi_qca/custom_src/include; ../../../../../middleware/wifi_qca/common_src/include; ../../../../../middleware/wifi_qca/common_src/stack_common; ../../../../../middleware/wifi_qca/common_src/hcd; ../../../../../middleware/wifi_qca/common_src/wmi; ../../../../../middleware/wifi_qca/port; ../../../../../devices/MK22F51212/utilities; ../../../../../devices/MK22F51212/drivers; ../../../../../devices/MK22F51212/drivers; ../../../../../devices/MK22F51212; ../../../../../devices/MK22F51212/utilities/str; ../../../../../devices/MK22F51212/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../components/serial_manager; ../../../../../devices/MK22F51212/drivers; ../../../../../devices/MK22F51212/drivers; ../../../../../devices/MK22F51212/drivers; ../../../../../devices/MK22F51212/drivers; ../../../../../devices/MK22F51212/drivers; ../../../../../middleware/wifi_qca/port/boards/frdmk22f/freertos; ../../../../../middleware/wifi_qca/port/env/freertos; ../../../../../middleware/wifi_qca/port/drivers/dspi_edma_freertos; ../../../../../devices/MK22F51212/drivers; ../../../../../devices/MK22F51212/drivers; ../../../../../devices/MK22F51212/drivers; ../../../../../devices/MK22F51212/drivers; ../../../../../devices/MK22F51212/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../..; ..; ../custom
  ILINK.IlinkOutputFile: qca_throughput.out
  ILINK.IlinkIcfFile: MK22FN512xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK22FN512VLH12; SHELL_MAX_CMD=24; SHELL_NON_BLOCKING_MODE=0; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING=1; FRDM_K22F; FREEDOM; A_LITTLE_ENDIAN; SDK_DEBUGCONSOLE_UART; DEBUG_CONSOLE_RX_ENABLE=0; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: main.c FreeRTOSConfig.h wlan_qca400x.c wlan_qcom.h
  group source/common
    ../common/: wmiconfig_qapi.c
  group source/custom
    ../custom/: calist-kingfisher-inc.h cert-kingfisher-inc.h Command_Lists.c https.c https.h main.h shell_config.h task_manager.c throughput.h throughput_qapi.c usb_classes.h utils.c wmiconfig_custom_qapi.c worker_shell.h
  group source/driver_plugin
    ../driver_plugin/: atheros_wifi_mediactl_ext.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group wifi_qca
    ../../../../../middleware/wifi_qca/: ChangeLogKSDK.txt atheros_stack_offload.h atheros_wifi.h atheros_wifi_api.h atheros_wifi_internal.h license.txt qcom_api.h
  group wifi_qca/port
    ../../../../../middleware/wifi_qca/port/: wifi_common.h wifi_shield_common.h
  group wifi_qca/port/boards/frdmk22f/freertos
    ../../../../../middleware/wifi_qca/port/boards/frdmk22f/freertos/: wifi_shield.c wifi_shield.h
  group wifi_qca/port/boards/frdmk22f/freertos/gt202
    ../../../../../middleware/wifi_qca/port/boards/frdmk22f/freertos/gt202/: wifi_shield_gt202.h
  group wifi_qca/port/boards/frdmk22f/freertos/silex2401
    ../../../../../middleware/wifi_qca/port/boards/frdmk22f/freertos/silex2401/: wifi_shield_silex2401.h
  group wifi_qca/port/env/freertos
    ../../../../../middleware/wifi_qca/port/env/freertos/: wifi_env.c wifi_env.h wifi_env_port.h wifi_port.h
  group wifi_qca/port/drivers/dspi_edma_freertos
    ../../../../../middleware/wifi_qca/port/drivers/dspi_edma_freertos/: wifi_spi.c wifi_spi.h
  group wifi_qca/common_src/api_interface
    ../../../../../middleware/wifi_qca/common_src/api_interface/: api_init.c api_ioctl.c api_txrx.c api_wmi_rx.c
  group wifi_qca/common_src/bmi
    ../../../../../middleware/wifi_qca/common_src/bmi/: bmi.c
  group wifi_qca/common_src/driver
    ../../../../../middleware/wifi_qca/common_src/driver/: driver_diag.c driver_init.c driver_main.c driver_netbuf.c driver_txrx.c
  group wifi_qca/common_src/hcd
    ../../../../../middleware/wifi_qca/common_src/hcd/: hcd_api.h spi_hcd.c
  group wifi_qca/common_src/htc
    ../../../../../middleware/wifi_qca/common_src/htc/: htc.c
  group wifi_qca/common_src/hw_interface
    ../../../../../middleware/wifi_qca/common_src/hw_interface/: hw_api.c
  group wifi_qca/common_src/include
    ../../../../../middleware/wifi_qca/common_src/include/: a_debug.h a_drv.h a_drv_api.h aggr_recv_api.h bmi.h common_api.h dbglog_api.h driver_cxt.h dset.h dset_api.h hif_internal.h htc_api.h ieee80211.h netbuf.h spi_hcd_if.h wlan_api.h wmi_api.h
  group wifi_qca/common_src/qapi
    ../../../../../middleware/wifi_qca/common_src/qapi/: qcom_api.c qcom_dns.c qcom_legacy.c
  group wifi_qca/common_src/reorder
    ../../../../../middleware/wifi_qca/common_src/reorder/: rcv_aggr.c
  group wifi_qca/common_src/stack_common
    ../../../../../middleware/wifi_qca/common_src/stack_common/: api_stack_offload.c common_stack_offload.h
  group wifi_qca/common_src/storerecall
    ../../../../../middleware/wifi_qca/common_src/storerecall/: dset.c dset_api.c storerecall.c
  group wifi_qca/common_src/util
    ../../../../../middleware/wifi_qca/common_src/util/: util.c
  group wifi_qca/common_src/wmi
    ../../../../../middleware/wifi_qca/common_src/wmi/: wmi.c wmi_host.h
  group wifi_qca/custom_src/api_interface
    ../../../../../middleware/wifi_qca/custom_src/api_interface/: cust_api_init.c cust_api_ioctl.c cust_api_txrx.c cust_api_wmi_rx.c
  group wifi_qca/custom_src/driver
    ../../../../../middleware/wifi_qca/custom_src/driver/: cust_driver_main.c cust_driver_netbuf.c
  group wifi_qca/custom_src/hw_interface
    ../../../../../middleware/wifi_qca/custom_src/hw_interface/: cust_spi_hcd.c
  group wifi_qca/custom_src/include
    ../../../../../middleware/wifi_qca/custom_src/include/: a_config.h a_osapi.h a_types.h cust_netbuf.h custom_wlan_api.h wlan_config.h
  group wifi_qca/custom_src/qapi
    ../../../../../middleware/wifi_qca/custom_src/qapi/: custom_qcom_api.c
  group wifi_qca/custom_src/stack_custom
    ../../../../../middleware/wifi_qca/custom_src/stack_custom/: cust_api_stack_offload.c cust_api_stack_txrx.c custom_stack_offload.h qca_structs.h
  group wifi_qca/include
    ../../../../../middleware/wifi_qca/include/: athdefs.h bmi_msg.h dbglog.h dbglog_id.h htc.h htc_services.h p2p.h pkt_log.h pmu.h targaddrs.h wlan_defs.h wmi.h
  group wifi_qca/include/AR6002
    ../../../../../middleware/wifi_qca/include/AR6002/: AR6K_version.h
  group wifi_qca/include/AR6002/hw2.0/hw
    ../../../../../middleware/wifi_qca/include/AR6002/hw2.0/hw/: hw20_apb_map.h hw20_gpio_reg.h hw20_mbox_host_reg.h hw20_mbox_reg.h hw20_rtc_reg.h hw20_si_reg.h hw20_uart_reg.h hw20_vmc_reg.h
  group wifi_qca/include/AR6002/hw4.0/hw
    ../../../../../middleware/wifi_qca/include/AR6002/hw4.0/hw/: hw40_rtc_reg.h hw40_rtc_wlan_reg.h
  group amazon-freertos/freertos_kernel
    ../../../../../rtos/amazon-freertos/freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos/freertos_kernel/portable
    ../../../../../rtos/amazon-freertos/freertos_kernel/portable/: readme.txt
  group amazon-freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/amazon-freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group amazon-freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../rtos/amazon-freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group amazon-freertos/freertos_kernel/include
    ../../../../../rtos/amazon-freertos/freertos_kernel/include/: FreeRTOS.h atomic.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group utilities
    ../../../../../devices/MK22F51212/utilities/: fsl_shell.c fsl_shell.h fsl_assert.c
    ../../../../../devices/MK22F51212/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MK22F51212/utilities/str/: fsl_str.c fsl_str.h
  group drivers
    ../../../../../devices/MK22F51212/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_uart.c fsl_uart.h fsl_lpuart.c fsl_lpuart.h fsl_port.h fsl_smc.c fsl_smc.h fsl_gpio.c fsl_gpio.h fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_edma.c fsl_edma.h fsl_dmamux.c fsl_dmamux.h
  group device
    ../../../../../devices/MK22F51212/: MK22F51212.h MK22F51212_features.h fsl_device_registers.h system_MK22F51212.c system_MK22F51212.h
  group component/uart
    ../../../../../components/uart/: uart.h uart_adapter.c
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MK22F51212/iar/: startup_MK22F51212.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
