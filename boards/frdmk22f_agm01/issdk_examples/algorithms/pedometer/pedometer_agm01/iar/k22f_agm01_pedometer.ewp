# IAR project k22f_agm01_pedometer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 NXP MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK22FN512VLH12; FRDM_K22F; FREEDOM; PRINTF_ADVANCED_ENABLE
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../platform/drivers; ../../../../../../../middleware/issdk_1.5/drivers/gpio; ../../../../../../../middleware/issdk_1.5/drivers/systick; ../../../../../../../CMSIS/Driver/Include; ../../../../../../../middleware/issdk_1.5/sensors; ../../../../../../../middleware/issdk_1.5/algorithms/pedometer/include; ../../../../../../../middleware/issdk_1.5/algorithms/pedometer/include/libinclude; ../../../../..; ..; ../../../../../../frdmk22f; ../../../../../../../devices/MK22F51212/drivers; ../../../../../../../devices/MK22F51212/cmsis_drivers; ../../../../../../../devices/MK22F51212/utilities; ../../../../../../../devices/MK22F51212
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: K22F-AGM01-PEDOMETER.bin
  ILINK.IlinkOutputFile: k22f_agm01_pedometer.out
  ILINK.IlinkIcfFile: MK22FN512xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../middleware/issdk_1.5/algorithms/pedometer/lib/LibPedometer_m4.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK22FN512VLH12; FRDM_K22F; FREEDOM; PRINTF_ADVANCED_ENABLE
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../../devices/MK22F51212/iar/: startup_MK22F51212.s
    ../../../../../../../devices/MK22F51212/: system_MK22F51212.c system_MK22F51212.h
  group doc
    ../: readme.txt
  group board
    ../../../../../: frdm_k22f.c frdm_k22f.h frdm_stbc_agm01_shield.h issdk_hal.h RTE_Device.h
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group sensors
    ../../../../../../../middleware/issdk_1.5/sensors/: sensor_drv.h fxos8700_drv.h fxos8700_drv.c fxos8700.h
    ../../../../../../../middleware/issdk_1.5/algorithms/pedometer/source/: pedometer.c
    ../../../../../../../middleware/issdk_1.5/algorithms/pedometer/include/: pedometer.h
    ../../../../../../../middleware/issdk_1.5/algorithms/pedometer/include/libinclude/: KeynetikPedometer.h
    ../../../../../../../middleware/issdk_1.5/algorithms/pedometer/examples/: pedometer_stepcount_fxos8700.c
  group utilities
    ../../../../../../../middleware/issdk_1.5/drivers/systick/: systick_utils.c systick_utils.h
    ../../../../../../../devices/MK22F51212/utilities/: fsl_debug_console.c fsl_debug_console.h
  group drivers
    ../../../../../../../devices/MK22F51212/drivers/: fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_i2c.h fsl_i2c.c fsl_dmamux.h fsl_dmamux.c fsl_smc.h fsl_smc.c fsl_pit.c fsl_pit.h fsl_edma.h fsl_edma.c fsl_i2c_edma.c fsl_i2c_edma.h fsl_uart_edma.h fsl_uart_edma.c fsl_common.h fsl_common.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
    ../../../../../../../devices/MK22F51212/cmsis_drivers/: fsl_i2c_cmsis.h fsl_i2c_cmsis.c fsl_uart_cmsis.h fsl_uart_cmsis.c
  group gpio_driver
    ../../../../../../../middleware/issdk_1.5/drivers/gpio/: gpio_driver_irq.c gpio_driver.c gpio_driver.h Driver_GPIO.h
  group interface
    ../../../../../../../middleware/issdk_1.5/sensors/: register_io_i2c.c register_io_i2c.h sensor_io_i2c.c sensor_io_i2c.h register_io_spi.c register_io_spi.h sensor_io_spi.c sensor_io_spi.h
