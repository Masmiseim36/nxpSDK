<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>k22f_agm01_pedometer</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>k22f_agm01_pedometer</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>k22f_agm01_pedometer</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>k22f_agm01_pedometer</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/k22f_agm01_pedometer.ewp</path>
  </project>
</workspace>
