# IAR project sensorfusion_freertos_agmp03.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 NXP MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK22FN512VLH12; FRDM_K22F; FREEDOM; PRINTF_ADVANCED_ENABLE; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../../rtos/freertos/Source/portable/IAR/ARM_CM4F; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../platform/drivers; ../../../../../../frdmk22f; ../../../../..; ..; ../../../../../../../rtos/freertos/Source/include; ../../../../../../../devices/MK22F51212/drivers; ../../../../../../../devices/MK22F51212; ../../../../../../../devices/MK22F51212/utilities/io; ../../../../../../../devices/MK22F51212/utilities/str; ../../../../../../../devices/MK22F51212/utilities/log; ../../../../../../../devices/MK22F51212/utilities; ../../../../../../../devices/MK22F51212/cmsis_drivers; ../../../../../../../CMSIS/Driver/Include; ../../../../../../../middleware/issdk/drivers/systick; ../../../../../../../middleware/issdk/drivers/gpio; ../../../../../../../middleware/issdk/drivers/gpio/kinetis; ../../../../../../../middleware/issdk/algorithms/sensorfusion/sources; ../../../../../../../middleware/issdk/sensors
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: K22F-AGMP03-SENSORFUSION-FREERTOS.bin
  ILINK.IlinkOutputFile: sensorfusion_freertos_agmp03.out
  ILINK.IlinkIcfFile: MK22FN512xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK22FN512VLH12; FRDM_K22F; FREEDOM; PRINTF_ADVANCED_ENABLE; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  group board
    ../../../../../: frdm_k22f.c frdm_k22f.h frdm_stbc_agmp03_shield.h issdk_hal.h RTE_Device.h
    ../: pin_mux.c pin_mux.h clock_config.c clock_config.h board.c board.h
  group source
    ../: build.h FreeRTOSConfig.h main_agmp03_freertos_two_tasks.c
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MK22F51212/drivers/: fsl_clock.h fsl_clock.c fsl_flash.c fsl_flash.h fsl_common.h fsl_common.c fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c fsl_uart_edma.h fsl_uart_edma.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_i2c.h fsl_i2c.c fsl_i2c_edma.c fsl_i2c_edma.h fsl_dspi.h fsl_dspi.c fsl_dspi_edma.h fsl_dspi_edma.c fsl_pit.c fsl_pit.h
    ../../../../../../../devices/MK22F51212/cmsis_drivers/: fsl_uart_cmsis.h fsl_uart_cmsis.c fsl_i2c_cmsis.h fsl_i2c_cmsis.c fsl_dspi_cmsis.h fsl_dspi_cmsis.c
  group drivers/freertos
    ../../../../../../../devices/MK22F51212/drivers/: fsl_i2c_freertos.h fsl_i2c_freertos.c
  group startup
    ../../../../../../../devices/MK22F51212/: system_MK22F51212.c system_MK22F51212.h
    ../../../../../../../devices/MK22F51212/iar/: startup_MK22F51212.s
  group utilities
    ../../../../../../../devices/MK22F51212/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../../devices/MK22F51212/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../../devices/MK22F51212/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MK22F51212/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
    ../../../../../../../middleware/issdk/drivers/systick/: systick_utils.c systick_utils.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_USART.h Driver_Common.h Driver_I2C.h Driver_SPI.h
  group freertos
    ../../../../../../../rtos/freertos/: FreeRTOS_for_Kinetis_SDK_v2.0.txt
  group freertos/license
    ../../../../../../../rtos/freertos/License/: license.txt
  group freertos/include
    ../../../../../../../rtos/freertos/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h stdint.readme task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
  group freertos/source
    ../../../../../../../rtos/freertos/Source/: croutine.c list.c queue.c readme.txt tasks.c timers.c event_groups.c
  group freertos/portable
    ../../../../../../../rtos/freertos/Source/portable/: readme.txt
    ../../../../../../../rtos/freertos/Source/portable/IAR/ARM_CM4F/: fsl_tickless_systick.c fsl_tickless_generic.h port.c portasm.s portmacro.h
    ../../../../../../../rtos/freertos/Source/portable/MemMang/: heap_1.c
  group gpio_driver
    ../../../../../../../middleware/issdk/drivers/gpio/kinetis/: gpio_driver_irq.c gpio_driver.c gpio_driver.h
    ../../../../../../../middleware/issdk/drivers/gpio/: Driver_GPIO.h
  group sensor_fusion
    ../../../../../../../middleware/issdk/algorithms/sensorfusion/sources/: approximations.c approximations.h calibration_storage.h calibration_storage.c control.c control.h debug.h debug.c DecodeCommandBytes.c driver_FXAS21002.c driver_FXLS8962.c driver_MAG3110.c driver_MPL3115.c driver_KSDK_NVM.c driver_KSDK_NVM.h driver_pit.c driver_pit.h driver_systick.c drivers.h fusion.h fusion.c hal_frdm_fxs_mult2_b.c magnetic.c magnetic.h matrix.c matrix.h orientation.c orientation.h output_stream.c precisionAccelerometer.c precisionAccelerometer.h sensor_fusion.h sensor_fusion.c status.c status.h
  group interfaces
    ../../../../../../../middleware/issdk/sensors/: register_io_i2c.c register_io_spi.c sensor_io_spi.c sensor_io_i2c.c register_io_i2c.h register_io_spi.h sensor_io_spi.h sensor_io_i2c.h sensor_drv.h
  group sensors
    ../../../../../../../middleware/issdk/sensors/: fxls8962.h fxls8962_drv.h fxls8962_drv.c mag3110.h mag3110_drv.h mag3110_drv.c fxas21002.h fxas21002_drv.h fxas21002_drv.c mpl3115.h mpl3115_drv.h mpl3115_drv.c
