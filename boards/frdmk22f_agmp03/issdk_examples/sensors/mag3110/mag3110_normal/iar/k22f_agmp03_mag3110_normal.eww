<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>k22f_agmp03_mag3110_normal</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>k22f_agmp03_mag3110_normal</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>k22f_agmp03_mag3110_normal</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>k22f_agmp03_mag3110_normal</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/k22f_agmp03_mag3110_normal.ewp</path>
  </project>
</workspace>
