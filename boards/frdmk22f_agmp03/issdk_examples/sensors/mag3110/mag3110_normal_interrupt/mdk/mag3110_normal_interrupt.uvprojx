# Keil uVision project mag3110_normal_interrupt.uvprojx, settings and files
target mag3110_normal_interrupt Debug (ARM-ADS)
  device: MK22FN512VLH12 NXP
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: mag3110_normal_interrupt.out
  AfterMake: fromelf.exe --m32combined  --output  "$L@L.bin"  "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MK22FN512VLH12, FRDM_K22F, FREEDOM, PRINTF_ADVANCED_ENABLE
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../platform/drivers;../../../../../../frdmk22f;../../../../..;..;../../../../../../../devices/MK22F51212/drivers;../../../../../../../devices/MK22F51212;../../../../../../../devices/MK22F51212/utilities/io;../../../../../../../devices/MK22F51212/utilities/str;../../../../../../../devices/MK22F51212/utilities/log;../../../../../../../devices/MK22F51212/utilities;../../../../../../../devices/MK22F51212/cmsis_drivers;../../../../../../../CMSIS/Driver/Include;../../../../../../../middleware/issdk/drivers/systick;../../../../../../../middleware/issdk/drivers/gpio;../../../../../../../middleware/issdk/drivers/gpio/kinetis;../../../../../../../middleware/issdk/sensors
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: --remove
  group board
    ../../../../../: frdm_k22f.c frdm_k22f.h frdm_stbc_agmp03_shield.h issdk_hal.h RTE_Device.h
    ../: pin_mux.c pin_mux.h clock_config.c clock_config.h board.c board.h
  group source
    ../: mag3110_normal_interrupt.c
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MK22F51212/drivers/: fsl_clock.h fsl_clock.c fsl_flash.c fsl_flash.h fsl_common.h fsl_common.c fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c fsl_i2c.h fsl_i2c.c fsl_i2c_edma.c fsl_i2c_edma.h fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_dspi.h fsl_dspi.c fsl_dspi_edma.h fsl_dspi_edma.c fsl_pit.c fsl_pit.h fsl_uart_edma.h fsl_uart_edma.c
    ../../../../../../../devices/MK22F51212/cmsis_drivers/: fsl_i2c_cmsis.h fsl_i2c_cmsis.c fsl_dspi_cmsis.h fsl_dspi_cmsis.c fsl_uart_cmsis.h fsl_uart_cmsis.c
  group startup
    ../../../../../../../devices/MK22F51212/: system_MK22F51212.c system_MK22F51212.h
    ../../../../../../../devices/MK22F51212/arm/: startup_MK22F51212.s
  group utilities
    ../../../../../../../devices/MK22F51212/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../../devices/MK22F51212/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../../devices/MK22F51212/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MK22F51212/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
    ../../../../../../../middleware/issdk/drivers/systick/: systick_utils.c systick_utils.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_I2C.h Driver_Common.h Driver_SPI.h Driver_USART.h
  group gpio_driver
    ../../../../../../../middleware/issdk/drivers/gpio/kinetis/: gpio_driver_irq.c gpio_driver.c gpio_driver.h
    ../../../../../../../middleware/issdk/drivers/gpio/: Driver_GPIO.h
  group interfaces
    ../../../../../../../middleware/issdk/sensors/: register_io_i2c.c register_io_spi.c sensor_io_spi.c sensor_io_i2c.c register_io_i2c.h register_io_spi.h sensor_io_spi.h sensor_io_i2c.h sensor_drv.h
  group sensors
    ../../../../../../../middleware/issdk/sensors/: mag3110.h mag3110_drv.h mag3110_drv.c
target mag3110_normal_interrupt Release (ARM-ADS)
  device: MK22FN512VLH12 NXP
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: mag3110_normal_interrupt.out
  AfterMake: fromelf.exe --m32combined  --output  "$L@L.bin"  "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MK22FN512VLH12, FRDM_K22F, FREEDOM, PRINTF_ADVANCED_ENABLE
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: --remove
