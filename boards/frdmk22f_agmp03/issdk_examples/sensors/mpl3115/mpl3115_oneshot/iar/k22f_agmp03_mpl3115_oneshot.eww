<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>k22f_agmp03_mpl3115_oneshot</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>k22f_agmp03_mpl3115_oneshot</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>k22f_agmp03_mpl3115_oneshot</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>k22f_agmp03_mpl3115_oneshot</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/k22f_agmp03_mpl3115_oneshot.ewp</path>
  </project>
</workspace>
