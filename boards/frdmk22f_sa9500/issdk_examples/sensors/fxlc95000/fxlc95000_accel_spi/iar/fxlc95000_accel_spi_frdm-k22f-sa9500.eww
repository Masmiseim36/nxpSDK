<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>fxlc95000_accel_spi_frdm-k22f-sa9500</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>fxlc95000_accel_spi_frdm-k22f-sa9500</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>fxlc95000_accel_spi_frdm-k22f-sa9500</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>fxlc95000_accel_spi_frdm-k22f-sa9500</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/fxlc95000_accel_spi_frdm-k22f-sa9500.ewp</path>
  </project>
</workspace>
