# Keil uVision project fxlc95000_accel_spi_frdm-k22f-sa9500.uvprojx, settings and files
target fxlc95000_accel_spi_frdm-k22f-sa9500 Debug (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: fxlc95000_accel_spi_frdm-k22f-sa9500.out
  AfterMake: fromelf.exe --m32combined  --output  "$L@L.bin"  "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MK22FN512VLH12, FRDM_K22F, FREEDOM, PRINTF_ADVANCED_ENABLE
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../platform/drivers;../../../../../../../middleware/issdk_1.5/drivers/gpio;../../../../../../../middleware/issdk_1.5/drivers/systick;../../../../../../../CMSIS/Driver/Include;../../../../../../../middleware/issdk_1.5/sensors;../../../../..;..;../../../../../../frdmk22f;../../../../../../../devices/MK22F51212/drivers;../../../../../../../devices/MK22F51212/cmsis_drivers;../../../../../../../devices/MK22F51212/utilities;../../../../../../../devices/MK22F51212
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: --remove
  group startup
    ../../../../../../../devices/MK22F51212/arm/: startup_MK22F51212.s
    ../../../../../../../devices/MK22F51212/: system_MK22F51212.c system_MK22F51212.h
  group doc
    ../: readme.txt
  group board
    ../../../../../: frdm_k22f.c frdm_k22f.h frdm_stbc_sa9500_shield.h issdk_hal.h RTE_Device.h
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group sensors
    ../../../../../../../middleware/issdk_1.5/driverexamples/fxlc95000/: fxlc95000_accel_spi.c
    ../../../../../../../middleware/issdk_1.5/sensors/: fxlc95000.h fxlc95000_drv.h fxlc95000_drv.c
  group interface
    ../../../../../../../middleware/issdk_1.5/sensors/: sensor_drv.h register_io_i2c.c register_io_i2c.h sensor_io_i2c.c sensor_io_i2c.h register_io_spi.c register_io_spi.h sensor_io_spi.c sensor_io_spi.h
  group utilities
    ../../../../../../../middleware/issdk_1.5/drivers/systick/: systick_utils.c systick_utils.h
    ../../../../../../../devices/MK22F51212/utilities/: fsl_debug_console.c fsl_debug_console.h
  group drivers
    ../../../../../../../devices/MK22F51212/drivers/: fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_dspi.h fsl_dspi.c fsl_lptmr.c fsl_lptmr.h fsl_smc.h fsl_smc.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_dspi_edma.h fsl_dspi_edma.c fsl_uart_edma.h fsl_uart_edma.c fsl_common.h fsl_common.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
    ../../../../../../../devices/MK22F51212/cmsis_drivers/: fsl_dspi_cmsis.h fsl_dspi_cmsis.c fsl_uart_cmsis.h fsl_uart_cmsis.c
  group gpio_driver
    ../../../../../../../middleware/issdk_1.5/drivers/gpio/: gpio_driver_irq.c gpio_driver.c gpio_driver.h Driver_GPIO.h
target fxlc95000_accel_spi_frdm-k22f-sa9500 Release (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: fxlc95000_accel_spi_frdm-k22f-sa9500.out
  AfterMake: fromelf.exe --m32combined  --output  "$L@L.bin"  "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MK22FN512VLH12, FRDM_K22F, FREEDOM, PRINTF_ADVANCED_ENABLE
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: --remove
