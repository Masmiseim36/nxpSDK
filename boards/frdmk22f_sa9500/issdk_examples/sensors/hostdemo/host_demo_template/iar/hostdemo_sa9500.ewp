# IAR project hostdemo_sa9500.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 NXP MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK22FN512VLH12; FRDM_K22F; FREEDOM; PRINTF_ADVANCED_ENABLE
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../platform/drivers; ../../../../../../frdmk22f; ../../../../..; ..; ../../../../../../../devices/MK22F51212/drivers; ../../../../../../../devices/MK22F51212; ../../../../../../../devices/MK22F51212/utilities/io; ../../../../../../../devices/MK22F51212/utilities/str; ../../../../../../../devices/MK22F51212/utilities/log; ../../../../../../../devices/MK22F51212/utilities; ../../../../../../../devices/MK22F51212/cmsis_drivers; ../../../../../../../CMSIS/Driver/Include; ../../../../../../../middleware/issdk/drivers/systick; ../../../../../../../middleware/issdk/drivers/gpio; ../../../../../../../middleware/issdk/drivers/gpio/kinetis; ../../../../../../../middleware/issdk/sensors; ../../../../../../../middleware/issdk/drivers/ads; ../../../../../../../middleware/issdk/drivers/ads/kinetis; ../../../../../../../middleware/issdk/drivers/host
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: K22F-SA9500-HOST-DEMO.bin
  ILINK.IlinkOutputFile: hostdemo_sa9500.out
  ILINK.IlinkIcfFile: MK22FN512xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK22FN512VLH12; FRDM_K22F; FREEDOM; PRINTF_ADVANCED_ENABLE
  ICCARM.CCOptLevel: 3
  group board
    ../../../../../: frdm_k22f.c frdm_k22f.h frdm_stbc_sa9500_shield.h issdk_hal.h RTE_Device.h
    ../: pin_mux.c pin_mux.h clock_config.c clock_config.h board.c board.h
  group source
    ../: host_demo.c
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MK22F51212/drivers/: fsl_clock.h fsl_clock.c fsl_flash.c fsl_flash.h fsl_common.h fsl_common.c fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c fsl_uart_edma.h fsl_uart_edma.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_i2c.h fsl_i2c.c fsl_i2c_edma.c fsl_i2c_edma.h fsl_dspi.h fsl_dspi.c fsl_dspi_edma.h fsl_dspi_edma.c fsl_lptmr.c fsl_lptmr.h
    ../../../../../../../devices/MK22F51212/cmsis_drivers/: fsl_uart_cmsis.h fsl_uart_cmsis.c fsl_i2c_cmsis.h fsl_i2c_cmsis.c fsl_dspi_cmsis.h fsl_dspi_cmsis.c
  group startup
    ../../../../../../../devices/MK22F51212/: system_MK22F51212.c system_MK22F51212.h
    ../../../../../../../devices/MK22F51212/iar/: startup_MK22F51212.s
  group utilities
    ../../../../../../../devices/MK22F51212/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../../devices/MK22F51212/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../../devices/MK22F51212/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MK22F51212/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
    ../../../../../../../middleware/issdk/drivers/systick/: systick_utils.c systick_utils.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_USART.h Driver_Common.h Driver_I2C.h Driver_SPI.h
  group gpio_driver
    ../../../../../../../middleware/issdk/drivers/gpio/kinetis/: gpio_driver_irq.c gpio_driver.c gpio_driver.h
    ../../../../../../../middleware/issdk/drivers/gpio/: Driver_GPIO.h
  group interfaces
    ../../../../../../../middleware/issdk/sensors/: register_io_i2c.c register_io_spi.c sensor_io_spi.c sensor_io_i2c.c register_io_i2c.h register_io_spi.h sensor_io_spi.h sensor_io_i2c.h sensor_drv.h
  group sensors
    ../../../../../../../middleware/issdk/sensors/: fxas21002.h fxos8700.h mpl3115.h fxlc95000.h fxls8471q.h fxls8962.h fxpq3115.h mag3110.h mma845x.h mma865x.h mma8491q.h mma9553.h diff_p.h
  group ads
    ../../../../../../../middleware/issdk/drivers/ads/kinetis/: auto_detection_service.c auto_detection_service.h
    ../../../../../../../middleware/issdk/drivers/ads/: auto_detection_shield.h
  group host
    ../../../../../../../middleware/issdk/sensors/: host_io_uart.c host_io_uart.h
    ../../../../../../../middleware/issdk/drivers/host/: comm_if_uart.c comm_interface.h data_format_hdlc.c data_format_hdlc.h data_format_json.c data_format_json.h data_format_service.h host_interface_service.c host_interface_service.h
