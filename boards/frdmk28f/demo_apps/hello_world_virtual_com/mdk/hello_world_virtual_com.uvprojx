# Keil uVision project hello_world_virtual_com.uvprojx, settings and files
target hello_world_virtual_com debug (ARM-ADS)
  device: MK28FN2M0VMI15 NXP
  pack: Keil.Kinetis_K20_DFP.1.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: hello_world_virtual_com.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG, CPU_MK28FN2M0VMI15, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, SERIAL_PORT_TYPE_USBCDC=1, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, USB_STACK_BM, BOARD_USE_VIRTUALCOM=1, FRDM_K28F, FREEDOM
  c misc: --library_interface=armcc --diag_suppress=1296,186
  c include: ..;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../components/serial_manager;../../../../../components/serial_manager/usb_cdc_adapter;../../../component_examples/config;../../../../../middleware/usb/phy;../../../../../middleware/usb/device;../../../../../middleware/usb/include;../../../../../middleware/usb/osa;../../../../../middleware/usb/device;../../../../../middleware/usb/include;../../../../../middleware/usb/osa;../../../../../devices/MK28F15/drivers;../../../../../devices/MK28F15/drivers;../../../../../devices/MK28F15/drivers;../../../../../devices/MK28F15;../../../../../devices/MK28F15/utilities/str;../../../../../devices/MK28F15/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../devices/MK28F15/drivers;../../../../../components/lists;../../../../../devices/MK28F15/drivers;../../../../../devices/MK28F15/drivers;../../../../../devices/MK28F15/drivers
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK28FN2M0xxx15_flash.scf
  link misc: --remove
  group source
    ../: hello_world.c
  group board
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_usb.c serial_port_usb.h serial_port_uart.c serial_port_uart.h
  group component-serial_manager-usb_cdc_adapter
    ../../../../../components/serial_manager/usb_cdc_adapter/: usb_device_descriptor.c usb_device_descriptor.h usb_device_cdc_acm.c usb_device_cdc_acm.h usb_device_class.c usb_device_class.h usb_device_ch9.c usb_device_ch9.h
    ../../../component_examples/config/: usb_device_config.h
  group usb-phy
    ../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group usb-device-source-ehci
    ../../../../../middleware/usb/device/: usb_device_ehci.c usb_device_ehci.h
  group usb-include
    ../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h usb.h usb_misc.h usb_spec.h
  group osa
    ../../../../../middleware/usb/osa/: usb_osa.h usb_osa_bm.c usb_osa_bm.h usb_osa.h usb_osa_bm.c usb_osa_bm.h
  group usb-device-source-khci
    ../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
  group drivers
    ../../../../../devices/MK28F15/drivers/: fsl_sysmpu.c fsl_sysmpu.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_gpio.c fsl_gpio.h fsl_port.h fsl_smc.c fsl_smc.h
  group usb-device-include
    ../../../../../middleware/usb/device/: usb_device.h
  group usb-device-source
    ../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
  group device
    ../../../../../devices/MK28F15/: MK28F15.h MK28F15_features.h fsl_device_registers.h system_MK28F15.c system_MK28F15.h
  group utilities
    ../../../../../devices/MK28F15/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MK28F15/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK28F15/utilities/: fsl_assert.c
  group component-uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MK28F15/arm/: startup_MK28F15.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h
target hello_world_virtual_com release (ARM-ADS)
  device: MK28FN2M0VMI15 NXP
  pack: Keil.Kinetis_K20_DFP.1.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: hello_world_virtual_com.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: NDEBUG, CPU_MK28FN2M0VMI15, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, SERIAL_PORT_TYPE_USBCDC=1, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, USB_STACK_BM, BOARD_USE_VIRTUALCOM=1, FRDM_K28F, FREEDOM
  c misc: --library_interface=armcc --diag_suppress=1296,186
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK28FN2M0xxx15_flash.scf
  link misc: --remove
