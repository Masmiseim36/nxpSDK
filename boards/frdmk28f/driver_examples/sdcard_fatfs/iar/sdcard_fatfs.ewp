# IAR project sdcard_fatfs.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK28FN2M0xxx15 NXP MK28FN2M0xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK28FN2M0VMI15; FRDM_K28F; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ..; ../../..; ../../../../../devices/MK28F15/drivers; ../../../../../devices/MK28F15; ../../../../../devices/MK28F15/utilities/io; ../../../../../devices/MK28F15/utilities/str; ../../../../../devices/MK28F15/utilities/log; ../../../../../devices/MK28F15/utilities; ../../../../../middleware/sdmmc/src; ../../../../../middleware/sdmmc/inc; ../../../../../middleware/sdmmc/port; ../../../../../middleware/fatfs/src/fsl_sd_disk; ../../../../../middleware/fatfs/src; ../../../../../middleware/fatfs/src/option
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: sdcard_fatfs.out
  ILINK.IlinkIcfFile: MK28FN2M0xxx15_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK28FN2M0VMI15; FRDM_K28F; FREEDOM
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: sdcard_fatfs.c ffconf.h
  group sdmmc/port
    ../: fsl_sdmmc_host.c fsl_sdmmc_event.c fsl_sdmmc_event.h
  group sdmmc/src
    ../../../../../middleware/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc/inc/: fsl_sd.h fsl_sdmmc_host.h fsl_sdmmc_common.h fsl_sdmmc_spec.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK28F15/drivers/: fsl_clock.h fsl_clock.c fsl_flash.c fsl_flash.h fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_smc.h fsl_smc.c fsl_sysmpu.h fsl_sysmpu.c fsl_sdhc.h fsl_sdhc.c
  group startup
    ../../../../../devices/MK28F15/: system_MK28F15.c system_MK28F15.h
    ../../../../../devices/MK28F15/iar/: startup_MK28F15.s
  group utilities
    ../../../../../devices/MK28F15/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MK28F15/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MK28F15/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK28F15/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group fatfs/fatfs_include
    ../../../../../middleware/fatfs/src/fsl_sd_disk/: fsl_sd_disk.h
    ../../../../../middleware/fatfs/src/: integer.h ff.h diskio.h
  group fatfs/fatfs_source
    ../../../../../middleware/fatfs/src/fsl_sd_disk/: fsl_sd_disk.c
    ../../../../../middleware/fatfs/src/: ff.c diskio.c
