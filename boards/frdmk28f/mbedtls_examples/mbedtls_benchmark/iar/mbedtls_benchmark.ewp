# IAR project mbedtls_benchmark.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MK28FN2M0xxx15 NXP MK28FN2M0xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK28FN2M0VMI15; PRINTF_ADVANCED_ENABLE=1; PRINTF_FLOAT_ENABLE=1; FREESCALE_KSDK_BM; MBEDTLS_CONFIG_FILE="ksdk_mbedtls_config.h"; FRDM_K28F; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.IExtraOptions: --diag_suppress Pa084
  ICCARM.CCIncludePath2: ..; ../../..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../middleware/mmcau; ../../../../../middleware/mbedtls/include; ../../../../../middleware/mbedtls/port/ksdk; ../../../../../devices/MK28F15/drivers; ../../../../../devices/MK28F15/drivers; ../../../../../devices/MK28F15/drivers; ../../../../../devices/MK28F15/drivers; ../../../../../devices/MK28F15; ../../../../../devices/MK28F15/utilities/str; ../../../../../devices/MK28F15/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/serial_manager; ../../../../../devices/MK28F15/drivers; ../../../../../components/lists; ../../../../../devices/MK28F15/drivers; ../../../../../devices/MK28F15/drivers; ../../../../../devices/MK28F15/drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: mbedtls_benchmark.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x8000
  ILINK.IlinkIcfFile: MK28FN2M0xxx15_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/mmcau/asm-cm4-cm7/lib_mmcau.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK28FN2M0VMI15; PRINTF_ADVANCED_ENABLE=1; PRINTF_FLOAT_ENABLE=1; FREESCALE_KSDK_BM; MBEDTLS_CONFIG_FILE="ksdk_mbedtls_config.h"; FRDM_K28F; FREEDOM
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: benchmark.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK28F15/drivers/: fsl_trng.c fsl_trng.h fsl_port.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_sysmpu.h fsl_sysmpu.c
  group mmcau/mmcau_include
    ../../../../../middleware/mmcau/: cau_api.h fsl_mmcau.h
  group mmcau/mmcau_source
    ../../../../../middleware/mmcau/: fsl_mmcau.c
  group mbedtls/mbedtls_include
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/mbedtls_source
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c chacha20.c chachapoly.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c pkcs11.c
  group mbedtls/mbedtls_port
    ../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c
  group device
    ../../../../../devices/MK28F15/: fsl_device_registers.h MK28F15.h MK28F15_features.h system_MK28F15.c system_MK28F15.h
  group utilities
    ../../../../../devices/MK28F15/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK28F15/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MK28F15/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: uart.h lpuart_adapter.c
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: generic_list.h generic_list.c
  group startup
    ../../../../../devices/MK28F15/iar/: startup_MK28F15.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
