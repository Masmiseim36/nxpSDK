# IAR project erpc_server_matrix_multiply_spi.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK28FN2M0xxx15 NXP MK28FN2M0xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK28FN2M0VMI15; FRDM_K28F; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ..; ../../erpc_common/erpc_matrix_multiply/service; ../../erpc_common; ../../..; ../../../../../middleware/multicore/erpc/erpc_c/infra; ../../../../../middleware/multicore/erpc/erpc_c/port; ../../../../../middleware/multicore/erpc/erpc_c/setup; ../../../../../middleware/multicore/erpc/erpc_c/transports; ../../../../../devices/MK28F15/drivers; ../../../../../devices/MK28F15; ../../../../../devices/MK28F15/utilities/io; ../../../../../devices/MK28F15/utilities/str; ../../../../../devices/MK28F15/utilities/log; ../../../../../devices/MK28F15/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: erpc_server_matrix_multiply_spi.out
  ILINK.IlinkIcfFile: MK28FN2M0xxx15_flash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK28FN2M0VMI15; FRDM_K28F; FREEDOM
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: main_server.c erpc_config.h
  group erpc
    ../../erpc_common/: erpc_error_handler.h erpc_error_handler.cpp
  group erpc/service
    ../../erpc_common/erpc_matrix_multiply/service/: erpc_crc16.h erpc_matrix_multiply.erpc erpc_matrix_multiply.h erpc_matrix_multiply_server.h erpc_matrix_multiply_server.cpp
  group erpc/transports
    ../../../../../middleware/multicore/erpc/erpc_c/transports/: dspi_slave_transport.h dspi_slave_transport.cpp
  group erpc/infra
    ../../../../../middleware/multicore/erpc/erpc_c/infra/: framed_transport.h framed_transport.cpp erpc_version.h codec.h basic_codec.h transport.h message_buffer.h message_loggers.h erpc_common.h manually_constructed.h crc16.h basic_codec.cpp message_buffer.cpp message_loggers.cpp crc16.cpp simple_server.h simple_server.cpp server.h server.cpp
  group erpc/setup
    ../../../../../middleware/multicore/erpc/erpc_c/setup/: erpc_setup_mbf_dynamic.cpp erpc_transport_setup.h erpc_mbf_setup.h erpc_setup_dspi_slave.cpp erpc_server_setup.h erpc_server_setup.cpp
  group erpc/port
    ../../../../../middleware/multicore/erpc/erpc_c/port/: erpc_port.h erpc_port_stdlib.cpp erpc_config_internal.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK28F15/drivers/: fsl_dspi.h fsl_dspi.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_flash.c fsl_flash.h fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_smc.h fsl_smc.c fsl_sysmpu.h fsl_sysmpu.c
  group startup
    ../../../../../devices/MK28F15/: system_MK28F15.c system_MK28F15.h
    ../../../../../devices/MK28F15/iar/: startup_MK28F15.s
  group utilities
    ../../../../../devices/MK28F15/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MK28F15/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MK28F15/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK28F15/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
