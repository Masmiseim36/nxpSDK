# IAR project freertos_segger_sysview.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK28FN2M0xxx15 NXP MK28FN2M0xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK28FN2M0VMI15; FRDM_K28F; FREEDOM; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../rtos/freertos/Source/portable/IAR/ARM_CM4F; ../../../../../../CMSIS/Include; ../../../../../../devices; ..; ../SEGGER; ../Config; ../Sample/OS; ../../../..; ../../../../../../rtos/freertos/Source/include; ../../../../../../devices/MK28F15/drivers; ../../../../../../devices/MK28F15; ../../../../../../devices/MK28F15/utilities/io; ../../../../../../devices/MK28F15/utilities/str; ../../../../../../devices/MK28F15/utilities/log; ../../../../../../devices/MK28F15/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../SEGGER; ../Config; ../Sample/OS; ../../../..
  ILINK.IlinkOutputFile: freertos_segger_sysview.out
  ILINK.IlinkIcfFile: MK28FN2M0xxx15_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK28FN2M0VMI15; FRDM_K28F; FREEDOM; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: main.c FreeRTOSConfig.h
  group segger_sysview
    ../SEGGER/: SEGGER.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Int.h
    ../Config/: Global.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW_Conf.h
    ../Sample/OS/: SEGGER_SYSVIEW_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.h
  group board
    ../Sample/OS/: pin_mux.c pin_mux.h
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MK28F15/drivers/: fsl_clock.h fsl_clock.c fsl_flash.c fsl_flash.h fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_smc.h fsl_smc.c fsl_sysmpu.h fsl_sysmpu.c
  group startup
    ../../../../../../devices/MK28F15/: system_MK28F15.c system_MK28F15.h
    ../../../../../../devices/MK28F15/iar/: startup_MK28F15.s
  group utilities
    ../../../../../../devices/MK28F15/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../devices/MK28F15/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../devices/MK28F15/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MK28F15/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group freertos
    ../../../../../../rtos/freertos/: FreeRTOS_for_Kinetis_SDK_v2.0.txt
  group freertos/license
    ../../../../../../rtos/freertos/License/: license.txt
  group freertos/include
    ../../../../../../rtos/freertos/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h stdint.readme task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
  group freertos/source
    ../../../../../../rtos/freertos/Source/: croutine.c list.c queue.c readme.txt tasks.c timers.c event_groups.c
  group freertos/portable
    ../../../../../../rtos/freertos/Source/portable/: readme.txt
    ../../../../../../rtos/freertos/Source/portable/IAR/ARM_CM4F/: fsl_tickless_systick.c fsl_tickless_generic.h port.c portasm.s portmacro.h
    ../../../../../../rtos/freertos/Source/portable/MemMang/: heap_4.c
