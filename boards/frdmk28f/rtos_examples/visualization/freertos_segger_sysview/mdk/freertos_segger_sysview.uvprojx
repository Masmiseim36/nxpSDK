# Keil uVision project freertos_segger_sysview.uvprojx, settings and files
target freertos_segger_sysview Debug (ARM-ADS)
  device: MK28FN2M0VMI15 NXP
  pack: Keil.Kinetis_K20_DFP.1.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: freertos_segger_sysview.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MK28FN2M0VMI15, FRDM_K28F, FREEDOM, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../rtos/freertos/Source/portable/RVDS/ARM_CM4F;../../../../../../CMSIS/Include;../../../../../../devices;..;../SEGGER;../Config;../Sample/OS;../../../..;../../../../../../rtos/freertos/Source/include;../../../../../../devices/MK28F15/drivers;../../../../../../devices/MK28F15;../../../../../../devices/MK28F15/utilities/io;../../../../../../devices/MK28F15/utilities/str;../../../../../../devices/MK28F15/utilities/log;../../../../../../devices/MK28F15/utilities
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../SEGGER;../Config;../Sample/OS;../../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK28FN2M0xxx15_flash.scf
  link misc: --remove
  group source
    ../: main.c FreeRTOSConfig.h
  group segger_sysview
    ../SEGGER/: SEGGER.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Int.h
    ../Config/: Global.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW_Conf.h
    ../Sample/OS/: SEGGER_SYSVIEW_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.h
  group board
    ../Sample/OS/: pin_mux.c pin_mux.h
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MK28F15/drivers/: fsl_clock.h fsl_clock.c fsl_flash.c fsl_flash.h fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_smc.h fsl_smc.c fsl_sysmpu.h fsl_sysmpu.c
  group startup
    ../../../../../../devices/MK28F15/: system_MK28F15.c system_MK28F15.h
    ../../../../../../devices/MK28F15/arm/: startup_MK28F15.s
  group utilities
    ../../../../../../devices/MK28F15/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../devices/MK28F15/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../devices/MK28F15/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MK28F15/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group freertos
    ../../../../../../rtos/freertos/: FreeRTOS_for_Kinetis_SDK_v2.0.txt
  group freertos-license
    ../../../../../../rtos/freertos/License/: license.txt
  group freertos-include
    ../../../../../../rtos/freertos/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h stdint.readme task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
  group freertos-source
    ../../../../../../rtos/freertos/Source/: croutine.c list.c queue.c readme.txt tasks.c timers.c event_groups.c
  group freertos-portable
    ../../../../../../rtos/freertos/Source/portable/: readme.txt
    ../../../../../../rtos/freertos/Source/portable/RVDS/ARM_CM4F/: fsl_tickless_systick.c fsl_tickless_generic.h port.c portmacro.h
    ../../../../../../rtos/freertos/Source/portable/MemMang/: heap_4.c
target freertos_segger_sysview Release (ARM-ADS)
  device: MK28FN2M0VMI15 NXP
  pack: Keil.Kinetis_K20_DFP.1.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: freertos_segger_sysview.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MK28FN2M0VMI15, FRDM_K28F, FREEDOM, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../SEGGER;../Config;../Sample/OS;../../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK28FN2M0xxx15_flash.scf
  link misc: --remove
