# Keil uVision project host_msd_fatfs_bm.uvprojx, settings and files
target host_msd_fatfs_bm Debug (ARM-ADS)
  device: MK28FN2M0VMI15 NXP
  pack: Keil.Kinetis_K20_DFP.1.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: host_msd_fatfs_bm.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: _DEBUG=1, CPU_MK28FN2M0VMI15, USB_STACK_BM, PRINTF_ADVANCED_ENABLE=1
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..;../../../../../../middleware/fatfs/src;../../../..;../../../../../../CMSIS/Include;../../../../../../middleware/usb;../../../../../../middleware/usb/osa;../../../../../../middleware/usb/include;../../../../../../middleware/usb/host;../../../../../../middleware/usb/phy;../../../../../../devices/MK28F15/drivers;../../../../../../middleware/usb/host/class;../../../../../../middleware/fatfs/src/option;../../../../../../devices/MK28F15/utilities/io;../../../../../../devices/MK28F15/utilities/str;../../../../../../devices/MK28F15/utilities/log;../../../../../../devices/MK28F15/utilities;../../../../../../devices/MK28F15
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK28FN2M0xxx15_flash.scf
  link misc: --remove
  group doc
    ../: readme.txt
  group sources
    ../: app.h app.c host_msd_fatfs.c ffconf.h host_msd_fatfs.h usb_host_config.h fsl_usb_disk.h fsl_usb_disk_bm.c
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group usb-host
    ../../../../../../middleware/usb/host/: usb_host_khci.c usb_host_khci.h usb_host_ehci.c usb_host_ehci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c
  group usb-include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h usb.h usb_misc.h usb_spec.h
  group osa
    ../../../../../../middleware/usb/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group usb-phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group drivers
    ../../../../../../devices/MK28F15/drivers/: fsl_port.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_sim.h fsl_sim.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_sysmpu.h fsl_sysmpu.c
  group usb-host-class
    ../../../../../../middleware/usb/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_msd.c usb_host_msd.h usb_host_msd_ufi.c
  group fatfs-fatfs_source
    ../../../../../../middleware/fatfs/src/: ff.c diskio.c
  group fatfs-fatfs_include
    ../../../../../../middleware/fatfs/src/: integer.h ff.h diskio.h
  group utilities
    ../../../../../../devices/MK28F15/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../devices/MK28F15/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../devices/MK28F15/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MK28F15/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group startup
    ../../../../../../devices/MK28F15/: system_MK28F15.c system_MK28F15.h
    ../../../../../../devices/MK28F15/arm/: startup_MK28F15.s
target host_msd_fatfs_bm Release (ARM-ADS)
  device: MK28FN2M0VMI15 NXP
  pack: Keil.Kinetis_K20_DFP.1.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: host_msd_fatfs_bm.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: _DEBUG=0, CPU_MK28FN2M0VMI15, USB_STACK_BM, PRINTF_ADVANCED_ENABLE=1
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK28FN2M0xxx15_flash.scf
  link misc: --remove
