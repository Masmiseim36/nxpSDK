# IAR project host_msd_fatfs_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK28FN2M0xxx15 NXP MK28FN2M0xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; CPU_MK28FN2M0VMI15; USB_STACK_FREERTOS; PRINTF_ADVANCED_ENABLE=1; USB_STACK_FREERTOS_HEAP_SIZE=32768; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../rtos/freertos/Source/portable/IAR/ARM_CM4F; ..; ../../../../../../middleware/fatfs/src; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../middleware/usb; ../../../../../../middleware/usb/osa; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/host; ../../../../../../rtos/freertos/Source/include; ../../../../../../middleware/usb/phy; ../../../../../../devices/MK28F15/drivers; ../../../../../../middleware/usb/host/class; ../../../../../../middleware/fatfs/src/option; ../../../../../../devices/MK28F15/utilities/io; ../../../../../../devices/MK28F15/utilities/str; ../../../../../../devices/MK28F15/utilities/log; ../../../../../../devices/MK28F15/utilities; ../../../../../../devices/MK28F15
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ../../../..; ..
  ILINK.IlinkOutputFile: host_msd_fatfs_freertos.out
  ILINK.IlinkIcfFile: MK28FN2M0xxx15_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK28FN2M0VMI15; USB_STACK_FREERTOS; PRINTF_ADVANCED_ENABLE=1; USB_STACK_FREERTOS_HEAP_SIZE=32768; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  group doc
    ../: readme.txt
  group sources
    ../: app.h app.c host_msd_fatfs.c ffconf.h host_msd_fatfs.h usb_host_config.h FreeRTOSConfig.h fsl_usb_disk.h fsl_usb_disk_freertos.c
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group usb/host
    ../../../../../../middleware/usb/host/: usb_host_khci.c usb_host_khci.h usb_host_ehci.c usb_host_ehci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c
  group usb/host/class
    ../../../../../../middleware/usb/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_msd.c usb_host_msd.h usb_host_msd_ufi.c
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h usb.h usb_misc.h usb_spec.h
  group usb/phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group osa
    ../../../../../../middleware/usb/osa/: usb_osa.h usb_osa_freertos.h usb_osa_freertos.c usb_osa.h usb_osa_freertos.h usb_osa_freertos.c
  group drivers
    ../../../../../../devices/MK28F15/drivers/: fsl_port.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_sim.h fsl_sim.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_sysmpu.h fsl_sysmpu.c
  group freertos
    ../../../../../../rtos/freertos/: FreeRTOS_for_Kinetis_SDK_v2.0.txt
  group freertos/portable
    ../../../../../../rtos/freertos/Source/portable/MemMang/: heap_4.c
    ../../../../../../rtos/freertos/Source/portable/: readme.txt
    ../../../../../../rtos/freertos/Source/portable/IAR/ARM_CM4F/: fsl_tickless_systick.c fsl_tickless_generic.h port.c portasm.s portmacro.h
  group freertos/license
    ../../../../../../rtos/freertos/License/: license.txt
  group freertos/include
    ../../../../../../rtos/freertos/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h stdint.readme task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
  group freertos/source
    ../../../../../../rtos/freertos/Source/: croutine.c list.c queue.c readme.txt tasks.c timers.c event_groups.c
  group fatfs/fatfs_source
    ../../../../../../middleware/fatfs/src/: ff.c diskio.c
  group fatfs/fatfs_include
    ../../../../../../middleware/fatfs/src/: integer.h ff.h diskio.h
  group utilities
    ../../../../../../devices/MK28F15/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../devices/MK28F15/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../devices/MK28F15/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MK28F15/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group startup
    ../../../../../../devices/MK28F15/: system_MK28F15.c system_MK28F15.h
    ../../../../../../devices/MK28F15/iar/: startup_MK28F15.s
