# Keil uVision project pin_detect_hid_msd_bm.uvprojx, settings and files
target pin_detect_hid_msd_bm debug (ARM-ADS)
  device: MK28FN2M0VMI15 NXP
  pack: Keil.Kinetis_K20_DFP.1.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: pin_detect_hid_msd_bm.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG, CPU_MK28FN2M0VMI15, USB_STACK_BM
  c misc: --library_interface=armcc 
--diag_suppress=1296,186
  c include: ..;../../../..;../../../../../../CMSIS/Include;../../../../../../middleware/usb/host;../../../../../../middleware/usb/include;../../../../../../middleware/usb/osa;../../../../../../middleware/usb/host;../../../../../../middleware/usb/include;../../../../../../middleware/usb/osa;../../../../../../middleware/usb/device;../../../../../../middleware/usb/include;../../../../../../middleware/usb/osa;../../../../../../middleware/usb/device;../../../../../../middleware/usb/include;../../../../../../middleware/usb/osa;../../../../../../middleware/usb/phy;../../../../../../middleware/usb/host/class;../../../../../../middleware/usb/host;../../../../../../middleware/usb/host/class;../../../../../../middleware/fatfs/source;../../../../../../devices/MK28F15/drivers;../../../../../../devices/MK28F15/drivers;../../../../../../devices/MK28F15/drivers;../../../../../../devices/MK28F15;../../../../../../devices/MK28F15/drivers;../../../../../../devices/MK28F15/drivers;../../../../../../devices/MK28F15/drivers;../../../../../../devices/MK28F15/utilities/str;../../../../../../devices/MK28F15/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../devices/MK28F15/drivers
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK28FN2M0xxx15_flash.scf
  link misc: --remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
  group source
    ../: app.c app.h device_mouse.c device_mouse.h host_msd_fatfs.c host_msd_fatfs.h ffconf.h usb_device_descriptor.c usb_device_descriptor.h usb_host_config.h usb_device_config.h host_app.c host_app.h fsl_usb_disk.h fsl_usb_disk_bm.c
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group usb-host
    ../../../../../../middleware/usb/host/: usb_host_khci.c usb_host_khci.h usb_host_ehci.c usb_host_ehci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c
  group usb-include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h usb.h usb_misc.h usb_spec.h usb.h usb_misc.h usb_spec.h usb.h usb_misc.h usb_spec.h
  group osa
    ../../../../../../middleware/usb/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c usb_osa.h usb_osa_bm.h usb_osa_bm.c usb_osa.h usb_osa_bm.h usb_osa_bm.c usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group usb-device-source-khci
    ../../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
  group usb-device-source-ehci
    ../../../../../../middleware/usb/device/: usb_device_ehci.c usb_device_ehci.h
  group usb-phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group usb-device-source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
  group usb-host-class
    ../../../../../../middleware/usb/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_msd.c usb_host_msd.h usb_host_msd_ufi.c
  group usb-device-class
    ../: usb_device_class.c usb_device_class.h
  group usb-device-class-hid
    ../: usb_device_hid.c usb_device_hid.h
  group usb-device-include
    ../../../../../../middleware/usb/device/: usb_device.h
  group fatfs-fatfs_source
    ../../../../../../middleware/fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group fatfs-fatfs_include
    ../../../../../../middleware/fatfs/source/: diskio.h ff.h integer.h
  group drivers
    ../../../../../../devices/MK28F15/drivers/: fsl_smc.h fsl_smc.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_sysmpu.h fsl_sysmpu.c fsl_port.h
  group device
    ../../../../../../devices/MK28F15/: fsl_device_registers.h MK28F15.h MK28F15_features.h system_MK28F15.c system_MK28F15.h
  group startup
    ../../../../../../devices/MK28F15/arm/: startup_MK28F15.s
  group utilities
    ../../../../../../devices/MK28F15/utilities/: fsl_assert.c
    ../../../../../../devices/MK28F15/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MK28F15/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group component/uart
    ../../../../../../components/uart/: uart.h lpuart_adapter.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: generic_list.h generic_list.c
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
target pin_detect_hid_msd_bm release (ARM-ADS)
  device: MK28FN2M0VMI15 NXP
  pack: Keil.Kinetis_K20_DFP.1.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: pin_detect_hid_msd_bm.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: NDEBUG, CPU_MK28FN2M0VMI15, USB_STACK_BM
  c misc: --library_interface=armcc 
--diag_suppress=1296,186
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK28FN2M0xxx15_flash.scf
  link misc: as above
