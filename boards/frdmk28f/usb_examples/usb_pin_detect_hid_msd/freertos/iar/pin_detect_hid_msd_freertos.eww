<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>pin_detect_hid_msd_freertos</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>pin_detect_hid_msd_freertos</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>pin_detect_hid_msd_freertos</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>pin_detect_hid_msd_freertos</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/pin_detect_hid_msd_freertos.ewp</path>
  </project>
</workspace>
