# IAR project wolfssl_benchmark.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MK28FN2M0xxx15 NXP MK28FN2M0xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK28FN2M0VMI15; FRDM_K28F; FREEDOM; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; FREESCALE_KSDK_BM; WOLFSSL_USER_SETTINGS
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ..; ../../..; ../../../../../middleware/mmcau; ../../../../../middleware/wolfssl; ../../../../../middleware/wolfssl/wolfssl/wolfcrypt/port; ../../../../../devices/MK28F15/drivers; ../../../../../devices/MK28F15; ../../../../../devices/MK28F15/utilities/io; ../../../../../devices/MK28F15/utilities/str; ../../../../../devices/MK28F15/utilities/log; ../../../../../devices/MK28F15/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: wolfssl_benchmark.out
  ILINK.IlinkIcfFile: MK28FN2M0xxx15_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/mmcau/asm-cm4-cm7/lib_mmcau.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK28FN2M0VMI15; FRDM_K28F; FREEDOM; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; FREESCALE_KSDK_BM; WOLFSSL_USER_SETTINGS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: wolfssl_benchmark.c user_settings.h
  group board
    ../: pin_mux.c pin_mux.h
  group board/src
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK28F15/drivers/: fsl_trng.c fsl_trng.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_smc.h fsl_smc.c fsl_sysmpu.h fsl_sysmpu.c
  group mmcau/mmcau_include
    ../../../../../middleware/mmcau/: cau_api.h fsl_mmcau.h
  group mmcau/mmcau_source
    ../../../../../middleware/mmcau/: fsl_mmcau.c
  group startup
    ../../../../../devices/MK28F15/: system_MK28F15.c system_MK28F15.h
    ../../../../../devices/MK28F15/iar/: startup_MK28F15.s
  group utilities
    ../../../../../devices/MK28F15/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MK28F15/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MK28F15/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK28F15/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group wolfssl/wolfssl_include
    ../../../../../middleware/wolfssl/wolfssl/: callbacks.h certs_test.h crl.h error-ssl.h internal.h ocsp.h options.h sniffer.h sniffer_error.h ssl.h test.h version.h
    ../../../../../middleware/wolfssl/wolfssl/openssl/: ec.h ssl.h bn.h
    ../../../../../middleware/wolfssl/wolfssl/wolfcrypt/: aes.h arc4.h asn.h asn_public.h blake2.h blake2-impl.h blake2-int.h camellia.h cmac.h chacha.h chacha20_poly1305.h coding.h compress.h curve25519.h des3.h dh.h dsa.h ecc.h ed25519.h error-crypt.h fe_operations.h fips_test.h ge_operations.h hash.h hc128.h hmac.h integer.h idea.h logging.h md2.h md4.h md5.h mem_track.h memory.h misc.h mpi_class.h mpi_superclass.h pkcs7.h poly1305.h pwdbased.h rabbit.h random.h ripemd.h rsa.h settings.h sha.h sha256.h sha512.h signature.h srp.h tfm.h types.h visibility.h wc_encrypt.h wc_port.h
  group wolfssl/wolfssl_source
    ../../../../../middleware/wolfssl/wolfcrypt/src/: aes.c arc4.c asm.c asn.c blake2b.c camellia.c cmac.c chacha.c chacha20_poly1305.c coding.c compress.c curve25519.c des3.c dh.c dsa.c ecc.c ecc_fp.c ed25519.c error.c fe_low_mem.c fe_operations.c ge_low_mem.c ge_operations.c hash.c hc128.c hmac.c integer.c idea.c logging.c md2.c md4.c md5.c memory.c misc.c pkcs7.c poly1305.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha512.c signature.c srp.c tfm.c wc_encrypt.c wc_port.c
    ../../../../../middleware/wolfssl/src/: async.c crl.c internal.c io.c keys.c ocsp.c sniffer.c ssl.c tls.c
  group wolfssl/wolfssl_port
    ../../../../../middleware/wolfssl/wolfcrypt/src/port/nxp/: ksdk_port.c
    ../../../../../middleware/wolfssl/wolfssl/wolfcrypt/port/nxp/: ksdk_port.h
