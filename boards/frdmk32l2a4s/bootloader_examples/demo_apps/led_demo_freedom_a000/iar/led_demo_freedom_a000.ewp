# IAR project led_demo_freedom_a000.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: K32L2A41xxxxA NXP K32L2A41xxxxA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CPU_K32L2A41VLL1A; CPU_IS_ARM_CORTEX_M0P=1; FREEDOM; FRDM_K32L2A4S
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050,Pe1105,Pe1305,Pa182
  ICCARM.CCIncludePath2: ..; ../../../../../../middleware/mcu-boot/apps/led_demo/src; ../../../../../../devices/K32L2A41A/drivers; ../../../../../../devices/K32L2A41A; ../../../../../../middleware/mcu-boot/src/include; ../../../../../../middleware/mcu-boot/src/startup; ../../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG; BL_HAS_BOOTLOADER_CONFIG
  ILINK.IlinkOutputFile: led_demo_freedom_a000.out
  ILINK.IlinkIcfFile: ../../../../../../middleware/mcu-boot/targets/common/linker/iar/K32L2A41A/K32L2A41xxxxA_application_0xA000.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group board
    ../: pin_mux.c pin_mux.h
  group K32L2A41A
    ../: main.c
    ../../../../../../middleware/mcu-boot/apps/led_demo/src/: milliseconds_delay.h milliseconds_delay.c
  group drivers
    ../../../../../../devices/K32L2A41A/drivers/: fsl_port.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_wdog32.h fsl_wdog32.c fsl_common.h fsl_common.c
  group device
    ../../../../../../devices/K32L2A41A/: fsl_device_registers.h K32L2A41A.h K32L2A41A_features.h system_K32L2A41A.h system_K32L2A41A.c
  group startup
    ../../../../../../middleware/mcu-boot/src/startup/: crt0.s startup.c
    ../../../../../../middleware/mcu-boot/targets/K32L2A41A/src/startup/iar/: startup_K32L2A41A.s
  group source/include
    ../../../../../../middleware/mcu-boot/src/include/: bootloader_core.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm0plus.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
