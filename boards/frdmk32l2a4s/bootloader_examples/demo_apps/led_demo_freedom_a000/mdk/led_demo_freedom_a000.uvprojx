# Keil uVision project led_demo_freedom_a000.uvprojx, settings and files
target led_demo_freedom_a000 release (ARM-ADS)
  device: K32L2A41VLL1A NXP
  pack: Keil.Kinetis_KLxx_DFP.1.9.0
  cpu: CPUTYPE("Cortex-M0+")
  output: led_demo_freedom_a000.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_K32L2A41VLL1A, CPU_IS_ARM_CORTEX_M0P=1, FREEDOM, FRDM_K32L2A4S
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -Wno-null-dereference  -Wno-unknown-attributes  -Wno-expansion-to-defined  -Wno-invalid-noreturn
  c include: ..;../../../../../../middleware/mcu-boot/apps/led_demo/src;../../../../../../devices/K32L2A41A/drivers;../../../../../../devices/K32L2A41A;../../../../../../middleware/mcu-boot/src/include;../../../../../../middleware/mcu-boot/src/startup;../../../../../../CMSIS/Include
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
  scatter file: ../../../../../../middleware/mcu-boot/targets/common/linker/arm/K32L2A41A/K32L2A41xxxxA_application_0xa000.scf
  link misc: --remove --keep=*(.FlashConfig) --datacompressor off
  group board
    ../: pin_mux.c pin_mux.h
  group K32L2A41A
    ../: main.c
    ../../../../../../middleware/mcu-boot/apps/led_demo/src/: milliseconds_delay.h milliseconds_delay.c
  group drivers
    ../../../../../../devices/K32L2A41A/drivers/: fsl_port.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_wdog32.h fsl_wdog32.c fsl_common.h fsl_common.c
  group device
    ../../../../../../devices/K32L2A41A/: fsl_device_registers.h K32L2A41A.h K32L2A41A_features.h system_K32L2A41A.h system_K32L2A41A.c
  group startup
    ../../../../../../middleware/mcu-boot/targets/K32L2A41A/src/startup/arm/: startup_K32L2A41A.S
    ../../../../../../middleware/mcu-boot/src/startup/: startup.c
  group source/include
    ../../../../../../middleware/mcu-boot/src/include/: bootloader_core.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm0plus.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
