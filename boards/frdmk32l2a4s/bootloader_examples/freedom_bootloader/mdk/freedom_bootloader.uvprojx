# Keil uVision project freedom_bootloader.uvprojx, settings and files
target freedom_bootloader debug (ARM-ADS)
  device: K32L2A41VLL1A NXP
  pack: Keil.Kinetis_KLxx_DFP.1.9.0
  cpu: CPUTYPE("Cortex-M0+")
  output: freedom_bootloader.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_K32L2A41VLL1A, CPU_IS_ARM_CORTEX_M0P=1, FREEDOM, BL_TARGET_FLASH, FRDM_K32L2A4S, USB_STACK_BM, FSL_OSA_BM_TIMER_CONFIG=FSL_OSA_BM_TIMER_NONE
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -Wno-null-dereference  -Wno-unknown-attributes  -Wno-expansion-to-defined  -Wno-invalid-noreturn
  c include: ..;../../../../../devices/K32L2A41A/drivers;../../../../../devices/K32L2A41A;../../../../../middleware/usb/device;../../../../../components/osa;../../../../../middleware/usb/include;../../../../../middleware/mcu-boot/src/autobaud;../../../../../middleware/mcu-boot/src/bootloader;../../../../../middleware/mcu-boot/src/crc;../../../../../middleware/mcu-boot/src/include;../../../../../middleware/mcu-boot/src/memory;../../../../../middleware/mcu-boot/src/memory/src;../../../../../middleware/mcu-boot/src/startup;../../../../../middleware/mcu-boot/src/packet;../../../../../middleware/mcu-boot/src/property;../../../../../middleware/mcu-boot/src/sbloader;../../../../../middleware/mcu-boot/src/utilities;../../../../../middleware/mcu-boot/src/drivers/smc;../../../../../middleware/mcu-boot/targets/K32L2A41A/src;../../../../../middleware/mcu-boot/src/drivers/ltc;../../../../../middleware/mcu-boot/src/bm_usb;../../../../../middleware/mcu-boot/src/drivers/mmcau;../../../../../middleware/mcu-boot/src/security;../../../../../middleware/mcu-boot/src/drivers/microseconds;../../../../../CMSIS/Include;../../../../../components/lists
  asm define: DEBUG, BL_HAS_BOOTLOADER_CONFIG=0
  asm include: ../../../../../middleware/mcu-boot/src/startup
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
  scatter file: ../../../../../middleware/mcu-boot/targets/common/linker/arm/K32L2A41A/K32L2A41xxxxA_application_0x0000.scf
  link misc: --remove --keep=*(.FlashConfig) --datacompressor off
  group board
    ../: pin_mux.c pin_mux.h
  group drivers
    ../../../../../devices/K32L2A41A/drivers/: fsl_clock.h fsl_clock.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_lpi2c.c fsl_lpi2c.h fsl_port.h fsl_lpspi.c fsl_lpspi.h fsl_crc.c fsl_crc.h fsl_intmux.h fsl_intmux.c fsl_smc.h fsl_smc.c fsl_wdog32.h fsl_wdog32.c fsl_common.h fsl_common.c
  group device
    ../../../../../devices/K32L2A41A/: fsl_device_registers.h K32L2A41A.h K32L2A41A_features.h system_K32L2A41A.h system_K32L2A41A.c
  group usb/device/include
    ../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group usb/device/source
    ../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h usb_device_dci.h
    ../: usb_device_ch9.c usb_device_ch9.h
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c
  group usb/device/source/khci
    ../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
  group usb/include
    ../../../../../middleware/usb/include/: usb.h usb.h usb_misc.h usb_spec.h
  group usb/device/class/hid
    ../: usb_device_hid.c usb_device_hid.h
  group usb/device/class/msc
    ../: usb_device_msc.c usb_device_msc.h usb_device_msc_ufi.c usb_device_msc_ufi.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group startup
    ../../../../../middleware/mcu-boot/targets/K32L2A41A/src/startup/arm/: startup_K32L2A41A.S
    ../../../../../middleware/mcu-boot/src/startup/: ar_asm_macros.h startup.c
  group source/autobaud
    ../../../../../middleware/mcu-boot/src/autobaud/: autobaud.h
    ../../../../../middleware/mcu-boot/src/autobaud/src/: autobaud_irq.c
  group source/bootloader
    ../../../../../middleware/mcu-boot/src/bootloader/: bl_peripheral_interface.h bl_user_entry.h bl_version.h bootloader.h bl_command.h bl_context.h bl_peripheral.h bl_shutdown_cleanup.h bl_irq_common.h bl_app_crc_check.h bl_reliable_update.h
  group source/bootloader/src
    ../../../../../middleware/mcu-boot/src/bootloader/src/: bl_user_entry.c bl_main.c bl_context.c bl_exception_handler.c bl_tree_root.c bl_command.c bl_shutdown_cleanup.c bl_app_crc_check.c bl_misc.c bl_reliable_update.c lpuart_peripheral_interface.c lpspi_peripheral_interface.c lpi2c_peripheral_interface.c usb_hid_msc_peripheral_interface.c
  group source/crc
    ../../../../../middleware/mcu-boot/src/crc/: crc16.h crc32.h
    ../../../../../middleware/mcu-boot/src/crc/src/: crc16.c crc32.c
  group source/include
    ../../../../../middleware/mcu-boot/src/include/: bootloader_common.h bootloader_core.h
  group source/memory
    ../../../../../middleware/mcu-boot/src/memory/: memory.h
  group source/memory/src
    ../../../../../middleware/mcu-boot/src/memory/src/: sram_init.h memory.c normal_memory.h normal_memory.c pattern_fill_mdk.s pattern_fill.h flash_memory.h flash_memory.c sram_init_cm0plus.c
  group source/packet
    ../../../../../middleware/mcu-boot/src/packet/: command_packet.h serial_packet.h
  group source/packet/src
    ../../../../../middleware/mcu-boot/src/packet/src/: serial_packet.c
  group source/property
    ../../../../../middleware/mcu-boot/src/property/: property.h
  group source/sbloader
    ../../../../../middleware/mcu-boot/src/sbloader/: sbloader.h sb_file_format.h
  group source/sbloader/src
    ../../../../../middleware/mcu-boot/src/sbloader/src/: sbloader.c
  group source/utilities
    ../../../../../middleware/mcu-boot/src/utilities/: fsl_rtos_abstraction.h fsl_assert.h vector_table_info.h kinetis_family.h
  group source/utilities/src
    ../../../../../middleware/mcu-boot/src/utilities/src/: fsl_assert.c fsl_rtos_abstraction.c debug_util.c
  group source/drivers/smc
    ../../../../../middleware/mcu-boot/src/drivers/smc/: smc.c smc.h
  group source/property/src
    ../../../../../middleware/mcu-boot/src/property/src/: property_kinetis.c
  group K32L2A41A
    ../../../../../middleware/mcu-boot/targets/K32L2A41A/src/: bootloader_config.h bl_clock_config_K32L2A41A.c hardware_init_K32L2A41A.c memory_map_K32L2A41A.c bl_peripherals_K32L2A41A.c peripherals_pinmux.h target_config.h bl_lpspi_irq_config_K32L2A41A.c bl_lpi2c_irq_config_K32L2A41A.c bl_lpuart_irq_config_K32L2A41A.c
    ../../../../../middleware/mcu-boot/targets/common/src/: pinmux_utility_common.c bl_intmux_irq.c
  group source/usb/bm_composite
    ../../../../../middleware/mcu-boot/targets/K32L2A41A/src/: usb_device_config.h
    ../../../../../middleware/mcu-boot/src/bm_usb/: bootloader_hid_report_ids.h fat_directory_entry.h composite.h composite.c hid_bootloader.h hid_bootloader.c msc_disk.h msc_disk.c usb_descriptor.h usb_descriptor.c
  group source
    ../../../../../middleware/mcu-boot/src/drivers/ltc/: ltc.h
  group source/drivers/mmcau
    ../../../../../middleware/mcu-boot/src/drivers/mmcau/: mmcau.h
    ../../../../../middleware/mcu-boot/src/drivers/mmcau/src/: mmcau_aes_functions.c
  group source/security
    ../../../../../middleware/mcu-boot/src/security/: aes_security.h aes128_key_wrap_unwrap.h cbc_mac.h
  group source/security/src
    ../../../../../middleware/mcu-boot/src/security/src/: aes_security.c aes128_key_wrap_unwrap.c cbc_mac.c
  group source/drivers/microseconds
    ../../../../../middleware/mcu-boot/src/drivers/microseconds/: microseconds.h
    ../../../../../middleware/mcu-boot/src/drivers/microseconds/src/: microseconds_sysclk.c
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm0plus.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
target freedom_bootloader release (ARM-ADS)
  device: K32L2A41VLL1A NXP
  pack: Keil.Kinetis_KLxx_DFP.1.9.0
  cpu: CPUTYPE("Cortex-M0+")
  output: freedom_bootloader.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_K32L2A41VLL1A, CPU_IS_ARM_CORTEX_M0P=1, FREEDOM, BL_TARGET_FLASH, FRDM_K32L2A4S, USB_STACK_BM, FSL_OSA_BM_TIMER_CONFIG=FSL_OSA_BM_TIMER_NONE
  c misc: as above
  c include: as above
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=0
  asm include: ../../../../../middleware/mcu-boot/src/startup
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
  scatter file: as above
  link misc: --remove --keep=*(.FlashConfig) --datacompressor off
