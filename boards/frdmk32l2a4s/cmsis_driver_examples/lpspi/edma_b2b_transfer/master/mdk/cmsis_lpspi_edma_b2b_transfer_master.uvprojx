# Keil uVision project cmsis_lpspi_edma_b2b_transfer_master.uvprojx, settings and files
target cmsis_lpspi_edma_b2b_transfer_master debug (ARM-ADS)
  device: K32L2A41VLL1A NXP
  pack: Keil.Kinetis_KLxx_DFP.1.9.0
  cpu: CPUTYPE("Cortex-M0+")
  output: cmsis_lpspi_edma_b2b_transfer_master.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_K32L2A41VLL1A, FRDM_K32L2A4S, FREEDOM
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../../devices/K32L2A41A/utilities/debug_console_lite;../../../../../../../devices/K32L2A41A/drivers;../../../../../../../devices/K32L2A41A/cmsis_drivers;../../../../../../../devices/K32L2A41A;../../../../../../../components/uart;../../../../../../../components/lists;../../../../../../../CMSIS/Include;../../../../../../../CMSIS/Driver/Include
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
  scatter file: K32L2A41xxxxA_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
  group source
    ../: cmsis_lpspi_edma_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../../../devices/K32L2A41A/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../../devices/K32L2A41A/drivers/: fsl_port.h fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.h fsl_lpspi_edma.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c
    ../../../../../../../devices/K32L2A41A/cmsis_drivers/: fsl_lpspi_cmsis.h fsl_lpspi_cmsis.c
  group device
    ../../../../../../../devices/K32L2A41A/: fsl_device_registers.h K32L2A41A.h K32L2A41A_features.h system_K32L2A41A.c system_K32L2A41A.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../../devices/K32L2A41A/arm/: startup_K32L2A41A.S
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm0plus.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_SPI.h Driver_Common.h
target cmsis_lpspi_edma_b2b_transfer_master release (ARM-ADS)
  device: K32L2A41VLL1A NXP
  pack: Keil.Kinetis_KLxx_DFP.1.9.0
  cpu: CPUTYPE("Cortex-M0+")
  output: cmsis_lpspi_edma_b2b_transfer_master.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_K32L2A41VLL1A, FRDM_K32L2A4S, FREEDOM
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
  scatter file: K32L2A41xxxxA_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
