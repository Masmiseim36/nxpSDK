# Keil uVision project safety_iec60730b.uvprojx, settings and files
target safety_iec60730b debug (ARM-ADS)
  device: K32L2A41VLL1A NXP
  pack: Keil.Kinetis_KLxx_DFP.1.9.0
  cpu: CPUTYPE("Cortex-M0+")
  output: safety_iec60730b.out +hex
  AfterMake: ..\..\..\..\..\middleware\safety_iec60730b\tools\crc\crc_hex.bat -..\..\..\..\boards\frdmk32l2a4s\demo_apps\safety_iec60730b\mdk\debug\safety_iec60730b.hex -..\..\..\..\boards\frdmk32l2a4s\demo_apps\safety_iec60730b\mdk\debug\safety_iec60730b_crc.hex -..\..\..\..\tools\srecord\srec_cat
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_K32L2A41VLL1A, FRDM_K32L2A4S, FREEDOM, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../middleware/safety_iec60730b/boards/common/cm0/startup/cm0;..;linker;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/register;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/ram;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/flash;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/stack;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/programCounter;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0;../../../../../middleware/safety_iec60730b/safety/v4_1;../../../../../middleware/safety_iec60730b/safety/v4_1/compiler;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/wdog;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/tsi;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/dio;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/clock;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/aio;../../../../../devices/K32L2A41A;../../../../../devices/K32L2A41A/drivers;../../../../../devices/K32L2A41A/utilities/str;../../../../../devices/K32L2A41A/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../middleware/freemaster/src/common;../../../../../middleware/freemaster/src/platforms/gen32le;../../../../../middleware/freemaster/src/drivers/mcuxsdk/can;../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial;../../../../../CMSIS/Include
  asm define: DEBUG
  asm include: ../../../../../middleware/safety_iec60730b/boards/common/cm0/startup/cm0;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/register;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/ram;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/flash;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/stack;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/programCounter;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0;../../../../../middleware/safety_iec60730b/safety/v4_1;../../../../../middleware/safety_iec60730b/safety/v4_1/compiler;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/wdog;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/tsi;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/dio;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/clock;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/aio;../../../../../devices/K32L2A41A
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
  scatter file: linker/frdmk32l2a4s_safety.sct
  link misc: ../../../../../middleware/safety_iec60730b/safety/v4_1/IEC60730B_M0_KEIL_v4_1.lib ../../../../../middleware/safety_iec60730b/safety/v4_1/IEC60730B_M0_COM_KEIL_v4_1.lib --remove --datacompressor=off
  group source
    ../: freemaster_cfg.h safety_test_items.h safety_test_items.c isr.h safety_config.h project_setup_frdmk32l2a4s.h project_setup_frdmk32l2a4s.c safety_cm0_kinetis.c safety_cm0_kinetis.h main.c
  group doc
    ../: readme.txt
  group board
    ../: pin_mux.c pin_mux.h clock_config.c clock_config.h board.c board.h
  group linker
    ../../../../../middleware/safety_iec60730b/tools/crc/: crc_hex.bat
    linker/: frdmk32l2a4s_safety.sct linker_config.h
  group tools/srecord
    ../../../../../tools/srecord/: srecord-1.64.zip
  group startup
    ../../../../../middleware/safety_iec60730b/boards/common/cm0/startup/cm0/: start.c startup_mdk.c vectors_mdk.c vectors_mdk.h
  group GUI
    ../GUI/: safety.pmp
  group safety/v4_1/register
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/register/: iec60730b_cm0_reg.h
  group safety/v4_1/ram
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/ram/: iec60730b_cm0_ram.h
  group safety/v4_1/flash
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/flash/: iec60730b_cm0_flash.h
  group safety/v4_1/stack
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/stack/: iec60730b_cm0_stack.h
  group safety/v4_1/programCounter
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/programCounter/: iec60730b_cm0_pc.h iec60730b_cm0_pc_object.S
  group safety/v4_1
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/: iec60730b_core.h
    ../../../../../middleware/safety_iec60730b/safety/v4_1/: iec60730b.h iec60730b_types.h
  group safety/v4_1/compiler
    ../../../../../middleware/safety_iec60730b/safety/v4_1/compiler/: asm_mac_common.h
  group safety/v4_1/wdog
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/wdog/: iec60730b_wdog.c iec60730b_wdog.h
  group safety/v4_1/tsi
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/tsi/: iec60730b_tsi.h
  group safety/v4_1/dio
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/dio/: iec60730b_dio_ext.h iec60730b_dio.h
  group safety/v4_1/clock
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/clock/: iec60730b_clock.h
  group safety/v4_1/aio
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/aio/: iec60730b_aio.h
  group K32L2A41A
    ../../../../../devices/K32L2A41A/: system_K32L2A41A.c system_K32L2A41A.h
  group drivers
    ../../../../../devices/K32L2A41A/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c
  group device
    ../../../../../devices/K32L2A41A/: fsl_device_registers.h K32L2A41A.h K32L2A41A_features.h
  group utilities
    ../../../../../devices/K32L2A41A/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/K32L2A41A/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/K32L2A41A/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group freemaster
    ../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_defcfg.h freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h freemaster_can.c freemaster_can.h freemaster_sha.c freemaster_pdbdm.c freemaster_serial.c freemaster_serial.h
  group freemaster/platforms
    ../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group freemaster/drivers
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mscan.c freemaster_mscan.h freemaster_mcan.c freemaster_mcan.h
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_usb.c freemaster_serial_usb.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm0plus.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
