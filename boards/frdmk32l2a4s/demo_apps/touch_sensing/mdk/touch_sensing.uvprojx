# Keil uVision project touch_sensing.uvprojx, settings and files
target touch_sensing debug (ARM-ADS)
  device: K32L2A41VLL1A NXP
  pack: Keil.Kinetis_KLxx_DFP.1.9.0
  cpu: CPUTYPE("Cortex-M0+")
  output: touch_sensing.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_K32L2A41VLL1A, SDK_DEBUGCONSOLE_UART, FRDM_K32L2A4S, FREEDOM
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../middleware/touch/source/drivers/tsi;../../../../../middleware/touch/source/modules;../../../../../middleware/touch/include;..;../../../../../devices/K32L2A41A/drivers;../../../../../devices/K32L2A41A/utilities/debug_console_lite;../../../../../middleware/touch/source/controls;../../../../../middleware/touch/source/electrodes;../../../../../middleware/touch/source/filters;../../../../../middleware/touch/source/keydetectors;../../../../../middleware/touch/source/system;../../../../../middleware/touch/source/safety;../../../../../devices/K32L2A41A;../../../../../components/uart;../../../../../components/lists;../../../../../middleware/freemaster/src/common;../../../../../middleware/freemaster/src/platforms/gen32le;../../../../../middleware/freemaster/src/drivers/mcuxsdk/can;../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial;../../../../../CMSIS/Include
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
  scatter file: K32L2A41xxxxA_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
  group touch/source/drivers/tsi
    ../../../../../middleware/touch/source/drivers/tsi/: nt_drv_tsi_common.c nt_drv_tsi_driver.c nt_drv_tsi_driver.h nt_drv_tsi_v4_driver_specific.c
  group touch/source/modules
    ../../../../../middleware/touch/source/modules/: nt_module_tsi.c nt_module_tsi_prv.h nt_module_gpio.c nt_module_gpio_prv.h nt_module_gpioint.c nt_module_gpioint_prv.h nt_modules.c nt_modules_prv.h
  group touch/include
    ../../../../../middleware/touch/include/: nt_module_tsi.h nt.h nt_control_arotary.h nt_control_aslider.h nt_control_keypad.h nt_control_matrix.h nt_control_proxi.h nt_control_rotary.h nt_control_slider.h nt_controls.h nt_electrodes.h nt_filters.h nt_gpio.h nt_keydetector_afid.h nt_keydetector_safa.h nt_keydetector_usafa.h nt_keydetectors.h nt_module_gpio.h nt_module_gpioint.h nt_modules.h nt_safety.h nt_system.h nt_types.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source
    ../: freemaster_cfg.h main.c main.h nt_setup.c nt_setup.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/K32L2A41A/drivers/: fsl_port.h fsl_intmux.h fsl_intmux.c fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_lpit.c fsl_lpit.h fsl_smc.h fsl_smc.c fsl_tsi_v4.h fsl_tsi_v4.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c
  group utilities
    ../../../../../devices/K32L2A41A/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group touch/source/controls
    ../../../../../middleware/touch/source/controls/: nt_control_arotary.c nt_control_arotary_prv.h nt_control_aslider.c nt_control_aslider_prv.h nt_control_keypad.c nt_control_keypad_prv.h nt_control_matrix.c nt_control_matrix_prv.h nt_control_proxi.c nt_control_proxi_prv.h nt_control_rotary.c nt_control_rotary_prv.h nt_control_slider.c nt_control_slider_prv.h nt_controls.c nt_controls_prv.h
  group touch/source/electrodes
    ../../../../../middleware/touch/source/electrodes/: nt_electrodes.c nt_electrodes_prv.h
  group touch/source/filters
    ../../../../../middleware/touch/source/filters/: nt_filters.c nt_filters_prv.h
  group touch/source/keydetectors
    ../../../../../middleware/touch/source/keydetectors/: nt_keydetector_afid.c nt_keydetector_afid_prv.h nt_keydetector_prv.h nt_keydetector_safa.c nt_keydetector_safa_prv.h nt_keydetector_usafa.c nt_keydetector_usafa_prv.h
  group touch/source
    ../../../../../middleware/touch/source/: nt.c
  group touch/source/system
    ../../../../../middleware/touch/source/system/: nt_system.c nt_system_frmstr.c nt_system_frmstr_prv.h nt_system_mem.c nt_system_mem_prv.h nt_system_prv.h
  group touch/source/safety
    ../../../../../middleware/touch/source/safety/: nt_safety_crc.h nt_safety_gpio.h nt_safety_prv.h
  group device
    ../../../../../devices/K32L2A41A/: fsl_device_registers.h K32L2A41A.h K32L2A41A_features.h system_K32L2A41A.c system_K32L2A41A.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/K32L2A41A/arm/: startup_K32L2A41A.S
  group freemaster
    ../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_defcfg.h freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h freemaster_can.c freemaster_can.h freemaster_sha.c freemaster_pdbdm.c freemaster_serial.c freemaster_serial.h
  group freemaster/platforms
    ../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group freemaster/drivers
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mscan.c freemaster_mscan.h freemaster_mcan.c freemaster_mcan.h
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_usb.c freemaster_serial_usb.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm0plus.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
target touch_sensing release (ARM-ADS)
  device: K32L2A41VLL1A NXP
  pack: Keil.Kinetis_KLxx_DFP.1.9.0
  cpu: CPUTYPE("Cortex-M0+")
  output: touch_sensing.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_K32L2A41VLL1A, SDK_DEBUGCONSOLE_UART, FRDM_K32L2A4S, FREEDOM
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
  scatter file: K32L2A41xxxxA_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
