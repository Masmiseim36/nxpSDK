# IAR project fmstr_example_any.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: K32L2A41xxxxA NXP K32L2A41xxxxA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_K32L2A41VLL1A; SDK_DEBUGCONSOLE=1; FRDM_K32L2A4S; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../common/fmstr_example; ../../../../../devices/K32L2A41A/drivers; ../../../../../devices/K32L2A41A/utilities/debug_console_lite; ../../../../../middleware/freemaster/src/common; ../../../../../devices/K32L2A41A; ../../../../../components/uart; ../../../../../middleware/freemaster/src/platforms/gen32le; ../../../../../middleware/freemaster/src/drivers/mcuxsdk/can; ../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial; ../../../../../components/lists; ../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: fmstr_example_any.out
  ILINK.IlinkIcfFile: K32L2A41xxxxA_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_K32L2A41VLL1A; SDK_DEBUGCONSOLE=1; FRDM_K32L2A4S; FREEDOM
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: main.c freemaster_cfg.h freemaster_democfg.h
    ../../common/fmstr_example/: freemaster_example_per.c freemaster_example.h
  group source/example_data
    ../../common/fmstr_example/: data_example_pmp.h data_img_logo.h data_img_file.h data_img_fmstrlogo.h data_html_index.h example_data.h
  group board
    ../: clock_config.c clock_config.h pin_mux.c pin_mux.h peripherals.c peripherals.h board.c board.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/K32L2A41A/drivers/: fsl_sim.h fsl_sim.c fsl_port.h fsl_clock.h fsl_clock.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c
  group utilities
    ../../../../../devices/K32L2A41A/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group freemaster
    ../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_defcfg.h freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h freemaster_can.c freemaster_can.h freemaster_sha.c freemaster_pdbdm.c freemaster_serial.c freemaster_serial.h
  group freemaster/platforms
    ../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group freemaster/drivers
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mscan.c freemaster_mscan.h freemaster_mcan.c freemaster_mcan.h
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_usb.c freemaster_serial_usb.h
  group device
    ../../../../../devices/K32L2A41A/: fsl_device_registers.h K32L2A41A.h K32L2A41A_features.h system_K32L2A41A.c system_K32L2A41A.h
  group startup
    ../../../../../devices/K32L2A41A/iar/: startup_K32L2A41A.s
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm0plus.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
