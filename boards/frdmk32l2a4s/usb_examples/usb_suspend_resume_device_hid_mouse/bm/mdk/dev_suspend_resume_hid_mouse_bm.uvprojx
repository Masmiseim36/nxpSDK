# Keil uVision project dev_suspend_resume_hid_mouse_bm.uvprojx, settings and files
target dev_suspend_resume_hid_mouse_bm debug (ARM-ADS)
  device: K32L2A41VLL1A NXP
  pack: Keil.Kinetis_KLxx_DFP.1.9.0
  cpu: CPUTYPE("Cortex-M0+")
  output: dev_suspend_resume_hid_mouse_bm.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: _DEBUG=1, DEBUG, CPU_K32L2A41VLL1A, USB_STACK_BM, USB_STACK_USE_DEDICATED_RAM=1, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SDK_DEBUGCONSOLE=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../middleware/usb/device;../../../../../../middleware/usb/include;../../../../../../components/timer;../../../../../../devices/K32L2A41A/utilities/debug_console_lite;../../../../../../devices/K32L2A41A/drivers;../../../../../../devices/K32L2A41A;../../../../../../components/uart;../../../../../../components/lists;../../../../../../components/osa;../../../../../../CMSIS/Include
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
  scatter file: K32L2A41xxxxA_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x2000" --predefine="-D__usb_use_usbram__=1"
  group doc
    ../: readme.txt
  group source
    ../: mouse.c mouse.h usb_device_descriptor.c usb_device_descriptor.h usb_device_config.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group usb/device/source/khci
    ../../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb.h usb_misc.h usb_spec.h
  group component/timer
    ../../../../../../components/timer/: fsl_adapter_timer.h fsl_adapter_lpit.c
  group utilities
    ../../../../../../devices/K32L2A41A/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h usb_device_dci.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/hid
    ../: usb_device_hid.c usb_device_hid.h
  group drivers
    ../../../../../../devices/K32L2A41A/drivers/: fsl_smc.h fsl_smc.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_lpit.c fsl_lpit.h
  group device
    ../../../../../../devices/K32L2A41A/: fsl_device_registers.h K32L2A41A.h K32L2A41A_features.h system_K32L2A41A.c system_K32L2A41A.h
  group startup
    ../../../../../../devices/K32L2A41A/arm/: startup_K32L2A41A.S
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group usb/device/include
    ../../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm0plus.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
target dev_suspend_resume_hid_mouse_bm release (ARM-ADS)
  device: K32L2A41VLL1A NXP
  pack: Keil.Kinetis_KLxx_DFP.1.9.0
  cpu: CPUTYPE("Cortex-M0+")
  output: dev_suspend_resume_hid_mouse_bm.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: _DEBUG=0, NDEBUG, CPU_K32L2A41VLL1A, USB_STACK_BM, USB_STACK_USE_DEDICATED_RAM=1, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SDK_DEBUGCONSOLE=1
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
  scatter file: K32L2A41xxxxA_flash.scf
  link misc: as above
