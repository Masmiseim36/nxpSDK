# IAR project dev_suspend_resume_hid_mouse_freertos.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: K32L2A41xxxxA NXP K32L2A41xxxxA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: _DEBUG=1; DEBUG; CPU_K32L2A41VLL1A; USB_STACK_FREERTOS; USB_STACK_USE_DEDICATED_RAM=1; USB_STACK_FREERTOS_HEAP_SIZE=32768; FSL_RTOS_FREE_RTOS; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SERIAL_PORT_TYPE_UART=1; SDK_DEBUGCONSOLE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../..; ../../../../../../middleware/usb/device; ../../../../../../middleware/usb/include; ../../../../../../components/timer; ../../../../../../rtos/freertos/freertos_kernel/include; ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM0; ../../../../../../devices/K32L2A41A/drivers; ../../../../../../devices/K32L2A41A; ../../../../../../devices/K32L2A41A/utilities/str; ../../../../../../devices/K32L2A41A/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../components/osa; ../../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..; ../../../..
  ILINK.IlinkOutputFile: dev_suspend_resume_hid_mouse_freertos.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x100; __usb_use_usbram__=1
  ILINK.IlinkIcfFile: K32L2A41xxxxA_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; NDEBUG; CPU_K32L2A41VLL1A; USB_STACK_FREERTOS; USB_STACK_USE_DEDICATED_RAM=1; USB_STACK_FREERTOS_HEAP_SIZE=32768; FSL_RTOS_FREE_RTOS; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SERIAL_PORT_TYPE_UART=1; SDK_DEBUGCONSOLE=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group doc
    ../: readme.txt
  group source
    ../: mouse.c mouse.h usb_device_descriptor.c usb_device_descriptor.h usb_device_config.h FreeRTOSConfig.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h usb_device_dci.h
  group usb/device/source/khci
    ../../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/hid
    ../: usb_device_hid.c usb_device_hid.h
  group usb/device/include
    ../../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb.h usb_misc.h usb_spec.h
  group component/timer
    ../../../../../../components/timer/: fsl_adapter_timer.h fsl_adapter_lpit.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c
  group freertos/freertos_kernel
    ../../../../../../rtos/freertos/freertos_kernel/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos_kernel/portable/IAR/ARM_CM0
    ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/include
    ../../../../../../rtos/freertos/freertos_kernel/include/: croutine.h StackMacros.h atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group drivers
    ../../../../../../devices/K32L2A41A/drivers/: fsl_smc.h fsl_smc.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_lpit.c fsl_lpit.h
  group device
    ../../../../../../devices/K32L2A41A/: fsl_device_registers.h K32L2A41A.h K32L2A41A_features.h system_K32L2A41A.c system_K32L2A41A.h
  group startup
    ../../../../../../devices/K32L2A41A/iar/: startup_K32L2A41A.s
  group utilities
    ../../../../../../devices/K32L2A41A/utilities/: fsl_assert.c
    ../../../../../../devices/K32L2A41A/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/K32L2A41A/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm0plus.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
