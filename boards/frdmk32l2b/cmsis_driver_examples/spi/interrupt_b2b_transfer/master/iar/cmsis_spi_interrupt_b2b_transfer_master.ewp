# IAR project cmsis_spi_interrupt_b2b_transfer_master.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: K32L2B31xxxxA NXP K32L2B31xxxxA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_K32L2B31VLH0A; FRDM_K32L2B; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../../devices/K32L2B31A/utilities/debug_console_lite; ../../../../../../../devices/K32L2B31A/drivers; ../../../../../../../devices/K32L2B31A/cmsis_drivers; ../../../../../../../devices/K32L2B31A; ../../../../../../../components/uart; ../../../../../../../components/lists; ../../../../../../../CMSIS/Include; ../../../../../../../CMSIS/Driver/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: cmsis_spi_interrupt_b2b_transfer_master.out
  ILINK.IlinkIcfFile: K32L2B31xxxxA_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_K32L2B31VLH0A; FRDM_K32L2B; FREEDOM
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: cmsis_spi_interrupt_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../../../devices/K32L2B31A/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../../devices/K32L2B31A/drivers/: fsl_port.h fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_dma.h fsl_dma.c fsl_dmamux.h fsl_dmamux.c fsl_spi.h fsl_spi.c fsl_spi_dma.h fsl_spi_dma.c fsl_common.h fsl_common.c fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c
    ../../../../../../../devices/K32L2B31A/cmsis_drivers/: fsl_spi_cmsis.h fsl_spi_cmsis.c
  group device
    ../../../../../../../devices/K32L2B31A/: fsl_device_registers.h K32L2B31A.h K32L2B31A_features.h system_K32L2B31A.c system_K32L2B31A.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../../devices/K32L2B31A/iar/: startup_K32L2B31A.s
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm0plus.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_SPI.h Driver_Common.h
