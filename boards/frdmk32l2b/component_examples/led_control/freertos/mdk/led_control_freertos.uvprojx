# Keil uVision project led_control_freertos.uvprojx, settings and files
target led_control_freertos debug (ARM-ADS)
  device: K32L2B31VLH0A NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: led_control_freertos.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_K32L2B31VLH0A, USB_STACK_BM=1, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, osCustomStartup=0, FRDM_K32L2B, FREEDOM, DEBUG_CONSOLE_RX_ENABLE=0, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc --diag_suppress=1296,186
  c include: ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM0;..;../../../..;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../rtos/amazon-freertos/lib/include;../../../../../../rtos/amazon-freertos/lib/include/private;../../../../../../components/gpio;../../../../../../components/timer;../../../../../../devices/K32L2B31A/drivers;../../../../../../devices/K32L2B31A/utilities;../../../../../../devices/K32L2B31A/drivers;../../../../../../components/led;../../../../../../components/button;../../../../../../components/timer_manager;../../../../../../components/lists;../../../../../../components/panic;../../../../../../components/serial_manager;../../../../../../components/osa;../../../../../../devices/K32L2B31A/drivers;../../../../../../devices/K32L2B31A/drivers;../../../../../../devices/K32L2B31A;../../../../../../devices/K32L2B31A/utilities/str;../../../../../../devices/K32L2B31A/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../devices/K32L2B31A/drivers;../../../../../../devices/K32L2B31A/drivers;../../../../../../devices/K32L2B31A/drivers;../../../../../../devices/K32L2B31A/drivers
  asm define: DEBUG
  asm include: ..;../../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: K32L2B31xxxxA_flash.scf
  link misc: --remove
  group source
    ../: led_control.c FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h hardware_init.c app.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: board.readme
  group component/gpio
    ../../../../../../components/gpio/: gpio.h gpio_kinetis.c
  group component/timer
    ../../../../../../components/timer/: timer.h tpm_adapter.c
  group drivers
    ../../../../../../devices/K32L2B31A/drivers/: fsl_tpm.c fsl_tpm.h fsl_gpio.c fsl_gpio.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_uart.c fsl_uart.h fsl_port.h fsl_smc.c fsl_smc.h
  group utilities
    ../../../../../../devices/K32L2B31A/utilities/: fsl_shell.c fsl_shell.h fsl_assert.c
    ../../../../../../devices/K32L2B31A/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/K32L2B31A/utilities/str/: fsl_str.c fsl_str.h
  group component/led
    ../../../../../../components/led/: led.c led.h
  group component/button
    ../../../../../../components/button/: button.c button.h
  group component/timer_manager
    ../../../../../../components/timer_manager/: timer_manager.c timer_manager.h
  group component-lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group component/panic
    ../../../../../../components/panic/: panic.c panic.h
  group component-serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction_free_rtos.h
  group amazon-freertos-freertos-portable
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM0/: port.c portmacro.h
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
  group amazon-freertos-freertos
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos-include
    ../../../../../../rtos/amazon-freertos/lib/include/: FreeRTOS.h event_groups.h freertos_tasks_c_additions.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
    ../../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h stack_macros.h threading_alt.h
  group device
    ../../../../../../devices/K32L2B31A/: K32L2B31A.h K32L2B31A_features.h fsl_device_registers.h system_K32L2B31A.c system_K32L2B31A.h
  group component-uart
    ../../../../../../components/uart/: lpuart_adapter.c uart.h
  group startup
    ../../../../../../devices/K32L2B31A/arm/: startup_K32L2B31A.s
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm0plus.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
target led_control_freertos release (ARM-ADS)
  device: K32L2B31VLH0A NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: led_control_freertos.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_K32L2B31VLH0A, USB_STACK_BM=1, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, osCustomStartup=0, FRDM_K32L2B, FREEDOM, DEBUG_CONSOLE_RX_ENABLE=0, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc --diag_suppress=1296,186
  c include: as above
  asm define: NDEBUG
  asm include: ..;../../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: K32L2B31xxxxA_flash.scf
  link misc: --remove
