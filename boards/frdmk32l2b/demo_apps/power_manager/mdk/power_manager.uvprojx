# Keil uVision project power_manager.uvprojx, settings and files
target power_manager debug (ARM-ADS)
  device: K32L2B31VLH0A NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: power_manager.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: DEBUG, CPU_K32L2B31VLH0A, FRDM_K32L2B, FREEDOM
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../devices/K32L2B31A/utilities/debug_console_lite;../../../../../devices/K32L2B31A/drivers;../../../../../devices/K32L2B31A/utilities;../../../../../devices/K32L2B31A;../../../../../components/uart;../../../../../components/lists;../../../../../CMSIS/Include
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: K32L2B31xxxxA_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
  group source
    ../: clock_mcglite.c power_manager.h power_manager.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../devices/K32L2B31A/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../devices/K32L2B31A/drivers/: fsl_port.h fsl_llwu.h fsl_llwu.c fsl_pmc.h fsl_pmc.c fsl_smc.h fsl_smc.c fsl_rcm.c fsl_rcm.h fsl_lptmr.c fsl_lptmr.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c
  group utilities/utilities
    ../../../../../devices/K32L2B31A/utilities/: fsl_notifier.c fsl_notifier.h
  group device
    ../../../../../devices/K32L2B31A/: fsl_device_registers.h K32L2B31A.h K32L2B31A_features.h system_K32L2B31A.c system_K32L2B31A.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/K32L2B31A/arm/: startup_K32L2B31A.S
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm0plus.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
target power_manager release (ARM-ADS)
  device: K32L2B31VLH0A NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: power_manager.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: NDEBUG, CPU_K32L2B31VLH0A, FRDM_K32L2B, FREEDOM
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: K32L2B31xxxxA_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
