<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>flexio_spi_dma_spi_transfer_slave</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>flexio_spi_dma_spi_transfer_slave</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>flexio_spi_dma_spi_transfer_slave</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>flexio_spi_dma_spi_transfer_slave</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/flexio_spi_dma_spi_transfer_slave.ewp</path>
  </project>
</workspace>
