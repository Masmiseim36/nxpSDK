# IAR project ntag_i2c_explorer_demo.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: K32L2B31xxxxA NXP K32L2B31xxxxA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_K32L2B31VLH0A; PRINTF_ADVANCED_ENABLE=1; I2C_FSL; FRDM_K32L2B; FREEDOM; HAVE_STDBOOL_H; HAVE_STDINT_H
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../devices/K32L2B31A/utilities/debug_console_lite; ../../../../../devices/K32L2B31A/drivers; ../../../../../middleware/ntag_i2c_plus/HAL_NTAG/inc; ../../../../../middleware/ntag_i2c_plus/HAL_NTAG; ../../../../../middleware/ntag_i2c_plus/HAL_I2C/inc; ../../../../../middleware/ntag_i2c_plus/HAL_ISR/inc; ../../../../../middleware/ntag_i2c_plus/HAL_ISR; ../../../../../middleware/ntag_i2c_plus/HAL_TMR/inc; ../../../../../middleware/ntag_i2c_plus/inc; ../../../../../devices/K32L2B31A; ../../../../../components/uart; ../../../../../components/lists; ../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: ntag_i2c_explorer_demo.out
  ILINK.IlinkIcfFile: K32L2B31xxxxA_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_K32L2B31VLH0A; PRINTF_ADVANCED_ENABLE=1; I2C_FSL; FRDM_K32L2B; FREEDOM; HAVE_STDBOOL_H; HAVE_STDINT_H
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: ntag_i2c_explorer_demo.c ndef_message.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../devices/K32L2B31A/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../devices/K32L2B31A/drivers/: fsl_gpio.h fsl_gpio.c fsl_port.h fsl_smc.h fsl_smc.c fsl_adc16.c fsl_adc16.h fsl_i2c.h fsl_i2c.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c
  group ntag_i2c_plus/HAL_NTAG
    ../../../../../middleware/ntag_i2c_plus/HAL_NTAG/: ntag_driver_intern.h ntag_bridge.c ntag_driver.c
  group ntag_i2c_plus/HAL_NTAG/inc
    ../../../../../middleware/ntag_i2c_plus/HAL_NTAG/inc/: ntag_bridge.h ntag_defines.h ntag_device_list.h ntag_driver.h
  group ntag_i2c_plus/HAL_I2C
    ../../../../../middleware/ntag_i2c_plus/HAL_I2C/: i2c_kinetis_fsl.c
  group ntag_i2c_plus/HAL_I2C/inc
    ../../../../../middleware/ntag_i2c_plus/HAL_I2C/inc/: HAL_I2C_driver.h HAL_I2C_kinetis_fsl.h
  group ntag_i2c_plus/HAL_ISR
    ../../../../../middleware/ntag_i2c_plus/HAL_ISR/: isr_driver_intern.h isr_kinetis_intern.h isr_common.c isr_kinetis.c
  group ntag_i2c_plus/HAL_ISR/inc
    ../../../../../middleware/ntag_i2c_plus/HAL_ISR/inc/: HAL_ISR_callback_list.h HAL_ISR_driver.h
  group ntag_i2c_plus/HAL_TMR
    ../../../../../middleware/ntag_i2c_plus/HAL_TMR/: timer_driver.c
  group ntag_i2c_plus/HAL_TMR/inc
    ../../../../../middleware/ntag_i2c_plus/HAL_TMR/inc/: HAL_timer_driver.h
  group ntag_i2c_plus/inc
    ../../../../../middleware/ntag_i2c_plus/inc/: global_types.h nfc_device.h
  group device
    ../../../../../devices/K32L2B31A/: fsl_device_registers.h K32L2B31A.h K32L2B31A_features.h system_K32L2B31A.c system_K32L2B31A.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/K32L2B31A/iar/: startup_K32L2B31A.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm0plus.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
