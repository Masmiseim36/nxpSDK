# Keil uVision project ntag_i2c_explorer_demo.uvprojx, settings and files
target ntag_i2c_explorer_demo debug (ARM-ADS)
  device: K32L2B31VLH0A NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: ntag_i2c_explorer_demo.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: DEBUG, CPU_K32L2B31VLH0A, PRINTF_ADVANCED_ENABLE=1, I2C_FSL, FRDM_K32L2B, FREEDOM, HAVE_STDBOOL_H, HAVE_STDINT_H
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../devices/K32L2B31A/utilities/debug_console_lite;../../../../../devices/K32L2B31A/drivers;../../../../../middleware/ntag_i2c_plus/HAL_NTAG/inc;../../../../../middleware/ntag_i2c_plus/HAL_NTAG;../../../../../middleware/ntag_i2c_plus/HAL_I2C/inc;../../../../../middleware/ntag_i2c_plus/HAL_ISR/inc;../../../../../middleware/ntag_i2c_plus/HAL_ISR;../../../../../middleware/ntag_i2c_plus/HAL_TMR/inc;../../../../../middleware/ntag_i2c_plus/inc;../../../../../devices/K32L2B31A;../../../../../components/uart;../../../../../components/lists;../../../../../CMSIS/Include
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: K32L2B31xxxxA_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
  group source
    ../: ntag_i2c_explorer_demo.c ndef_message.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../devices/K32L2B31A/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../devices/K32L2B31A/drivers/: fsl_gpio.h fsl_gpio.c fsl_port.h fsl_smc.h fsl_smc.c fsl_adc16.c fsl_adc16.h fsl_i2c.h fsl_i2c.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c
  group ntag_i2c_plus/HAL_NTAG/inc
    ../../../../../middleware/ntag_i2c_plus/HAL_NTAG/inc/: ntag_bridge.h ntag_defines.h ntag_device_list.h ntag_driver.h
  group ntag_i2c_plus/HAL_NTAG
    ../../../../../middleware/ntag_i2c_plus/HAL_NTAG/: ntag_driver_intern.h ntag_bridge.c ntag_driver.c
  group ntag_i2c_plus/HAL_I2C/inc
    ../../../../../middleware/ntag_i2c_plus/HAL_I2C/inc/: HAL_I2C_driver.h HAL_I2C_kinetis_fsl.h
  group ntag_i2c_plus/HAL_I2C
    ../../../../../middleware/ntag_i2c_plus/HAL_I2C/: i2c_kinetis_fsl.c
  group ntag_i2c_plus/HAL_ISR/inc
    ../../../../../middleware/ntag_i2c_plus/HAL_ISR/inc/: HAL_ISR_callback_list.h HAL_ISR_driver.h
  group ntag_i2c_plus/HAL_ISR
    ../../../../../middleware/ntag_i2c_plus/HAL_ISR/: isr_driver_intern.h isr_kinetis_intern.h isr_common.c isr_kinetis.c
  group ntag_i2c_plus/HAL_TMR/inc
    ../../../../../middleware/ntag_i2c_plus/HAL_TMR/inc/: HAL_timer_driver.h
  group ntag_i2c_plus/HAL_TMR
    ../../../../../middleware/ntag_i2c_plus/HAL_TMR/: timer_driver.c
  group ntag_i2c_plus/inc
    ../../../../../middleware/ntag_i2c_plus/inc/: global_types.h nfc_device.h
  group device
    ../../../../../devices/K32L2B31A/: fsl_device_registers.h K32L2B31A.h K32L2B31A_features.h system_K32L2B31A.c system_K32L2B31A.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/K32L2B31A/arm/: startup_K32L2B31A.S
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm0plus.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
target ntag_i2c_explorer_demo release (ARM-ADS)
  device: K32L2B31VLH0A NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: ntag_i2c_explorer_demo.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: NDEBUG, CPU_K32L2B31VLH0A, PRINTF_ADVANCED_ENABLE=1, I2C_FSL, FRDM_K32L2B, FREEDOM, HAVE_STDBOOL_H, HAVE_STDINT_H
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: K32L2B31xxxxA_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
