# IAR project cmsis_lpi2c_edma_b2b_transfer_master_cm0plus.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: K32L3A60_M0 NXP K32L3A60_M0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_K32L3A60VPJ1A_cm0plus
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../../../devices/K32L3A60/utilities/debug_console_lite; ../../../../../../../../devices/K32L3A60/drivers; ../../../../../../../../devices/K32L3A60/cmsis_drivers; ../../../../../../../../components/uart; ../../../../../../../../components/lists; ../../../../../../../../devices/K32L3A60; ../../../../../../../../CMSIS/Include; ../../../../../../../../CMSIS/Driver/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: cmsis_lpi2c_edma_b2b_transfer_master_cm0plus.out
  ILINK.IlinkIcfFile: K32L3A60xxx_cm0plus_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_K32L3A60VPJ1A_cm0plus
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: cmsis_lpi2c_edma_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../../../../devices/K32L3A60/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../../../devices/K32L3A60/drivers/: fsl_port.h fsl_clock.h fsl_clock.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_lpi2c.c fsl_lpi2c.h fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_common.h fsl_common.c fsl_msmc.h fsl_msmc.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c
    ../../../../../../../../devices/K32L3A60/cmsis_drivers/: fsl_lpi2c_cmsis.h fsl_lpi2c_cmsis.c
  group component/uart
    ../../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group device
    ../../../../../../../../devices/K32L3A60/: fsl_device_registers.h K32L3A60_cm0plus.h K32L3A60_cm0plus_features.h system_K32L3A60_cm0plus.c system_K32L3A60_cm0plus.h
  group CMSIS
    ../../../../../../../../CMSIS/Include/: core_cm0plus.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group startup
    ../../../../../../../../devices/K32L3A60/iar/: startup_K32L3A60_cm0plus.s
  group CMSIS_driver
    ../../../../../../../../CMSIS/Driver/Include/: Driver_I2C.h Driver_Common.h
