# IAR project power_mode_switch_cm4.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: K32L3A60_M4 NXP K32L3A60_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_K32L3A60VPJ1A_cm4
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/K32L3A60/utilities/debug_console_lite; ../../../../../../devices/K32L3A60/drivers; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../../../devices/K32L3A60; ../../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: power_mode_switch_cm4.out
  ILINK.IlinkKeepSymbols: _power_mode_switch_cm0plus_image
  ILINK.IlinkIcfFile: K32L3A60xxx_cm4_flash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_K32L3A60VPJ1A_cm4
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  OBJCOPY.OOCOutputFile: app.srec
  group source
    ../: power_mode_switch_core0.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../../devices/K32L3A60/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../devices/K32L3A60/drivers/: fsl_lpspi.c fsl_lpspi.h fsl_port.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_lptmr.c fsl_lptmr.h fsl_mu.h fsl_mu.c fsl_msmc.h fsl_msmc.c fsl_llwu.h fsl_llwu.c fsl_spm.c fsl_spm.h fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group device
    ../../../../../../devices/K32L3A60/: fsl_device_registers.h K32L3A60_cm4.h K32L3A60_cm4_features.h system_K32L3A60_cm4.c system_K32L3A60_cm4.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group startup
    ../../../../../../devices/K32L3A60/iar/: startup_K32L3A60_cm4.s
