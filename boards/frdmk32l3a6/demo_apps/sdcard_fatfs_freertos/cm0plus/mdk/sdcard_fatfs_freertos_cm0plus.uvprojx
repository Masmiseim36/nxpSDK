# Keil uVision project sdcard_fatfs_freertos_cm0plus.uvprojx, settings and files
target sdcard_fatfs_freertos_cm0plus debug (ARM-ADS)
  device: K32L3A60VPJ1A:cm0plus NXP
  pack: Keil.Kinetis_K32L_DFP.1.0.0-dev3
  cpu: CPUTYPE("Cortex-M0+")
  output: sdcard_fatfs_freertos_cm0plus.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_K32L3A60VPJ1A_cm0plus, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc --diag_suppress=1296,186
  c include: ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM0;../..;..;../../../..;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/K32L3A60;../../../../../../rtos/amazon-freertos/lib/include;../../../../../../rtos/amazon-freertos/lib/include/private;../../../../../../devices/K32L3A60/drivers;../../../../../../devices/K32L3A60/drivers;../../../../../../middleware/sdmmc/port;../../../../../../middleware/sdmmc/port;../../../../../../middleware/fatfs/source/fsl_sd_disk;../../../../../../devices/K32L3A60/drivers;../../../../../../devices/K32L3A60/drivers;../../../../../../devices/K32L3A60/drivers;../../../../../../devices/K32L3A60/drivers;../../../../../../devices/K32L3A60/drivers;../../../../../../devices/K32L3A60/drivers;../../../../../../devices/K32L3A60/utilities/str;../../../../../../devices/K32L3A60/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../devices/K32L3A60;../../../../../../middleware/sdmmc/inc;../../../../../../middleware/sdmmc/src;../../../../../../middleware/fatfs/source
  asm define: DEBUG
  asm include: ..;../../../..
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x9000000 size 0x20000
  scatter file: K32L3A60xxx_cm0plus_flash.scf
  link misc: --remove
  group source
    ../: sdcard_fatfs_freertos.c ffconf.h FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/K32L3A60/drivers/: fsl_usdhc.c fsl_usdhc.h fsl_intmux.c fsl_intmux.h fsl_port.h fsl_gpio.c fsl_gpio.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_msmc.c fsl_msmc.h fsl_lpuart.c fsl_lpuart.h
  group sdmmc-port
    ../../../../../../middleware/sdmmc/port/: fsl_sdmmc_event.h
    ../../../../../../middleware/sdmmc/port/usdhc/freertos/: fsl_sdmmc_event.c fsl_sdmmc_host.c
  group sdmmc-inc
    ../../../../../../middleware/sdmmc/inc/: fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
  group sdmmc-src
    ../../../../../../middleware/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group fatfs-source
    ../../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
    ../../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group amazon-freertos-freertos
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos-freertos-portable
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM0/: port.c portmacro.h
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
  group amazon-freertos-include
    ../../../../../../rtos/amazon-freertos/lib/include/: FreeRTOS.h event_groups.h freertos_tasks_c_additions.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
    ../../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h stack_macros.h threading_alt.h
  group utilities
    ../../../../../../devices/K32L3A60/utilities/: fsl_assert.c
    ../../../../../../devices/K32L3A60/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/K32L3A60/utilities/str/: fsl_str.c fsl_str.h
  group component-uart
    ../../../../../../components/uart/: lpuart_adapter.c uart.h
  group component-serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group device
    ../../../../../../devices/K32L3A60/: K32L3A60_cm0plus.h K32L3A60_cm0plus_features.h fsl_device_registers.h system_K32L3A60_cm0plus.c system_K32L3A60_cm0plus.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm0plus.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h
  group startup
    ../../../../../../devices/K32L3A60/arm/: startup_K32L3A60_cm0plus.s
target sdcard_fatfs_freertos_cm0plus release (ARM-ADS)
  device: K32L3A60VPJ1A:cm0plus NXP
  pack: Keil.Kinetis_K32W_DFP.1.0.0-dev3
  cpu: CPUTYPE("Cortex-M0+")
  output: sdcard_fatfs_freertos_cm0plus.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_K32L3A60VPJ1A_cm0plus, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc --diag_suppress=1296,186
  c include: as above
  asm define: NDEBUG
  asm include: ..;../../../..
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x9000000 size 0x20000
  scatter file: K32L3A60xxx_cm0plus_flash.scf
  link misc: --remove
