# Keil uVision project pflash_cm4.uvprojx, settings and files
target pflash_cm4 debug (ARM-ADS)
  device: K32L3A60VPJ1A:cm4 NXP
  pack: Keil.Kinetis_K32L_DFP.1.0.0-dev3
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: pflash_cm4.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_K32L3A60VPJ1A_cm4
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../../devices/K32L3A60/drivers/cm4;../../../../../../../devices/K32L3A60/utilities/debug_console_lite;../../../../../../../devices/K32L3A60/drivers;../../../../../../../components/uart;../../../../../../../components/lists;../../../../../../../devices/K32L3A60;../../../../../../../CMSIS/Include
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x8000000 size 0x10000
  scatter file: K32L3A60xxx_cm4_flash.scf
  link misc: --remove
  group source
    ../: pflash.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/K32L3A60/drivers/cm4/: fsl_cache.c fsl_cache.h
    ../../../../../../../devices/K32L3A60/drivers/: fsl_port.h fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_msmc.h fsl_msmc.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c
  group utilities
    ../../../../../../../devices/K32L3A60/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group device
    ../../../../../../../devices/K32L3A60/: fsl_device_registers.h K32L3A60_cm4.h K32L3A60_cm4_features.h system_K32L3A60_cm4.c system_K32L3A60_cm4.h
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group startup
    ../../../../../../../devices/K32L3A60/arm/: startup_K32L3A60_cm4.S
target pflash_cm4 release (ARM-ADS)
  device: K32L3A60VPJ1A:cm4 NXP
  pack: Keil.Kinetis_K32W_DFP.1.0.0-dev3
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: pflash_cm4.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_K32L3A60VPJ1A_cm4
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x8000000 size 0x10000
  scatter file: K32L3A60xxx_cm4_flash.scf
  link misc: --remove
