# Keil uVision project flexio_spi_edma_lpspi_transfer_master_cm0plus.uvprojx, settings and files
target flexio_spi_edma_lpspi_transfer_master_cm0plus debug (ARM-ADS)
  device: K32L3A60VPJ1A:cm0plus NXP
  pack: Keil.Kinetis_K32L_DFP.1.0.0-dev3
  cpu: CPUTYPE("Cortex-M0+")
  output: flexio_spi_edma_lpspi_transfer_master_cm0plus.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_K32L3A60VPJ1A_cm0plus
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../../../../devices/K32L3A60/drivers;../../../../../../../../../devices/K32L3A60/utilities/debug_console_lite;../../../../../../../../../components/uart;../../../../../../../../../components/lists;../../../../../../../../../devices/K32L3A60;../../../../../../../../../CMSIS/Include
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x9000000 size 0x20000
  scatter file: K32L3A60xxx_cm0plus_flash.scf
  link misc: --remove
  group source
    ../: flexio_spi_edma_lpspi_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../../../devices/K32L3A60/drivers/: fsl_intmux.h fsl_intmux.c fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_port.h fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_flexio.c fsl_flexio.h fsl_flexio_spi.c fsl_flexio_spi.h fsl_flexio_spi_edma.c fsl_flexio_spi_edma.h fsl_lpspi.c fsl_lpspi.h fsl_common.h fsl_common.c fsl_msmc.h fsl_msmc.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c
  group utilities
    ../../../../../../../../../devices/K32L3A60/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group component/uart
    ../../../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group device
    ../../../../../../../../../devices/K32L3A60/: fsl_device_registers.h K32L3A60_cm0plus.h K32L3A60_cm0plus_features.h system_K32L3A60_cm0plus.c system_K32L3A60_cm0plus.h
  group CMSIS
    ../../../../../../../../../CMSIS/Include/: core_cm0plus.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group startup
    ../../../../../../../../../devices/K32L3A60/arm/: startup_K32L3A60_cm0plus.S
target flexio_spi_edma_lpspi_transfer_master_cm0plus release (ARM-ADS)
  device: K32L3A60VPJ1A:cm0plus NXP
  pack: Keil.Kinetis_K32W_DFP.1.0.0-dev3
  cpu: CPUTYPE("Cortex-M0+")
  output: flexio_spi_edma_lpspi_transfer_master_cm0plus.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_K32L3A60VPJ1A_cm0plus
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x9000000 size 0x20000
  scatter file: K32L3A60xxx_cm0plus_flash.scf
  link misc: --remove
