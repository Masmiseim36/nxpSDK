<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>lpspi_interrupt_b2b_transfer_master_cm0plus</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>lpspi_interrupt_b2b_transfer_master_cm0plus</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>lpspi_interrupt_b2b_transfer_master_cm0plus</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>lpspi_interrupt_b2b_transfer_master_cm0plus</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/lpspi_interrupt_b2b_transfer_master_cm0plus.ewp</path>
  </project>
</workspace>
