# Keil uVision project fmstr_example_any_cm4.uvprojx, settings and files
target fmstr_example_any_cm4 debug (ARM-ADS)
  device: K32L3A60VPJ1A:cm4 NXP
  pack: Keil.Kinetis_K32L_DFP.1.0.0-dev3
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: fmstr_example_any_cm4.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_K32L3A60VPJ1A_cm4, SDK_DEBUGCONSOLE=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../common/fmstr_example;../../../../../../devices/K32L3A60/utilities/debug_console_lite;../../../../../../middleware/freemaster/src/common;../../../../../../devices/K32L3A60/drivers;../../../../../../components/uart;../../../../../../components/lists;../../../../../../devices/K32L3A60;../../../../../../CMSIS/Include;../../../../../../middleware/freemaster/src/platforms/gen32le;../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can;../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x8000000 size 0x10000
  scatter file: K32L3A60xxx_cm4_flash.scf
  link misc: --remove
  group source
    ../: main.c freemaster_cfg.h freemaster_democfg.h
    ../../common/fmstr_example/: freemaster_example_per.c freemaster_example.h
  group board
    ../: clock_config.c clock_config.h pin_mux.c pin_mux.h peripherals.c peripherals.h board.c board.h
  group source/example_data
    ../../common/fmstr_example/: data_example_pmp.h data_img_logo.h data_img_file.h data_img_fmstrlogo.h data_html_index.h example_data.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../../devices/K32L3A60/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group freemaster
    ../../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_defcfg.h freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h freemaster_can.c freemaster_can.h freemaster_sha.c freemaster_pdbdm.c freemaster_serial.c freemaster_serial.h
  group drivers
    ../../../../../../devices/K32L3A60/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_msmc.h fsl_msmc.c fsl_port.h fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group device
    ../../../../../../devices/K32L3A60/: fsl_device_registers.h K32L3A60_cm4.h K32L3A60_cm4_features.h system_K32L3A60_cm4.c system_K32L3A60_cm4.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group startup
    ../../../../../../devices/K32L3A60/arm/: startup_K32L3A60_cm4.S
  group freemaster/platforms
    ../../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group freemaster/drivers
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mscan.c freemaster_mscan.h freemaster_mcan.c freemaster_mcan.h
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_usb.c freemaster_serial_usb.h
target fmstr_example_any_cm4 release (ARM-ADS)
  device: K32L3A60VPJ1A:cm4 NXP
  pack: Keil.Kinetis_K32W_DFP.1.0.0-dev3
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: fmstr_example_any_cm4.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_K32L3A60VPJ1A_cm4, SDK_DEBUGCONSOLE=1
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x8000000 size 0x10000
  scatter file: K32L3A60xxx_cm4_flash.scf
  link misc: --remove
