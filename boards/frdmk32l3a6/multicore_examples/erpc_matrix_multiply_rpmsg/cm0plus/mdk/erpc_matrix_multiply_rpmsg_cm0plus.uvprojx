# Keil uVision project erpc_matrix_multiply_rpmsg_cm0plus.uvprojx, settings and files
target erpc_matrix_multiply_rpmsg_cm0plus debug (ARM-ADS)
  device: K32L3A60VPJ1A:cm0plus NXP
  pack: Keil.Kinetis_K32L_DFP.1.0.0-dev3
  cpu: CPUTYPE("Cortex-M0+")
  output: erpc_matrix_multiply_rpmsg_cm0plus.out
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bincombined --bincombined_base=0x01000000 --output=$Lcore1_image.bin !L
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_K32L3A60VPJ1A_cm0plus, MULTICORE_APP=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../erpc_common;../../../erpc_common/erpc_matrix_multiply/service;..;../..;../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/k32l3a6;../../../../../../devices/K32L3A60/utilities/debug_console_lite;../../../../../../devices/K32L3A60/drivers;../../../../../../middleware/multicore/erpc/erpc_c/infra;../../../../../../middleware/multicore/erpc/erpc_c/setup;../../../../../../middleware/multicore/erpc/erpc_c/transports;../../../../../../middleware/multicore/erpc/erpc_c/port;../../../../../../middleware/multicore/mcmgr/src;../../../../../../components/uart;../../../../../../components/lists;../../../../../../devices/K32L3A60;../../../../../../CMSIS/Include;../../../../../../middleware/multicore/rpmsg_lite/lib/include;../../../../../../middleware/multicore/erpc/erpc_c
  asm define: DEBUG
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x9000000 size 0x20000
  scatter file: K32L3A60xxx_cm0plus_flash.scf
  link misc: --remove --muldefweak --predefine="-D__use_shmem__=1" --predefine="-D__stack_size__=0x400" --predefine="-D__heap_size__=0x2000"
  group source
    ../../../erpc_common/: erpc_error_handler.h erpc_error_handler.cpp
    ../: main_core1.c
    ../../: rpmsg_config.h erpc_config.h
  group erpc/service
    ../../../erpc_common/erpc_matrix_multiply/service/: erpc_matrix_multiply.erpc erpc_matrix_multiply.h erpc_matrix_multiply_server.h erpc_matrix_multiply_server.cpp
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group mcmgr
    ../../../../../../middleware/multicore/mcmgr/src/: mcmgr_internal_core_api_k32l3a6.c mcmgr_mu_internal.c mcmgr.h mcmgr_internal_core_api.h mcmgr.c
  group rpmsg_lite/porting
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/k32l3a6/: rpmsg_platform.h
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/platform/k32l3a6/: rpmsg_platform.c
  group utilities
    ../../../../../../devices/K32L3A60/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../devices/K32L3A60/drivers/: fsl_port.h fsl_clock.h fsl_clock.c fsl_mu.h fsl_mu.c fsl_common.h fsl_common.c fsl_msmc.h fsl_msmc.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c
  group erpc/infra
    ../../../../../../middleware/multicore/erpc/erpc_c/infra/: erpc_simple_server.h erpc_simple_server.cpp erpc_server.h erpc_server.cpp erpc_static_queue.h erpc_version.h erpc_codec.h erpc_basic_codec.h erpc_transport.h erpc_message_buffer.h erpc_message_loggers.h erpc_common.h erpc_manually_constructed.h erpc_crc16.h erpc_basic_codec.cpp erpc_message_buffer.cpp erpc_message_loggers.cpp erpc_crc16.cpp erpc_client_server_common.h erpc_pre_post_action.h erpc_pre_post_action.cpp
  group erpc/setup
    ../../../../../../middleware/multicore/erpc/erpc_c/setup/: erpc_server_setup.h erpc_server_setup.cpp erpc_setup_rpmsg_lite_remote.cpp erpc_setup_mbf_rpmsg.cpp erpc_transport_setup.h erpc_mbf_setup.h
  group erpc/transports
    ../../../../../../middleware/multicore/erpc/erpc_c/transports/: erpc_rpmsg_lite_base_transport.h erpc_rpmsg_lite_transport.h erpc_rpmsg_lite_transport.cpp
  group erpc/port
    ../../../../../../middleware/multicore/erpc/erpc_c/port/: erpc_port.h erpc_port_stdlib.cpp erpc_config_internal.h erpc_setup_extensions.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group device
    ../../../../../../devices/K32L3A60/: fsl_device_registers.h K32L3A60_cm0plus.h K32L3A60_cm0plus_features.h system_K32L3A60_cm0plus.c system_K32L3A60_cm0plus.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm0plus.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group startup
    ../../../../../../devices/K32L3A60/arm/: startup_K32L3A60_cm0plus.S
  group rpmsg_lite
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_lite.h rpmsg_ns.h llist.h rpmsg_default_config.h virtio_ring.h virtqueue.h rpmsg_compiler.h rpmsg_env.h
    ../../../../../../middleware/multicore/rpmsg_lite/lib/common/: llist.c
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c
    ../../../../../../middleware/multicore/rpmsg_lite/lib/virtio/: virtqueue.c
  group rpmsg_lite/env/bm
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_bm.c
target erpc_matrix_multiply_rpmsg_cm0plus release (ARM-ADS)
  device: K32L3A60VPJ1A:cm0plus NXP
  pack: Keil.Kinetis_K32W_DFP.1.0.0-dev3
  cpu: CPUTYPE("Cortex-M0+")
  output: erpc_matrix_multiply_rpmsg_cm0plus.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_K32L3A60VPJ1A_cm0plus, MULTICORE_APP=1
  c misc: as above
  c include: as above
  asm define: NDEBUG
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x9000000 size 0x20000
  scatter file: K32L3A60xxx_cm0plus_flash.scf
  link misc: as above
