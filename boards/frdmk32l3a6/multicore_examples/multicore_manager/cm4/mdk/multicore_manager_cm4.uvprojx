# Keil uVision project multicore_manager_cm4.uvprojx, settings and files
target multicore_manager_cm4 debug (ARM-ADS)
  device: K32L3A60VPJ1A:cm4 NXP
  pack: Keil.Kinetis_K32L_DFP.1.0.0-dev3
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: multicore_manager_cm4.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_K32L3A60VPJ1A_cm4, MCMGR_HANDLE_EXCEPTIONS=1, __SEMIHOST_HARDFAULT_DISABLE=1, MULTICORE_APP=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../devices/K32L3A60/utilities/debug_console_lite;../../../../../../devices/K32L3A60/drivers;../../../../../../middleware/multicore/mcmgr/src;../../../../../../components/uart;../../../../../../components/lists;../../../../../../devices/K32L3A60;../../../../../../CMSIS/Include
  asm define: DEBUG
  asm include: ../../cm0plus/mdk/debug
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x8000000 size 0x10000
  scatter file: K32L3A60xxx_cm4_flash.scf
  link misc: --remove --keep=*(*core1_code)
  group source
    ../: mcmgr_core0.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group mcmgr
    ../../../../../../middleware/multicore/mcmgr/src/: mcmgr_internal_core_api_k32l3a6.c mcmgr_mu_internal.c mcmgr.h mcmgr_internal_core_api.h mcmgr.c
  group utilities
    ../../../../../../devices/K32L3A60/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
    ../../../../../../devices/K32L3A60/utilities/incbin/: fsl_incbin.S
  group drivers
    ../../../../../../devices/K32L3A60/drivers/: fsl_gpio.h fsl_gpio.c fsl_port.h fsl_lpuart.h fsl_lpuart.c fsl_clock.h fsl_clock.c fsl_mu.h fsl_mu.c fsl_common.h fsl_common.c fsl_msmc.h fsl_msmc.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group device
    ../../../../../../devices/K32L3A60/: fsl_device_registers.h K32L3A60_cm4.h K32L3A60_cm4_features.h system_K32L3A60_cm4.c system_K32L3A60_cm4.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group startup
    ../../../../../../devices/K32L3A60/arm/: startup_K32L3A60_cm4.S
target multicore_manager_cm4 release (ARM-ADS)
  device: K32L3A60VPJ1A:cm4 NXP
  pack: Keil.Kinetis_K32W_DFP.1.0.0-dev3
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: multicore_manager_cm4.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_K32L3A60VPJ1A_cm4, MCMGR_HANDLE_EXCEPTIONS=1, __SEMIHOST_HARDFAULT_DISABLE=1, MULTICORE_APP=1
  c misc: as above
  c include: as above
  asm define: NDEBUG
  asm include: ../../cm0plus/mdk/release
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x8000000 size 0x10000
  scatter file: K32L3A60xxx_cm4_flash.scf
  link misc: --remove --keep=*(*core1_code)
