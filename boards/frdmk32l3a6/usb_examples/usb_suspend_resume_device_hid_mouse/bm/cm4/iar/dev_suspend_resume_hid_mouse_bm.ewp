# IAR project dev_suspend_resume_hid_mouse_bm.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: K32L3A60_M4 NXP K32L3A60_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; DEBUG; CPU_K32L3A60VPJ1A_cm4; USB_STACK_BM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.IExtraOptions: --no_cse
  ICCARM.CCIncludePath2: ..; ../..; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../devices/K32L3A60; ../../../../..; ../../../../../../../middleware/usb; ../../../../../../../middleware/usb/osa; ../../../../../../../middleware/usb/include; ../../../../../../../middleware/usb/device; ../../../../../../../middleware/usb/device; ../../../../../../../middleware/usb/include; ../../../../../../../middleware/usb/osa; ../../../../../../../devices/K32L3A60/drivers; ../../../../../../../devices/K32L3A60/drivers; ../../../../../../../devices/K32L3A60/drivers; ../../../../../../../devices/K32L3A60/drivers; ../../../../../../../devices/K32L3A60; ../../../../../../../devices/K32L3A60/drivers; ../../../../../../../devices/K32L3A60/drivers; ../../../../../../../devices/K32L3A60/utilities/str; ../../../../../../../devices/K32L3A60/utilities/debug_console; ../../../../../../../components/uart; ../../../../../../../components/serial_manager; ../../../../../../../components/serial_manager; ../../../../../../../components/lists; ../../../../../../../devices/K32L3A60/drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: dev_suspend_resume_hid_mouse_bm.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x1000
  ILINK.IlinkIcfFile: K32L3A60xxx_cm4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; NDEBUG; CPU_K32L3A60VPJ1A_cm4; USB_STACK_BM
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group utility
    ../: usb_timer.h usb_lpit_drv.c usb_io.h usb_kinetis_io_drv.c
  group doc
    ../: readme.txt
  group source
    ../: mouse.c mouse.h usb_device_descriptor.c usb_device_descriptor.h usb_device_config.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group usb/device/source
    ../../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
    ../: usb_device_ch9.c usb_device_ch9.h
  group usb/device/source/khci
    ../../../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
  group usb/device/include
    ../../../../../../../middleware/usb/device/: usb_device.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/hid
    ../: usb_device_hid.c usb_device_hid.h
  group usb/include
    ../../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group osa
    ../../../../../../../middleware/usb/osa/: usb_osa.h usb_osa_bm.c usb_osa_bm.h
  group drivers
    ../../../../../../../devices/K32L3A60/drivers/: fsl_lpit.c fsl_lpit.h fsl_msmc.c fsl_msmc.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_gpio.c fsl_gpio.h fsl_port.h
  group device
    ../../../../../../../devices/K32L3A60/: K32L3A60_cm4.h K32L3A60_cm4_features.h fsl_device_registers.h system_K32L3A60_cm4.c system_K32L3A60_cm4.h
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm4.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h
  group startup
    ../../../../../../../devices/K32L3A60/iar/: startup_K32L3A60_cm4.s
  group utilities
    ../../../../../../../devices/K32L3A60/utilities/: fsl_assert.c
    ../../../../../../../devices/K32L3A60/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/K32L3A60/utilities/str/: fsl_str.c fsl_str.h
  group component/uart
    ../../../../../../../components/uart/: lpuart_adapter.c uart.h
  group component/serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
