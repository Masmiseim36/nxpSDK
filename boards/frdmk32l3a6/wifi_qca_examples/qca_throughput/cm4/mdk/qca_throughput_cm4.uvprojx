# Keil uVision project qca_throughput_cm4.uvprojx, settings and files
target qca_throughput_cm4 debug (ARM-ADS)
  device: K32L3A60VPJ1A:cm4 NXP
  pack: Keil.Kinetis_K32L_DFP.1.0.0-dev3
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: qca_throughput_cm4.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_K32L3A60VPJ1A_cm4, SHELL_MAX_CMD=24, SHELL_NON_BLOCKING_MODE=0, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING=1, A_LITTLE_ENDIAN, DEBUG_CONSOLE_RX_ENABLE=0, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc --diag_suppress=1296,186
  c include: ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F;../..;../../../../cm4;..;../custom;../../../..;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/K32L3A60;../../../../../../rtos/amazon-freertos/lib/include;../../../../../../rtos/amazon-freertos/lib/include/private;../../../../../../middleware/wifi_qca/port/boards/frdmk32l3a6/freertos/silex2401;../../../../../../middleware/wifi_qca;../../../../../../middleware/wifi_qca/include;../../../../../../middleware/wifi_qca/include/AR6002;../../../../../../middleware/wifi_qca/include/AR6002/hw2.0/hw;../../../../../../middleware/wifi_qca/include/AR6002/hw4.0/hw;../../../../../../middleware/wifi_qca/custom_src/stack_custom;../../../../../../middleware/wifi_qca/custom_src/include;../../../../../../middleware/wifi_qca/common_src/include;../../../../../../middleware/wifi_qca/common_src/stack_common;../../../../../../middleware/wifi_qca/common_src/hcd;../../../../../../middleware/wifi_qca/common_src/wmi;../../../../../../middleware/wifi_qca/port;../../../../../../devices/K32L3A60/utilities;../../../../../../devices/K32L3A60/drivers;../../../../../../devices/K32L3A60/drivers;../../../../../../devices/K32L3A60/drivers;../../../../../../devices/K32L3A60/drivers;../../../../../../devices/K32L3A60/drivers;../../../../../../devices/K32L3A60/drivers;../../../../../../devices/K32L3A60/utilities/str;../../../../../../devices/K32L3A60/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../devices/K32L3A60;../../../../../../middleware/wifi_qca/port/boards/frdmk32l3a6/freertos;../../../../../../middleware/wifi_qca/port/env/freertos;../../../../../../middleware/wifi_qca/port/drivers/lpspi_edma_freertos;../../../../../../devices/K32L3A60/drivers;../../../../../../devices/K32L3A60/drivers;../../../../../../devices/K32L3A60/drivers;../../../../../../devices/K32L3A60/drivers
  asm define: DEBUG
  asm misc: --cpreproc
  asm include: ..;../../../..;../..;../../custom
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x8000000 size 0x10000
  scatter file: K32L3A60xxx_cm4_flash.scf
  link misc: --remove
  group source
    ../: main.c FreeRTOSConfig.h wlan_qca400x.c wlan_qcom.h
  group source:common
    ../common/: wmiconfig_qapi.c
  group source-custom
    ../custom/: calist-kingfisher-inc.h cert-kingfisher-inc.h Command_Lists.c https.c https.h main.h shell_config.h task_manager.c throughput.h throughput_qapi.c usb_classes.h utils.c wmiconfig_custom_qapi.c worker_shell.h
  group source-driver_plugin
    ../driver_plugin/: atheros_wifi_mediactl_ext.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group wifi_qca-port-shields-silex2401
    ../../../../../../middleware/wifi_qca/port/boards/frdmk32l3a6/freertos/silex2401/: wifi_shield_silex2401.h
  group amazon-freertos-freertos-portable
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
  group wifi_qca-include
    ../../../../../../middleware/wifi_qca/: atheros_stack_offload.h atheros_wifi.h atheros_wifi_api.h atheros_wifi_internal.h qcom_api.h
    ../../../../../../middleware/wifi_qca/include/: athdefs.h bmi_msg.h dbglog.h dbglog_id.h htc.h htc_services.h p2p.h pkt_log.h pmu.h targaddrs.h wlan_defs.h wmi.h
  group wifi_qca-common_src-api_interface
    ../../../../../../middleware/wifi_qca/common_src/api_interface/: api_init.c api_ioctl.c api_txrx.c api_wmi_rx.c
  group wifi_qca-common_src-bmi
    ../../../../../../middleware/wifi_qca/common_src/bmi/: bmi.c
  group wifi_qca-common_src-driver
    ../../../../../../middleware/wifi_qca/common_src/driver/: driver_diag.c driver_init.c driver_main.c driver_netbuf.c driver_txrx.c
  group wifi_qca-common_src-hcd
    ../../../../../../middleware/wifi_qca/common_src/hcd/: hcd_api.h
  group wifi_qca-common_src-htc
    ../../../../../../middleware/wifi_qca/common_src/hcd/: spi_hcd.c
    ../../../../../../middleware/wifi_qca/common_src/htc/: htc.c
  group wifi_qca-common_src-hw_interface
    ../../../../../../middleware/wifi_qca/common_src/hw_interface/: hw_api.c
  group wifi_qca-common_src-include
    ../../../../../../middleware/wifi_qca/common_src/include/: a_debug.h a_drv.h a_drv_api.h aggr_recv_api.h bmi.h common_api.h dbglog_api.h driver_cxt.h dset.h dset_api.h hif_internal.h htc_api.h ieee80211.h netbuf.h spi_hcd_if.h wlan_api.h wmi_api.h
  group wifi_qca-common_src-qapi
    ../../../../../../middleware/wifi_qca/common_src/qapi/: qcom_api.c qcom_dns.c qcom_legacy.c
    ../../../../../../middleware/wifi_qca/common_src/stack_common/: api_stack_offload.c
  group wifi_qca-common_src-reorder
    ../../../../../../middleware/wifi_qca/common_src/reorder/: rcv_aggr.c
  group wifi_qca-common_src-stack_common
    ../../../../../../middleware/wifi_qca/common_src/stack_common/: common_stack_offload.h
    ../../../../../../middleware/wifi_qca/common_src/storerecall/: dset_api.c
  group wifi_qca-common_src-storerecall
    ../../../../../../middleware/wifi_qca/common_src/storerecall/: dset.c storerecall.c
  group wifi_qca-common_src-util
    ../../../../../../middleware/wifi_qca/common_src/util/: util.c
  group wifi_qca-common_src-wmi
    ../../../../../../middleware/wifi_qca/common_src/wmi/: wmi.c wmi_host.h
  group wifi_qca-custom_src-api_interface
    ../../../../../../middleware/wifi_qca/custom_src/api_interface/: cust_api_init.c cust_api_ioctl.c cust_api_txrx.c cust_api_wmi_rx.c
  group wifi_qca-custom_src-driver
    ../../../../../../middleware/wifi_qca/custom_src/driver/: cust_driver_main.c cust_driver_netbuf.c
  group wifi_qca-custom_src-hw_interface
    ../../../../../../middleware/wifi_qca/custom_src/hw_interface/: cust_spi_hcd.c
  group wifi_qca-custom_src-include
    ../../../../../../middleware/wifi_qca/custom_src/include/: a_config.h a_osapi.h a_types.h cust_netbuf.h custom_wlan_api.h wlan_config.h
  group wifi_qca-custom_src-qapi
    ../../../../../../middleware/wifi_qca/custom_src/qapi/: custom_qcom_api.c
  group wifi_qca-custom_src-stack_custom
    ../../../../../../middleware/wifi_qca/custom_src/stack_custom/: cust_api_stack_offload.c cust_api_stack_txrx.c custom_stack_offload.h qca_structs.h
  group wifi_qca-include-AR6002
    ../../../../../../middleware/wifi_qca/include/AR6002/: AR6K_version.h
  group wifi_qca-include-AR6002-hw2.0-hw
    ../../../../../../middleware/wifi_qca/include/AR6002/hw2.0/hw/: hw20_apb_map.h hw20_gpio_reg.h hw20_mbox_host_reg.h hw20_mbox_reg.h hw20_rtc_reg.h hw20_si_reg.h hw20_uart_reg.h hw20_vmc_reg.h
  group wifi_qca-include-AR6002-hw4.0-hw
    ../../../../../../middleware/wifi_qca/include/AR6002/hw4.0/hw/: hw40_rtc_reg.h hw40_rtc_wlan_reg.h
  group wifi_qca-port
    ../../../../../../middleware/wifi_qca/port/: wifi_common.h wifi_shield_common.h
  group utilities
    ../../../../../../devices/K32L3A60/utilities/: fsl_shell.c fsl_shell.h fsl_assert.c
    ../../../../../../devices/K32L3A60/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/K32L3A60/utilities/str/: fsl_str.c fsl_str.h
  group amazon-freertos-freertos
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos-include
    ../../../../../../rtos/amazon-freertos/lib/include/: FreeRTOS.h event_groups.h freertos_tasks_c_additions.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
    ../../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h stack_macros.h threading_alt.h
  group drivers
    ../../../../../../devices/K32L3A60/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_msmc.c fsl_msmc.h fsl_port.h fsl_lpuart.c fsl_lpuart.h fsl_gpio.c fsl_gpio.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.c fsl_lpspi_edma.h fsl_edma.c fsl_edma.h fsl_dmamux.c fsl_dmamux.h
  group component-uart
    ../../../../../../components/uart/: lpuart_adapter.c uart.h
  group component-serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group device
    ../../../../../../devices/K32L3A60/: K32L3A60_cm4.h K32L3A60_cm4_features.h fsl_device_registers.h system_K32L3A60_cm4.c system_K32L3A60_cm4.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h
  group startup
    ../../../../../../devices/K32L3A60/arm/: startup_K32L3A60_cm4.s
  group wifi_qca-port-shields
    ../../../../../../middleware/wifi_qca/port/boards/frdmk32l3a6/freertos/: wifi_shield.c wifi_shield.h
  group wifi_qca-port-env-freertos
    ../../../../../../middleware/wifi_qca/port/env/freertos/: wifi_env.c wifi_env.h wifi_env_port.h wifi_port.h
  group wifi_qca-port-drivers-lpspi_edma_freertos
    ../../../../../../middleware/wifi_qca/port/drivers/lpspi_edma_freertos/: wifi_spi.c wifi_spi.h
target qca_throughput_cm4 release (ARM-ADS)
  device: K32L3A60VPJ1A:cm4 NXP
  pack: Keil.Kinetis_K32W_DFP.1.0.0-dev3
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: qca_throughput_cm4.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_K32L3A60VPJ1A_cm4, SHELL_MAX_CMD=24, SHELL_NON_BLOCKING_MODE=0, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING=1, A_LITTLE_ENDIAN, DEBUG_CONSOLE_RX_ENABLE=0, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc --diag_suppress=1296,186
  c include: as above
  asm define: NDEBUG
  asm misc: --cpreproc
  asm include: ..;../../../..;../..;../../custom
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x8000000 size 0x10000
  scatter file: K32L3A60xxx_cm4_flash.scf
  link misc: --remove
