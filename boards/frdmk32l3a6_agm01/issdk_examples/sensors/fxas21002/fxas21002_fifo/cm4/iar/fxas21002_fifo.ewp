# IAR project fxas21002_fifo.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: K32L3A60_M4 NXP K32L3A60_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_K32L3A60VPJ1A_cm4; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../..; ../..; ..; ../../../../../../../../middleware/issdk/drivers/gpio/kinetis; ../../../../../../../../middleware/issdk/drivers/gpio; ../../../../../../../../devices/K32L3A60/drivers; ../../../../../../../../devices/K32L3A60/cmsis_drivers; ../../../../../../../../middleware/issdk/drivers/systick; ../../../../../../../../middleware/issdk/sensors; ../../../../../../../../devices/K32L3A60/utilities/str; ../../../../../../../../devices/K32L3A60/utilities/debug_console; ../../../../../../../../components/uart; ../../../../../../../../components/serial_manager; ../../../../../../../../components/lists; ../../../../../../../../devices/K32L3A60; ../../../../../../../../CMSIS/Include; ../../../../../../../../CMSIS/Driver/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: FRDM-K32L3A6-AGM01-FXAS21002-FIFO.bin
  ILINK.IlinkOutputFile: fxas21002_fifo.out
  ILINK.IlinkIcfFile: K32L3A60xxx_cm4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_K32L3A60VPJ1A_cm4; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group board
    ../../../../../../: frdm_k32l3a6.c frdm_k32l3a6.h frdm_stbc_agm01_shield.h issdk_hal.h RTE_Device.h
    ../../: pin_mux.c pin_mux.h
    ../: clock_config.c clock_config.h board.c board.h
  group source
    ../: fxas21002_fifo.c
  group doc
    ../: readme.txt readme.txt
  group gpio_driver
    ../../../../../../../../middleware/issdk/drivers/gpio/kinetis/: gpio_driver_irq.c gpio_driver.c gpio_driver.h
    ../../../../../../../../middleware/issdk/drivers/gpio/: Driver_GPIO.h
  group drivers
    ../../../../../../../../devices/K32L3A60/drivers/: fsl_port.h fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_lpuart.h fsl_lpuart.c fsl_lpuart_edma.h fsl_lpuart_edma.c fsl_lpi2c.c fsl_lpi2c.h fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.h fsl_lpspi_edma.c fsl_common.h fsl_common.c fsl_msmc.h fsl_msmc.c
    ../../../../../../../../devices/K32L3A60/cmsis_drivers/: fsl_lpuart_cmsis.h fsl_lpuart_cmsis.c fsl_lpi2c_cmsis.h fsl_lpi2c_cmsis.c fsl_lpspi_cmsis.h fsl_lpspi_cmsis.c
  group utilities
    ../../../../../../../../middleware/issdk/drivers/systick/: systick_utils.c systick_utils.h
    ../../../../../../../../devices/K32L3A60/utilities/: fsl_assert.c
    ../../../../../../../../devices/K32L3A60/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../../devices/K32L3A60/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group interfaces
    ../../../../../../../../middleware/issdk/sensors/: register_io_i2c.c register_io_spi.c sensor_io_spi.c sensor_io_i2c.c register_io_i2c.h register_io_spi.h sensor_io_spi.h sensor_io_i2c.h sensor_drv.h
  group sensors
    ../../../../../../../../middleware/issdk/sensors/: fxas21002.h fxas21002_drv.h fxas21002_drv.c
  group component/uart
    ../../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group device
    ../../../../../../../../devices/K32L3A60/: fsl_device_registers.h K32L3A60_cm4.h K32L3A60_cm4_features.h system_K32L3A60_cm4.c system_K32L3A60_cm4.h
  group CMSIS
    ../../../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group startup
    ../../../../../../../../devices/K32L3A60/iar/: startup_K32L3A60_cm4.s
  group CMSIS_driver
    ../../../../../../../../CMSIS/Driver/Include/: Driver_USART.h Driver_Common.h Driver_I2C.h Driver_SPI.h
