# Keil uVision project aws_tests.uvprojx, settings and files
target aws_tests debug (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: aws_tests.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VLL12, SDK_DEBUGCONSOLE=1, SDK_I2C_BASED_COMPONENT_USED=1, USE_RTOS=1, MBEDTLS_CONFIG_FILE='\"aws_mbedtls_config.h\"', FRDM_K64F, FREEDOM, A_LITTLE_ENDIAN, FSL_RTOS_FREE_RTOS, AMAZON_FREERTOS_ENABLE_UNIT_TESTS=1
  c misc: --library_interface=armcc 
--diag_suppress=1296,186 
--diag_suppress=177
  c include: ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F;../../..;..;../../../../../CMSIS/Include;../../../../../devices;../../../../../middleware/mmcau;../../../../../rtos/amazon-freertos/lib/include;../../../../../rtos/amazon-freertos/lib/include/private;../../../../../middleware/mbedtls/include;../../../../../middleware/mbedtls/port/ksdk;../config_files;../../../../../middleware/wifi_qca/port/boards/frdmk64f/freertos/gt202;../../../../../middleware/wifi_qca/port/boards/frdmk64f/freertos/silex2401;../../../../../devices/MK64F12/drivers;../../../../../components/fxos8700cq;../../../../../devices/MK64F12/drivers;../../../../../rtos/amazon-freertos/lib/third_party/mcu_vendor/nxp/FRDMK64F/drivers;../../../../../middleware/wifi_qca;../../../../../middleware/wifi_qca/include;../../../../../middleware/wifi_qca/include/AR6002;../../../../../middleware/wifi_qca/include/AR6002/hw2.0/hw;../../../../../middleware/wifi_qca/include/AR6002/hw4.0/hw;../../../../../middleware/wifi_qca/custom_src/stack_custom;../../../../../middleware/wifi_qca/custom_src/include;../../../../../middleware/wifi_qca/common_src/include;../../../../../middleware/wifi_qca/common_src/stack_common;../../../../../middleware/wifi_qca/common_src/hcd;../../../../../middleware/wifi_qca/common_src/wmi;../../../../../middleware/wifi_qca/port;../../../../../rtos/amazon-freertos/lib/include;../../../../../rtos/amazon-freertos/lib/include/private;../../../../../rtos/amazon-freertos/lib/third_party/pkcs11;../../../../../rtos/amazon-freertos/lib/third_party;../../../../../rtos/amazon-freertos/lib/third_party/jsmn;../../../../../rtos/amazon-freertos/lib/include;../../../../../rtos/amazon-freertos/lib/include;../../../../../rtos/amazon-freertos/tests/common/include;../../../../../rtos/amazon-freertos/lib/third_party/unity/src;../../../../../rtos/amazon-freertos/lib/third_party/unity/extras/fixture/src;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/utilities/str;../../../../../devices/MK64F12/utilities/debug_console;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/serial_manager;../../../../../components/lists;../../../../../devices/MK64F12/drivers;../../../../../middleware/wifi_qca/port/boards/frdmk64f/freertos;../../../../../middleware/wifi_qca/port/env/freertos;../../../../../middleware/wifi_qca/port/drivers/dspi_edma_freertos;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers
  asm define: DEBUG
  asm include: ../../..;..;../config_files
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash_data.scf
  link misc: ../../../../../middleware/mmcau/asm-cm4-cm7/lib_mmcau.lib 
--remove 
--predefine="-D__stack_size__=0x200" 
--predefine="-D__heap_size__=0x200" 
--predefine="-DXIP_IMAGE"
  group configs
    ../config_files/: aws_bufferpool_config.h aws_ggd_config.h aws_mbedtls_config.h aws_mqtt_agent_config.h aws_mqtt_config.h aws_pkcs11_config.h aws_secure_sockets_config.h aws_shadow_config.h aws_test_pkcs11_config.h aws_test_runner_config.h aws_test_tcp_config.h aws_test_wifi_config.h aws_wifi_config.h FreeRTOSConfig.h FreeRTOSIPConfig.h unity_config.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source
    ../application_code/: main.c
  group doc
    ../: readme.txt
  group wifi_qca-port-shields-gt202
    ../../../../../middleware/wifi_qca/port/boards/frdmk64f/freertos/gt202/: wifi_shield_gt202.h
  group wifi_qca-port-shields-silex2401
    ../../../../../middleware/wifi_qca/port/boards/frdmk64f/freertos/silex2401/: wifi_shield_silex2401.h
  group drivers
    ../../../../../devices/MK64F12/drivers/: fsl_rnga.c fsl_rnga.h fsl_i2c.h fsl_i2c.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_port.h fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c fsl_common.h fsl_common.c fsl_dspi.h fsl_dspi.c fsl_dspi_edma.h fsl_dspi_edma.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c
  group mmcau-mmcau_include
    ../../../../../middleware/mmcau/: cau_api.h fsl_mmcau.h
  group mmcau-mmcau_source
    ../../../../../middleware/mmcau/: fsl_mmcau.c
  group accel
    ../../../../../components/fxos8700cq/: fsl_fxos.h fsl_fxos.c
  group amazon-freertos-drivers
    ../../../../../rtos/amazon-freertos/lib/third_party/mcu_vendor/nxp/FRDMK64F/drivers/: mflash_drv.h mflash_drv.c mflash_file.h mflash_file.c
  group amazon-freertos-pkcs11
    ../../../../../rtos/amazon-freertos/lib/pkcs11/mbedtls/: aws_pkcs11_mbedtls.c
    ../../../../../rtos/amazon-freertos/lib/pkcs11/portable/nxp/frdmk64f/: aws_pkcs11_pal.c
  group amazon-freertos-FreeRTOS-portable
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F/: fsl_tickless_systick.c fsl_tickless_generic.h port.c portmacro.h
  group wifi_qca-common_src-wmi
    ../../../../../middleware/wifi_qca/common_src/wmi/: wmi.c wmi_host.h
  group wifi_qca-common_src-stack_common
    ../../../../../middleware/wifi_qca/common_src/storerecall/: dset_api.c
    ../../../../../middleware/wifi_qca/common_src/stack_common/: common_stack_offload.h
  group wifi_qca-common_src-qapi
    ../../../../../middleware/wifi_qca/common_src/stack_common/: api_stack_offload.c
    ../../../../../middleware/wifi_qca/common_src/qapi/: qcom_api.c qcom_dns.c qcom_legacy.c
  group wifi_qca-common_src-include
    ../../../../../middleware/wifi_qca/common_src/include/: dset_api.h driver_cxt.h a_drv_api.h wlan_api.h wmi_api.h hif_internal.h dset.h dbglog_api.h common_api.h bmi.h aggr_recv_api.h a_drv.h a_debug.h spi_hcd_if.h netbuf.h ieee80211.h htc_api.h
  group wifi_qca-common_src-htc
    ../../../../../middleware/wifi_qca/common_src/htc/: htc.c
    ../../../../../middleware/wifi_qca/common_src/hcd/: spi_hcd.c
  group wifi_qca-common_src-driver
    ../../../../../middleware/wifi_qca/common_src/driver/: driver_main.c driver_txrx.c driver_netbuf.c driver_init.c driver_diag.c
  group wifi_qca-common_src-api_interface
    ../../../../../middleware/wifi_qca/common_src/api_interface/: api_wmi_rx.c api_ioctl.c api_txrx.c api_init.c
  group wifi_qca-common_src-hw_interface
    ../../../../../middleware/wifi_qca/common_src/hw_interface/: hw_api.c
  group wifi_qca-common_src-storerecall
    ../../../../../middleware/wifi_qca/common_src/storerecall/: dset.c storerecall.c
  group wifi_qca-common_src-hcd
    ../../../../../middleware/wifi_qca/common_src/hcd/: hcd_api.h
  group wifi_qca-common_src-bmi
    ../../../../../middleware/wifi_qca/common_src/bmi/: bmi.c
  group wifi_qca-common_src-util
    ../../../../../middleware/wifi_qca/common_src/util/: util.c
  group wifi_qca-common_src-reorder
    ../../../../../middleware/wifi_qca/common_src/reorder/: rcv_aggr.c
  group wifi_qca-custom_src-stack_custom
    ../../../../../middleware/wifi_qca/custom_src/stack_custom/: cust_api_stack_offload.c qca_structs.h custom_stack_offload.h cust_api_stack_txrx.c
  group wifi_qca-custom_src-qapi
    ../../../../../middleware/wifi_qca/custom_src/qapi/: custom_qcom_api.c
  group wifi_qca-custom_src-include
    ../../../../../middleware/wifi_qca/custom_src/include/: cust_netbuf.h a_osapi.h a_config.h wlan_config.h custom_wlan_api.h a_types.h
  group wifi_qca-custom_src-api_interface
    ../../../../../middleware/wifi_qca/custom_src/api_interface/: cust_api_wmi_rx.c cust_api_ioctl.c cust_api_txrx.c cust_api_init.c
  group wifi_qca-custom_src-driver
    ../../../../../middleware/wifi_qca/custom_src/driver/: cust_driver_netbuf.c cust_driver_main.c
  group wifi_qca-custom_src-hw_interface
    ../../../../../middleware/wifi_qca/custom_src/hw_interface/: cust_spi_hcd.c
  group wifi_qca-include
    ../../../../../middleware/wifi_qca/include/: wmi.h dbglog.h athdefs.h dbglog_id.h bmi_msg.h wlan_defs.h targaddrs.h pmu.h pkt_log.h p2p.h htc_services.h htc.h
    ../../../../../middleware/wifi_qca/: qcom_api.h atheros_stack_offload.h atheros_wifi_internal.h atheros_wifi_api.h atheros_wifi.h
  group wifi_qca-include-AR6002-hw2.0-hw
    ../../../../../middleware/wifi_qca/include/AR6002/hw2.0/hw/: hw20_gpio_reg.h hw20_apb_map.h hw20_vmc_reg.h hw20_uart_reg.h hw20_si_reg.h hw20_rtc_reg.h hw20_mbox_reg.h hw20_mbox_host_reg.h
  group wifi_qca-include-AR6002
    ../../../../../middleware/wifi_qca/include/AR6002/: AR6K_version.h
  group wifi_qca-include-AR6002-hw4.0-hw
    ../../../../../middleware/wifi_qca/include/AR6002/hw4.0/hw/: hw40_rtc_wlan_reg.h hw40_rtc_reg.h
  group wifi_qca-port
    ../../../../../middleware/wifi_qca/port/: wifi_common.h
  group amazon-freertos-license
    ../../../../../rtos/amazon-freertos/: LICENSE
  group amazon-freertos-include
    ../../../../../rtos/amazon-freertos/lib/include/: event_groups.h FreeRTOS.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h FreeRTOS.h aws_crypto.h aws_greengrass_discovery.h aws_mqtt_agent.h aws_mqtt_lib.h aws_pkcs11.h aws_secure_sockets.h aws_shadow.h aws_system_init.h aws_tls.h aws_wifi.h event_groups.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
    ../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_wrappers.h portable.h projdefs.h stack_macros.h aws_bufferpool.h aws_default_root_certificates.h aws_doubly_linked_list.h aws_ggd_config_defaults.h aws_helper_secure_connect.h aws_lib_init.h aws_mqtt_agent_config_defaults.h aws_mqtt_buffer.h aws_mqtt_config_defaults.h aws_secure_sockets_config_defaults.h aws_shadow_config_defaults.h aws_shadow_json.h deprecated_definitions.h list.h mpu_wrappers.h portable.h projdefs.h stack_macros.h
  group amazon-freertos-FreeRTOS
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group mbedtls-mbedtls_include
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls-mbedtls_source
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c chacha20.c chachapoly.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls-mbedtls_port
    ../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c
  group amazon-freertos-mqtt
    ../../../../../rtos/amazon-freertos/lib/mqtt/: aws_mqtt_agent.c aws_mqtt_lib.c
  group amazon-freertos-tls
    ../../../../../rtos/amazon-freertos/lib/tls/: aws_tls.c
  group amazon-freertos-bufferpool
    ../../../../../rtos/amazon-freertos/lib/bufferpool/: aws_bufferpool_static_thread_safe.c
  group amazon-freertos-crypto
    ../../../../../rtos/amazon-freertos/lib/crypto/: aws_crypto.c
  group amazon-freertos-third_party-pkcs11
    ../../../../../rtos/amazon-freertos/lib/third_party/pkcs11/: pkcs11.h pkcs11f.h pkcs11t.h
  group amazon-freertos-utils
    ../../../../../rtos/amazon-freertos/lib/utils/: aws_system_init.c
  group amazon-freertos-third_party-jsmn
    ../../../../../rtos/amazon-freertos/lib/third_party/jsmn/: jsmn.c jsmn.h
  group amazon-freertos-shadow
    ../../../../../rtos/amazon-freertos/lib/shadow/: aws_shadow.c aws_shadow_json.c
  group amazon-freertos-secure_sockets
    ../../../../../rtos/amazon-freertos/lib/secure_sockets/portable/nxp/wifi_qca/: aws_secure_sockets.c
  group amazon-freertos-wifi
    ../../../../../rtos/amazon-freertos/lib/wifi/portable/nxp/common/: aws_wifi.c
  group common-tests-crypto
    ../../../../../rtos/amazon-freertos/tests/common/crypto/: aws_test_crypto.c
  group common-tests-framework
    ../../../../../rtos/amazon-freertos/tests/common/framework/: aws_test_framework.c
  group common-tests-greengrass
    ../../../../../rtos/amazon-freertos/tests/common/greengrass/: aws_test_greengrass_discovery.c aws_test_helper_secure_connect.c
  group common-tests-include
    ../../../../../rtos/amazon-freertos/tests/common/include/: aws_application_version.h aws_clientcredential.h aws_clientcredential_keys.h aws_dev_mode_key_provisioning.h aws_greengrass_discovery_test_access_declare.h aws_greengrass_discovery_test_access_define.h aws_logging_task.h aws_mqtt_lib_test_access_declare.h aws_mqtt_lib_test_access_define.h aws_test_framework.h aws_test_runner.h aws_test_tcp.h aws_test_tls.h
    ../../../../../rtos/amazon-freertos/lib/include/: aws_appversion32.h
  group common-tests-memory_leak
    ../../../../../rtos/amazon-freertos/tests/common/memory_leak/: aws_memory_leak.c
  group common-tests-mqtt
    ../../../../../rtos/amazon-freertos/tests/common/mqtt/: aws_test_mqtt_agent.c aws_test_mqtt_lib.c
  group common-tests-pkcs11
    ../../../../../rtos/amazon-freertos/tests/common/pkcs11/: aws_test_pkcs11.c
  group common-tests-secure_sockets
    ../../../../../rtos/amazon-freertos/tests/common/secure_sockets/: aws_test_tcp.c
  group common-tests-shadow
    ../../../../../rtos/amazon-freertos/tests/common/shadow/: aws_test_shadow.c
  group common-tests-test_runner
    ../../../../../rtos/amazon-freertos/tests/common/test_runner/: aws_test_runner.c
  group common-tests-tls
    ../../../../../rtos/amazon-freertos/tests/common/tls/: aws_test_tls.c
  group common-tests-wifi
    ../../../../../rtos/amazon-freertos/tests/common/wifi/: aws_test_wifi.c
  group unity
    ../../../../../rtos/amazon-freertos/lib/third_party/unity/src/: unity.c unity.h unity_internals.h
    ../../../../../rtos/amazon-freertos/lib/third_party/unity/extras/fixture/src/: unity_fixture.c unity_fixture.h unity_fixture_internals.h unity_fixture_malloc_overrides.h
  group amazon-freertos-devmode_key_provisioning
    ../../../../../rtos/amazon-freertos/demos/common/devmode_key_provisioning/: aws_dev_mode_key_provisioning.c
  group amazon-freertos-logging
    ../../../../../rtos/amazon-freertos/demos/common/logging/: aws_logging_task_dynamic_buffers.c
  group amazon-freertos-greengrass
    ../../../../../rtos/amazon-freertos/lib/greengrass/: aws_greengrass_discovery.c aws_helper_secure_connect.c
  group utilities
    ../../../../../devices/MK64F12/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK64F12/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MK64F12/utilities/: fsl_assert.c
  group device
    ../../../../../devices/MK64F12/: fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.c system_MK64F12.h
  group component/uart
    ../../../../../components/uart/: uart.h uart_adapter.c
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: generic_list.h generic_list.c
  group startup
    ../../../../../devices/MK64F12/arm/: startup_MK64F12.s
  group wifi_qca-port-shields
    ../../../../../middleware/wifi_qca/port/boards/frdmk64f/freertos/: wifi_shield.h wifi_shield.c
  group wifi_qca-port-env-freertos
    ../../../../../middleware/wifi_qca/port/env/freertos/: wifi_port.h wifi_env_port.h wifi_env.c wifi_env.h
  group wifi_qca-port-drivers-dspi_edma_freertos
    ../../../../../middleware/wifi_qca/port/drivers/dspi_edma_freertos/: wifi_spi.h wifi_spi.c
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
target aws_tests release (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: aws_tests.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: NDEBUG, CPU_MK64FN1M0VLL12, SDK_DEBUGCONSOLE=1, SDK_I2C_BASED_COMPONENT_USED=1, USE_RTOS=1, MBEDTLS_CONFIG_FILE='\"aws_mbedtls_config.h\"', FRDM_K64F, FREEDOM, A_LITTLE_ENDIAN, FSL_RTOS_FREE_RTOS, AMAZON_FREERTOS_ENABLE_UNIT_TESTS=1
  c misc: as above
  c include: as above
  asm define: NDEBUG
  asm include: ../../..;..;../config_files
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash_data.scf
  link misc: as above
