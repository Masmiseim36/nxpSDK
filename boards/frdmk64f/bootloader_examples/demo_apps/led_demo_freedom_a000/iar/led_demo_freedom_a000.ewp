# IAR project led_demo_freedom_a000.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VLL12; CPU_IS_ARM_CORTEX_M4=1; FREEDOM; FRDM_K64F
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050,Pe1105,Pe1305,Pa182
  ICCARM.CCIncludePath2: ..; ../../../../../../middleware/mcu-boot/apps/led_demo/src; ../../../../../../devices/MK64F12/drivers; ../../../../../../devices/MK64F12; ../../../../../../middleware/mcu-boot/src/include; ../../../../../../middleware/mcu-boot/src/startup; ../../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG; BL_HAS_BOOTLOADER_CONFIG
  ILINK.IlinkOutputFile: led_demo_freedom_a000.out
  ILINK.IlinkIcfFile: ../../../../../../middleware/mcu-boot/targets/common/linker/iar/MK64F12/MK64FN1M0xxx12_application_0xA000.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group board
    ../: pin_mux.c pin_mux.h
  group MK64F12
    ../: main.c
    ../../../../../../middleware/mcu-boot/apps/led_demo/src/: milliseconds_delay.h milliseconds_delay.c
    ../../../../../../middleware/mcu-boot/src/utilities/src/: bootloader_tree_stub.c
  group drivers
    ../../../../../../devices/MK64F12/drivers/: fsl_port.h fsl_gpio.h fsl_gpio.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c
  group device
    ../../../../../../devices/MK64F12/: fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.h system_MK64F12.c
  group startup
    ../../../../../../middleware/mcu-boot/src/startup/: crt0.s startup.c
    ../../../../../../middleware/mcu-boot/targets/MK64F12/src/startup/iar/: startup_MK64F12.s
  group source/include
    ../../../../../../middleware/mcu-boot/src/include/: bootloader_core.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
