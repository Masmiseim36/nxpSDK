# Keil uVision project flashloader_loader.uvprojx, settings and files
target flashloader_loader debug (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: flashloader_loader.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MK64FN1M0VLL12, CPU_IS_ARM_CORTEX_M4=1, BL_TARGET_FLASH, FRDM_K64F, USB_STACK_BM
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -Wno-null-dereference  -Wno-unknown-attributes  -Wno-expansion-to-defined  -Wno-invalid-noreturn
  c include: ../../flashloader/mdk;../../../../../middleware/mcu-boot/targets/MK64F12/src;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12;../../../../../middleware/mcu-boot/src/bootloader;../../../../../middleware/mcu-boot/src/include;../../../../../middleware/mcu-boot/src/utilities;../../../../../middleware/mcu-boot/src/startup;../../../../../CMSIS/Include
  asm define: DEBUG, BL_HAS_BOOTLOADER_CONFIG=0, LITE_FOOTPRINT
  asm include: ../../../../../middleware/mcu-boot/src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../../middleware/mcu-boot/targets/common/linker/arm/MK64F12/MK64FN1M0xxx12_flashloader_loader.scf
  link misc: --remove --keep=*(.FlashConfig) --datacompressor off
  group doc
    ../: readme.txt
  group MK64F12
    ../../../../../middleware/mcu-boot/targets/MK64F12/src/: bootloader_config.h target_config.h
  group drivers
    ../../../../../devices/MK64F12/drivers/: fsl_clock.h fsl_clock.c fsl_uart.h fsl_uart.c fsl_common.h fsl_common.c
  group device
    ../../../../../devices/MK64F12/: fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.h system_MK64F12.c
  group mcu-boot/startup
    ../../../../../middleware/mcu-boot/targets/MK64F12/src/startup/arm/: startup_MK64F12.S
  group source/bootloader
    ../../../../../middleware/mcu-boot/src/bootloader/: flashloader_image.h
    ../../../../../middleware/mcu-boot/src/bootloader/src/: bl_flashloader.c bl_exception_handler.c
  group source/include
    ../../../../../middleware/mcu-boot/src/include/: bootloader_common.h bootloader_core.h
  group source/utilities
    ../../../../../middleware/mcu-boot/src/utilities/: fsl_assert.h vector_table_info.h
  group source/utilities/src
    ../../../../../middleware/mcu-boot/src/utilities/src/: fsl_assert.c
  group startup
    ../../../../../middleware/mcu-boot/src/startup/: startup.c
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
target flashloader_loader release (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: flashloader_loader.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MK64FN1M0VLL12, CPU_IS_ARM_CORTEX_M4=1, BL_TARGET_FLASH, FRDM_K64F, USB_STACK_BM
  c misc: as above
  c include: as above
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=0, LITE_FOOTPRINT
  asm include: ../../../../../middleware/mcu-boot/src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: as above
  link misc: --remove --keep=*(.FlashConfig) --datacompressor off
