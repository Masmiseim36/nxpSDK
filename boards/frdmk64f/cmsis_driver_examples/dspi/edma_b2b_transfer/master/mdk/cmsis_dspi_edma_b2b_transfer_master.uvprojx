# Keil uVision project cmsis_dspi_edma_b2b_transfer_master.uvprojx, settings and files
target cmsis_dspi_edma_b2b_transfer_master Debug (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: cmsis_dspi_edma_b2b_transfer_master.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VLL12, FRDM_K64F, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..;../../../../../../../CMSIS/Driver/Include;../../../../..;../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../devices/MK64F12/drivers;../../../../../../../devices/MK64F12/cmsis_drivers;../../../../../../../devices/MK64F12/utilities/io;../../../../../../../devices/MK64F12/utilities/str;../../../../../../../devices/MK64F12/utilities/log;../../../../../../../devices/MK64F12/utilities;../../../../../../../devices/MK64F12
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove
  group source
    ../: cmsis_dspi_edma_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MK64F12/drivers/: fsl_port.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_dspi.h fsl_dspi.c fsl_dspi_edma.h fsl_dspi_edma.c fsl_flash.c fsl_flash.h fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c
    ../../../../../../../devices/MK64F12/cmsis_drivers/: fsl_dspi_cmsis.h fsl_dspi_cmsis.c
  group utilities
    ../../../../../../../devices/MK64F12/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../../devices/MK64F12/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../../devices/MK64F12/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group startup
    ../../../../../../../devices/MK64F12/: system_MK64F12.c system_MK64F12.h
    ../../../../../../../devices/MK64F12/arm/: startup_MK64F12.s
target cmsis_dspi_edma_b2b_transfer_master Release (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: cmsis_dspi_edma_b2b_transfer_master.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MK64FN1M0VLL12, FRDM_K64F, FREEDOM
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove
