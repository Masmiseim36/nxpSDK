<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>cmsis_i2c_interrupt_transfer</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>cmsis_i2c_interrupt_transfer</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>cmsis_i2c_interrupt_transfer</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>cmsis_i2c_interrupt_transfer</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/cmsis_i2c_interrupt_transfer.ewp</path>
  </project>
</workspace>
