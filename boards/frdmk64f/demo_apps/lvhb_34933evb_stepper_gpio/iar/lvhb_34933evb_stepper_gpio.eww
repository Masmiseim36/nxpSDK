<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>lvhb_34933evb_stepper_gpio</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>lvhb_34933evb_stepper_gpio</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>lvhb_34933evb_stepper_gpio</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>lvhb_34933evb_stepper_gpio</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/lvhb_34933evb_stepper_gpio.ewp</path>
  </project>
</workspace>
