# Keil uVision project ntag_i2c_explorer_demo.uvprojx, settings and files
target ntag_i2c_explorer_demo Debug (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: ntag_i2c_explorer_demo.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VLL12, FRDM_K64F, FREEDOM, PRINTF_ADVANCED_ENABLE=1, I2C_FSL, HAVE_STDBOOL_H, HAVE_STDINT_H
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../CMSIS/Include;../../../../../../devices;../../../..;..;../../../../../../devices/MK64F12/drivers;../../../../../../devices/MK64F12/utilities/io;../../../../../../devices/MK64F12/utilities/str;../../../../../../devices/MK64F12/utilities/log;../../../../../../devices/MK64F12/utilities;../../../../../../devices/MK64F12;../../../../../../middleware/ntag_i2c_plus/inc;../../../../../../middleware/ntag_i2c_plus/HAL_I2C/inc;../../../../../../middleware/ntag_i2c_plus/HAL_ISR;../../../../../../middleware/ntag_i2c_plus/HAL_ISR/inc;../../../../../../middleware/ntag_i2c_plus/HAL_NTAG/inc;../../../../../../middleware/ntag_i2c_plus/HAL_NTAG;../../../../../../middleware/ntag_i2c_plus/HAL_TMR/inc
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove
  group source
    ../: ntag_i2c_explorer_demo.c crc32.c crc32.h ndef_message.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MK64F12/drivers/: fsl_flash.c fsl_flash.h fsl_gpio.h fsl_gpio.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_port.h fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c fsl_adc16.c fsl_adc16.h fsl_i2c.h fsl_i2c.c
  group utilities
    ../../../../../../devices/MK64F12/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../devices/MK64F12/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../devices/MK64F12/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group startup
    ../../../../../../devices/MK64F12/: system_MK64F12.c system_MK64F12.h
    ../../../../../../devices/MK64F12/arm/: startup_MK64F12.s
  group ntag_i2c_plus-HAL_NTAG
    ../../../../../../middleware/ntag_i2c_plus/HAL_NTAG/inc/: ntag_bridge.h ntag_defines.h ntag_device_list.h ntag_driver.h
    ../../../../../../middleware/ntag_i2c_plus/HAL_NTAG/: ntag_driver_intern.h ntag_bridge.c ntag_driver.c
  group ntag_i2c_plus-HAL_I2C
    ../../../../../../middleware/ntag_i2c_plus/HAL_I2C/inc/: HAL_I2C_driver.h HAL_I2C_kinetis_fsl.h
    ../../../../../../middleware/ntag_i2c_plus/HAL_I2C/: i2c_kinetis_fsl.c
  group ntag_i2c_plus-HAL_ISR
    ../../../../../../middleware/ntag_i2c_plus/HAL_ISR/inc/: HAL_ISR_callback_list.h HAL_ISR_driver.h
    ../../../../../../middleware/ntag_i2c_plus/HAL_ISR/: isr_driver_intern.h isr_kinetis_intern.h isr_common.c isr_kinetis.c
  group ntag_i2c_plus-HAL_TMR
    ../../../../../../middleware/ntag_i2c_plus/HAL_TMR/inc/: HAL_timer_driver.h
    ../../../../../../middleware/ntag_i2c_plus/HAL_TMR/: timer_kinetis.c
  group ntag_i2c_plus-ntag_i2c_plus_include
    ../../../../../../middleware/ntag_i2c_plus/inc/: global_types.h nfc_device.h
target ntag_i2c_explorer_demo Release (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: ntag_i2c_explorer_demo.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MK64FN1M0VLL12, FRDM_K64F, FREEDOM, PRINTF_ADVANCED_ENABLE=1, I2C_FSL, HAVE_STDBOOL_H, HAVE_STDINT_H
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove
