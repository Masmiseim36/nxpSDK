# IAR project sigfox_console.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VLL12; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; FRDM_K64F; FREEDOM; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../middleware/sigfox; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12; ../../../../../middleware/aml; ../../../../../middleware/aml/spi_aml; ../../../../../middleware/aml/tmr_aml; ../../../../../middleware/aml/wait_aml; ../../../../../devices/MK64F12/utilities/str; ../../../../../devices/MK64F12/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: sigfox_console.out
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VLL12; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; FRDM_K64F; FREEDOM; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source
    ../: main.c sf_cmd.c sf_cmd.h
  group doc
    ../: readme.txt readme.txt
  group sf
    ../../../../../middleware/sigfox/: sf.c sf.h sf_model.h sf_ol23xx.h sf_setup.c sf_setup.h
  group drivers
    ../../../../../devices/MK64F12/drivers/: fsl_clock.h fsl_clock.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_common.h fsl_common.c fsl_port.h fsl_smc.h fsl_smc.c fsl_ftm.c fsl_ftm.h fsl_gpio.h fsl_gpio.c fsl_dspi.h fsl_dspi.c fsl_uart.h fsl_uart.c
  group device
    ../../../../../devices/MK64F12/: fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.c system_MK64F12.h
  group startup
    ../../../../../devices/MK64F12/iar/: startup_MK64F12.s
  group utilities
    ../../../../../devices/MK64F12/utilities/: fsl_assert.c
    ../../../../../devices/MK64F12/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK64F12/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group aml
    ../../../../../middleware/aml/: common_aml.h readme.txt gpio_aml.h
  group aml/spi_aml
    ../../../../../middleware/aml/spi_aml/: spi_aml.c spi_aml.h
  group aml/tmr_aml
    ../../../../../middleware/aml/tmr_aml/: ftm_aml.c ftm_aml.h tmr_aml.h tpm_aml.c tpm_aml.h
  group aml/wait_aml
    ../../../../../middleware/aml/wait_aml/: wait_aml.c wait_aml.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
