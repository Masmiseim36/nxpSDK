<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>enet_txrx_ptp1588_transfer</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>enet_txrx_ptp1588_transfer</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>enet_txrx_ptp1588_transfer</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>enet_txrx_ptp1588_transfer</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/enet_txrx_ptp1588_transfer.ewp</path>
  </project>
</workspace>
