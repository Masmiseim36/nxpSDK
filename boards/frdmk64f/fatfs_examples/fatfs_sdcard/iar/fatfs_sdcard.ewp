# IAR project fatfs_sdcard.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VLL12; FRDM_K64F; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/drivers; ../../../../../middleware/sdmmc/port; ../../../../../middleware/sdmmc/port; ../../../../../middleware/fatfs/source/fsl_sd_disk; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/utilities/str; ../../../../../devices/MK64F12/utilities/debug_console; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../devices/MK64F12/drivers; ../../../../../middleware/sdmmc/inc; ../../../../../middleware/sdmmc/src; ../../../../../middleware/fatfs/source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: fatfs_sdcard.out
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VLL12; FRDM_K64F; FREEDOM
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: fatfs_sdcard.c ffconf.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK64F12/drivers/: fsl_port.h fsl_gpio.h fsl_gpio.c fsl_sysmpu.h fsl_sysmpu.c fsl_sdhc.h fsl_sdhc.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_clock.h fsl_clock.c fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c fsl_common.h fsl_common.c
  group sdmmc/src
    ../../../../../middleware/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc/inc/: fsl_sd.h fsl_sdmmc_host.h fsl_sdmmc_common.h fsl_sdmmc_spec.h
  group sdmmc/port
    ../../../../../middleware/sdmmc/port/: fsl_sdmmc_event.h
    ../../../../../middleware/sdmmc/port/sdhc/interrupt/: fsl_sdmmc_event.c fsl_sdmmc_host.c
  group fatfs/fatfs_include
    ../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.h
    ../../../../../middleware/fatfs/source/: diskio.h ff.h integer.h
  group fatfs/fatfs_source
    ../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c
    ../../../../../middleware/fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group utilities
    ../../../../../devices/MK64F12/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK64F12/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MK64F12/utilities/: fsl_assert.c
  group device
    ../../../../../devices/MK64F12/: fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.c system_MK64F12.h
  group component/uart
    ../../../../../components/uart/: uart.h uart_adapter.c
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: generic_list.h generic_list.c
  group startup
    ../../../../../devices/MK64F12/iar/: startup_MK64F12.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
