# Keil uVision project lwip_httpssrv_wolfssl_bm.uvprojx, settings and files
target lwip_httpssrv_wolfssl_bm debug (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: lwip_httpssrv_wolfssl_bm.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VLL12, PRINTF_ADVANCED_ENABLE=1, FREESCALE_KSDK_BM, FRDM_K64F, FREEDOM
  c misc: --library_interface=armcc 
--diag_suppress=1296,186 
--diag_suppress=177,1293
  c include: ../../../../../../platform/components/phyksz8081;..;../../../..;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../middleware/mmcau;../../../../../../middleware/wolfssl;../../../../../../middleware/wolfssl/wolfssl/wolfcrypt/port;../../../../../../components/phyksz8081;../../../../../../devices/MK64F12/drivers;../../../../../../devices/MK64F12/drivers;../../../../../../devices/MK64F12/drivers;../../../../../../devices/MK64F12/drivers;../../../../../../devices/MK64F12/drivers;../../../../../../devices/MK64F12/drivers;../../../../../../devices/MK64F12/drivers;../../../../../../devices/MK64F12/utilities/str;../../../../../../devices/MK64F12/utilities/debug_console;../../../../../../devices/MK64F12/drivers;../../../../../../devices/MK64F12/drivers;../../../../../../devices/MK64F12;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../devices/MK64F12/drivers;../../../../../../middleware/lwip/port;../../../../../../middleware/lwip/src;../../../../../../middleware/lwip/src/include
  asm define: DEBUG
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: ../../../../../../middleware/mmcau/asm-cm4-cm7/lib_mmcau.lib 
--remove 
--predefine="-D__stack_size__=35000" 
--predefine="-D__heap_size__=30500"
  group lwip_httpd_wolfssl
    ../: httpd_wolfssl.c httpd_wolfssl.h
  group source
    ../: lwip_httpssrv_wolfssl_bm.c lwipopts.h user_settings.h certs_buff.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
    ../../../../../../components/phyksz8081/: fsl_phy.h fsl_phy.c
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MK64F12/drivers/: fsl_rnga.c fsl_rnga.h fsl_port.h fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_enet.h fsl_enet.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_gpio.h fsl_gpio.c fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c fsl_common.h fsl_common.c
  group mmcau-mmcau_include
    ../../../../../../middleware/mmcau/: cau_api.h fsl_mmcau.h
  group mmcau-mmcau_source
    ../../../../../../middleware/mmcau/: fsl_mmcau.c
  group wolfssl-wolfssl_include
    ../../../../../../middleware/wolfssl/wolfssl/: callbacks.h certs_test.h crl.h error-ssl.h internal.h ocsp.h options.h sniffer.h sniffer_error.h ssl.h test.h version.h
    ../../../../../../middleware/wolfssl/wolfssl/openssl/: ec.h ssl.h bn.h
    ../../../../../../middleware/wolfssl/wolfssl/wolfcrypt/: aes.h arc4.h asn.h asn_public.h blake2.h blake2-impl.h blake2-int.h camellia.h cmac.h chacha.h chacha20_poly1305.h coding.h compress.h curve25519.h des3.h dh.h dsa.h ecc.h ed25519.h error-crypt.h fe_operations.h fips_test.h ge_operations.h hash.h hc128.h hmac.h integer.h idea.h logging.h md2.h md4.h md5.h mem_track.h memory.h misc.h mpi_class.h mpi_superclass.h pkcs7.h poly1305.h pwdbased.h rabbit.h random.h ripemd.h rsa.h settings.h sha.h sha256.h sha512.h signature.h srp.h tfm.h types.h visibility.h wc_encrypt.h wc_port.h
  group wolfssl-wolfssl_source
    ../../../../../../middleware/wolfssl/wolfcrypt/src/: aes.c arc4.c asm.c asn.c blake2b.c camellia.c cmac.c chacha.c chacha20_poly1305.c coding.c compress.c curve25519.c des3.c dh.c dsa.c ecc.c ecc_fp.c ed25519.c error.c fe_low_mem.c fe_operations.c ge_low_mem.c ge_operations.c hash.c hc128.c hmac.c integer.c idea.c logging.c md2.c md4.c md5.c memory.c misc.c pkcs7.c poly1305.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha512.c signature.c srp.c tfm.c wc_encrypt.c wc_port.c
    ../../../../../../middleware/wolfssl/src/: async.c crl.c internal.c io.c keys.c ocsp.c sniffer.c ssl.c tls.c
  group wolfssl-wolfssl_port
    ../../../../../../middleware/wolfssl/wolfcrypt/src/port/nxp/: ksdk_port.c
    ../../../../../../middleware/wolfssl/wolfssl/wolfcrypt/port/nxp/: ksdk_port.h
  group lwip-src-apps-httpd
    ../../../../../../middleware/lwip/src/apps/httpd/: fs.c fsdata.h httpd_structs.h
  group lwip-src-include-lwip-apps
    ../../../../../../middleware/lwip/src/include/lwip/apps/: fs.h httpd.h httpd_opts.h
  group lwip-port
    ../../../../../../middleware/lwip/port/: ethernetif.c ethernetif.h sys_arch.c
  group utilities
    ../../../../../../devices/MK64F12/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MK64F12/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MK64F12/utilities/: fsl_assert.c
  group device
    ../../../../../../devices/MK64F12/: fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.c system_MK64F12.h
  group component/uart
    ../../../../../../components/uart/: uart.h uart_adapter.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: generic_list.h generic_list.c
  group startup
    ../../../../../../devices/MK64F12/arm/: startup_MK64F12.s
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
  group lwip-port-arch
    ../../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip-src-api
    ../../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-src-core
    ../../../../../../middleware/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip-src-core-ipv4
    ../../../../../../middleware/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip-src-core-ipv6
    ../../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip-src-include-lwip
    ../../../../../../middleware/lwip/src/include/lwip/: api.h arch.h debug.h dhcp.h dns.h errno.h ethip6.h icmp6.h inet.h init.h ip_addr.h ip4_addr.h ip6.h ip6_frag.h memp.h nd6.h netdb.h netifapi.h pbuf.h sio.h sockets.h sys.h tcpip.h udp.h autoip.h def.h dhcp6.h err.h etharp.h icmp.h igmp.h inet_chksum.h ip.h ip4.h ip4_frag.h ip6_addr.h mem.h mld6.h netbuf.h netif.h opt.h raw.h snmp.h stats.h tcp.h timeouts.h
  group lwip-src-include-lwip-priv
    ../../../../../../middleware/lwip/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h nd6_priv.h tcp_priv.h tcpip_priv.h
  group lwip-src-include-lwip-prot
    ../../../../../../middleware/lwip/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h ethernet.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip-src-include-netif
    ../../../../../../middleware/lwip/src/include/netif/: etharp.h ethernet.h lowpan6.h lowpan6_opts.h slipif.h
  group lwip-src-include-netif-ppp
    ../../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap_ms.h chap-md5.h chap-new.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip-src-include-netif-ppp-polarssl
    ../../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip-src-include-posix
    ../../../../../../middleware/lwip/src/include/posix/: errno.h netdb.h
  group lwip-src-include-posix-sys
    ../../../../../../middleware/lwip/src/include/posix/sys/: socket.h
  group lwip-src-netif
    ../../../../../../middleware/lwip/src/netif/: ethernet.c lowpan6.c slipif.c
  group lwip-src-netif-ppp
    ../../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
target lwip_httpssrv_wolfssl_bm release (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: lwip_httpssrv_wolfssl_bm.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: NDEBUG, CPU_MK64FN1M0VLL12, PRINTF_ADVANCED_ENABLE=1, FREESCALE_KSDK_BM, FRDM_K64F, FREEDOM
  c misc: as above
  c include: as above
  asm define: NDEBUG
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: as above
