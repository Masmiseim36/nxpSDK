# IAR project erpc_server_dac_adc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VLL12; FRDM_K64F; FREEDOM; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../..; ..; ../service; ../../erpc_common; ../../../../../CMSIS/Driver/Include; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/cmsis_drivers; ../../../../../devices/MK64F12/utilities/io; ../../../../../devices/MK64F12/utilities/str; ../../../../../devices/MK64F12/utilities/log; ../../../../../devices/MK64F12/utilities; ../../../../../devices/MK64F12; ../../../../../middleware/multicore/erpc/erpc_c/infra; ../../../../../middleware/multicore/erpc/erpc_c/port; ../../../../../middleware/multicore/erpc/erpc_c/setup; ../../../../../middleware/multicore/erpc/erpc_c/transports
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: erpc_server_dac_adc.out
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VLL12; FRDM_K64F; FREEDOM; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1
  ICCARM.CCOptLevel: 3
  group drivers
    ../../../../../CMSIS/Driver/Include/: Driver_Common.h Driver_USART.h
    ../../../../../devices/MK64F12/drivers/: fsl_uart.h fsl_uart.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_uart_edma.h fsl_uart_edma.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_dac.c fsl_dac.h fsl_flash.c fsl_flash.h fsl_gpio.h fsl_gpio.c fsl_port.h fsl_smc.h fsl_smc.c fsl_i2c.h fsl_i2c.c fsl_adc16.c fsl_adc16.h
    ../../../../../devices/MK64F12/cmsis_drivers/: fsl_uart_cmsis.h fsl_uart_cmsis.c
  group accel
    ../: fxos.c fsl_fxos.h fsl_fxos.c
  group source
    ../: main_server.c erpc_config.h
  group erpc
    ../../erpc_common/: erpc_error_handler.h erpc_error_handler.cpp
  group erpc/service
    ../service/: erpc_crc16.h erpc_dac_adc.h erpc_dac_adc_server.h erpc_dac_adc_server.cpp
  group erpc/infra
    ../../../../../middleware/multicore/erpc/erpc_c/infra/: simple_server.h simple_server.cpp server.h server.cpp erpc_version.h codec.h basic_codec.h transport.h message_buffer.h message_loggers.h erpc_common.h manually_constructed.h crc16.h basic_codec.cpp message_buffer.cpp message_loggers.cpp crc16.cpp framed_transport.h framed_transport.cpp
  group erpc/setup
    ../../../../../middleware/multicore/erpc/erpc_c/setup/: erpc_server_setup.h erpc_server_setup.cpp erpc_transport_setup.h erpc_mbf_setup.h erpc_setup_uart_cmsis.cpp erpc_setup_mbf_dynamic.cpp
  group erpc/transports
    ../../../../../middleware/multicore/erpc/erpc_c/transports/: uart_cmsis_transport.h uart_cmsis_transport.cpp
  group erpc/port
    ../../../../../middleware/multicore/erpc/erpc_c/port/: erpc_port.h erpc_port_stdlib.cpp erpc_config_internal.h
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group CMSIS_driver
    ../../../../../CMSIS/Driver/Include/: Driver_USART.h Driver_Common.h
  group utilities
    ../../../../../devices/MK64F12/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MK64F12/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MK64F12/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group startup
    ../../../../../devices/MK64F12/: system_MK64F12.c system_MK64F12.h
    ../../../../../devices/MK64F12/iar/: startup_MK64F12.s
