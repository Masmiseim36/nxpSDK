# Keil uVision project erpc_server_matrix_multiply_uart.uvprojx, settings and files
target erpc_server_matrix_multiply_uart debug (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: erpc_server_matrix_multiply_uart.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MK64FN1M0VLL12, FRDM_K64F, FREEDOM, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../erpc_common;../../erpc_common/erpc_matrix_multiply/service;..;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/cmsis_drivers;../../../../../middleware/multicore/erpc/erpc_c/infra;../../../../../middleware/multicore/erpc/erpc_c/setup;../../../../../middleware/multicore/erpc/erpc_c/transports;../../../../../middleware/multicore/erpc/erpc_c/port;../../../../../devices/MK64F12/utilities/str;../../../../../devices/MK64F12/utilities/debug_console;../../../../../devices/MK64F12;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../CMSIS/Include;../../../../../CMSIS/Driver/Include;../../../../../middleware/multicore/erpc/erpc_c
  asm define: DEBUG
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --muldefweak --predefine="-D__stack_size__=0x400" --predefine="-D__heap_size__=0x2000"
  group source
    ../../erpc_common/: erpc_error_handler.h erpc_error_handler.cpp
    ../: main_server.c erpc_config.h
  group erpc/service
    ../../erpc_common/erpc_matrix_multiply/service/: erpc_matrix_multiply.erpc erpc_matrix_multiply.h erpc_matrix_multiply_server.h erpc_matrix_multiply_server.cpp
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK64F12/drivers/: fsl_uart.h fsl_uart.c fsl_uart_edma.h fsl_uart_edma.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_clock.h fsl_clock.c fsl_smc.h fsl_smc.c fsl_common.h fsl_common.c
    ../../../../../devices/MK64F12/cmsis_drivers/: fsl_uart_cmsis.h fsl_uart_cmsis.c
  group erpc/infra
    ../../../../../middleware/multicore/erpc/erpc_c/infra/: erpc_simple_server.h erpc_simple_server.cpp erpc_server.h erpc_server.cpp erpc_framed_transport.h erpc_framed_transport.cpp erpc_version.h erpc_codec.h erpc_basic_codec.h erpc_transport.h erpc_message_buffer.h erpc_message_loggers.h erpc_common.h erpc_manually_constructed.h erpc_crc16.h erpc_basic_codec.cpp erpc_message_buffer.cpp erpc_message_loggers.cpp erpc_crc16.cpp erpc_client_server_common.h erpc_pre_post_action.h erpc_pre_post_action.cpp
  group erpc/setup
    ../../../../../middleware/multicore/erpc/erpc_c/setup/: erpc_server_setup.h erpc_server_setup.cpp erpc_setup_uart_cmsis.cpp erpc_setup_mbf_dynamic.cpp erpc_transport_setup.h erpc_mbf_setup.h
  group erpc/transports
    ../../../../../middleware/multicore/erpc/erpc_c/transports/: erpc_uart_cmsis_transport.h erpc_uart_cmsis_transport.cpp
  group erpc/port
    ../../../../../middleware/multicore/erpc/erpc_c/port/: erpc_port.h erpc_port_stdlib.cpp erpc_config_internal.h erpc_setup_extensions.h
  group utilities
    ../../../../../devices/MK64F12/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK64F12/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MK64F12/utilities/: fsl_assert.c
  group device
    ../../../../../devices/MK64F12/: fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.c system_MK64F12.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MK64F12/arm/: startup_MK64F12.S
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group CMSIS_driver
    ../../../../../CMSIS/Driver/Include/: Driver_USART.h Driver_Common.h
target erpc_server_matrix_multiply_uart release (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: erpc_server_matrix_multiply_uart.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MK64FN1M0VLL12, FRDM_K64F, FREEDOM, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: as above
