# IAR project ntag_i2c_explorer_demo.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VLL12; PRINTF_ADVANCED_ENABLE=1; I2C_FSL; FRDM_K64F; FREEDOM; HAVE_STDBOOL_H; HAVE_STDINT_H
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../devices/MK64F12/utilities/debug_console_lite; ../../../../../devices/MK64F12/drivers; ../../../../../middleware/ntag_i2c_plus/HAL_NTAG/inc; ../../../../../middleware/ntag_i2c_plus/HAL_NTAG; ../../../../../middleware/ntag_i2c_plus/HAL_I2C/inc; ../../../../../middleware/ntag_i2c_plus/HAL_ISR/inc; ../../../../../middleware/ntag_i2c_plus/HAL_ISR; ../../../../../middleware/ntag_i2c_plus/HAL_TMR/inc; ../../../../../middleware/ntag_i2c_plus/inc; ../../../../../devices/MK64F12; ../../../../../components/uart; ../../../../../components/lists; ../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: ntag_i2c_explorer_demo.out
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VLL12; PRINTF_ADVANCED_ENABLE=1; I2C_FSL; FRDM_K64F; FREEDOM; HAVE_STDBOOL_H; HAVE_STDINT_H
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: ntag_i2c_explorer_demo.c ndef_message.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../devices/MK64F12/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../devices/MK64F12/drivers/: fsl_gpio.h fsl_gpio.c fsl_port.h fsl_smc.h fsl_smc.c fsl_adc16.c fsl_adc16.h fsl_i2c.h fsl_i2c.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_clock.h fsl_clock.c fsl_uart.h fsl_uart.c fsl_common.h fsl_common.c
  group ntag_i2c_plus/HAL_NTAG
    ../../../../../middleware/ntag_i2c_plus/HAL_NTAG/: ntag_driver_intern.h ntag_bridge.c ntag_driver.c
  group ntag_i2c_plus/HAL_NTAG/inc
    ../../../../../middleware/ntag_i2c_plus/HAL_NTAG/inc/: ntag_bridge.h ntag_defines.h ntag_device_list.h ntag_driver.h
  group ntag_i2c_plus/HAL_I2C
    ../../../../../middleware/ntag_i2c_plus/HAL_I2C/: i2c_kinetis_fsl.c
  group ntag_i2c_plus/HAL_I2C/inc
    ../../../../../middleware/ntag_i2c_plus/HAL_I2C/inc/: HAL_I2C_driver.h HAL_I2C_kinetis_fsl.h
  group ntag_i2c_plus/HAL_ISR
    ../../../../../middleware/ntag_i2c_plus/HAL_ISR/: isr_driver_intern.h isr_kinetis_intern.h isr_common.c isr_kinetis.c
  group ntag_i2c_plus/HAL_ISR/inc
    ../../../../../middleware/ntag_i2c_plus/HAL_ISR/inc/: HAL_ISR_callback_list.h HAL_ISR_driver.h
  group ntag_i2c_plus/HAL_TMR
    ../../../../../middleware/ntag_i2c_plus/HAL_TMR/: timer_driver.c
  group ntag_i2c_plus/HAL_TMR/inc
    ../../../../../middleware/ntag_i2c_plus/HAL_TMR/inc/: HAL_timer_driver.h
  group ntag_i2c_plus/inc
    ../../../../../middleware/ntag_i2c_plus/inc/: global_types.h nfc_device.h
  group device
    ../../../../../devices/MK64F12/: fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.c system_MK64F12.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MK64F12/iar/: startup_MK64F12.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
