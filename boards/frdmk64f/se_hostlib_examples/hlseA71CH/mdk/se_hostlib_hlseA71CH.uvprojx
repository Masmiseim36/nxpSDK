# Keil uVision project se_hostlib_hlseA71CH.uvprojx, settings and files
target se_hostlib_hlseA71CH debug (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: se_hostlib_hlseA71CH.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VLL12, FRDM_K64F, FREEDOM, TGT_A71CH, I2C, MBEDTLS_CONFIG_FILE='\"a71ch_mbedtls_frdm_config.h\"', MBEDTLS, SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC
  c misc: --library_interface=armcc 
--diag_suppress=1296,186 
--diag_suppress=177
  c include: ..;../../../../../middleware/se_hostlib/hostLib/a71ch/ex_hlse;../../mainA71CH;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../middleware/mmcau;../../../../../middleware/se_hostlib;../../../../../middleware/mbedtls/include;../../../../../middleware/mbedtls/port/ksdk;../../../../../middleware/se_hostlib/hostLib/libCommon/hostCrypto;../../../../../middleware/se_hostlib/hostLib/tstUtil;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers;../../../../../middleware/se_hostlib/hostLib/libCommon/infra;../../../../../middleware/se_hostlib/hostLib/libCommon/scp;../../../../../middleware/se_hostlib/hostLib/libCommon/smCom;../../../../../middleware/se_hostlib/hostLib/platform/inc;../../../../../middleware/se_hostlib/platform;../../../../../middleware/se_hostlib/hostLib/tstUtil;../../../../../middleware/se_hostlib/hostLib/a71ch/inc;../../../../../middleware/se_hostlib/hostLib/api/inc;../../../../../middleware/se_hostlib/hostLib/mbedtls/inc;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/utilities/str;../../../../../devices/MK64F12/utilities/debug_console;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/serial_manager;../../../../../components/lists
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: ../../../../../middleware/mmcau/asm-cm4-cm7/lib_mmcau.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x8000"
  group source
    ../: ex_hlse_aes.c ex_hlse_boot.c ex_hlse_cert.c ex_hlse_config.c ex_hlse_debug.c ex_hlse_ecc_nohc.c ex_hlse_gpstorage.c ex_hlse_misc.c ex_hlse_psk.c ex_hlse_scp.c ex_hlse_sst.c ex_hlse_sst_kp.c ex_hlse_walkthrough.c mainA71CH_hlse.c a71ch_ex_hlse.h tst_hlse_a71ch_util.c tst_hlse_a71ch_util.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group mmcau-mmcau_include
    ../../../../../middleware/mmcau/: cau_api.h fsl_mmcau.h
  group mmcau-mmcau_source
    ../../../../../middleware/mmcau/: fsl_mmcau.c
  group drivers
    ../../../../../devices/MK64F12/drivers/: fsl_rnga.c fsl_rnga.h fsl_i2c.h fsl_i2c.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_gpio.h fsl_gpio.c fsl_port.h fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c
  group se_hostlib-common
    ../../../../../middleware/se_hostlib/hostLib/libCommon/infra/: global_platf.c global_platf.h sm_apdu.c sm_apdu.h sm_errors.c sm_errors.h sm_types.h nxLog.c nxLog.h nxLog_App.h nxLog_DefaultConfig.h a71_debug.c a71_debug.h
    ../../../../../middleware/se_hostlib/hostLib/libCommon/scp/: scp.c scp.h
    ../../../../../middleware/se_hostlib/hostLib/libCommon/smCom/: apduComm.h sci2c.c sci2c.h smCom.c smComSCI2C.c
    ../../../../../middleware/se_hostlib/hostLib/libCommon/hostCrypto/: axHostCrypto.h axHostCryptombedtls.c hcAsn.c hcAsn.h HostCryptoAPI.h
  group se_hostlib-platform
    ../../../../../middleware/se_hostlib/hostLib/platform/generic/: sm_printf.c
    ../../../../../middleware/se_hostlib/hostLib/platform/inc/: i2c_a7.h sm_printf.h sm_timer.h
    ../../../../../middleware/se_hostlib/hostLib/platform/kinetis/: i2c_frdm.c i2c_imxrt10xx.c i2c_lpc54xxx.c timer_kinetis.c timer_kinetis_bm.c timer_kinetis_freertos.c
    ../../../../../middleware/se_hostlib/hostLib/tstUtil/: app_boot.c
  group se_hostlib-inc
    ../../../../../middleware/se_hostlib/hostLib/libCommon/smCom/: smCom.h smComSCI2C.h sci2c_cfg.h
  group se_hostlib-src
    ../../../../../middleware/se_hostlib/hostLib/libCommon/hostCrypto/: HostCryptoAPImbedtls.c
  group se_hostlib-mbedtls
    ../../../../../middleware/se_hostlib/hostLib/mbedtls/inc/: a71ch_mbedtls_frdm_config.h a71ch_mbedtls_frdmkw41z_config.h a71ch_mbedtls_evkbimxrt1050_config.h ax_mbedtls.h ecp_alt.h
    ../../../../../middleware/se_hostlib/hostLib/mbedtls/src/: ax_mbedtls.c ecdh_alt.c ecdh_alt_ax.c ecp_alt.c ecp_alt_ax.c ecp_curves_alt.c
  group se_hostlib-tst
    ../../../../../middleware/se_hostlib/hostLib/tstUtil/: axWebUtil.h hkdf_mbedtls.c hkdf_mbedtls.h tst_a71ch_util.c tst_a71ch_util.h tst_sm_time.h tst_sm_time_kinetis.c tst_sm_util.c tst_sm_util.h tstHostCrypto.h tstHostCrypto_mbedtls.c app_boot.h tst_utils_kinetis.c tst_utils_rtos.c tst_utils_kinetis.h
  group se_hostlib-ax
    ../../../../../middleware/se_hostlib/hostLib/api/src/: ax_scp.c ax_switch.c A71HLSEWrapper.c ax_crypto_ecc.c ax_crypto_rng.c ax_util.c ax_sst.c ax_crypto_aes_key.c
    ../../../../../middleware/se_hostlib/hostLib/api/inc/: ax_scp_private.h HLSEObjects.h HLSECrypto.h HLSEMisc.h ax_api.h ax_util.h ax_common.h ax_common_private.h HLSEComm.h ax_scp.h HLSETypes.h HLSEAPI.h
    ../../../../../middleware/se_hostlib/hostLib/a71ch/src/: a71ch_crypto_derive.c a71ch_com.c a71ch_sst.c a71ch_crypto_ecc.c a71ch_module.c
    ../../../../../middleware/se_hostlib/hostLib/a71ch/inc/: a71ch_const.h a71ch_util.h a71ch_api.h
  group mbedtls-mbedtls_include
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls-mbedtls_source
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c chacha20.c chachapoly.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls-mbedtls_port
    ../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c
  group utilities
    ../../../../../devices/MK64F12/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK64F12/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MK64F12/utilities/: fsl_assert.c
  group device
    ../../../../../devices/MK64F12/: fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.c system_MK64F12.h
  group component/uart
    ../../../../../components/uart/: uart.h uart_adapter.c
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: generic_list.h generic_list.c
  group startup
    ../../../../../devices/MK64F12/arm/: startup_MK64F12.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
target se_hostlib_hlseA71CH release (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: se_hostlib_hlseA71CH.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: NDEBUG, CPU_MK64FN1M0VLL12, FRDM_K64F, FREEDOM, TGT_A71CH, I2C, MBEDTLS_CONFIG_FILE='\"a71ch_mbedtls_frdm_config.h\"', MBEDTLS, SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: as above
