# Keil uVision project a71ch_Main.uvprojx, settings and files
target a71ch_Main debug (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: a71ch_Main.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MK64FN1M0VLL12, SDK_DEBUGCONSOLE=0, SDK_DEBUGCONSOLE_UART, TGT_A71CH=1, SCI2C=1, SSS_USE_FTR_FILE, MBEDTLS_CONFIG_FILE='\"a71ch_mbedtls_frdm_config.h\"', MBEDTLS, SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC, PRINTF_ADVANCED_ENABLE=1, FRDM_K64F, FREEDOM, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../middleware/mmcau;../../../../../devices/MK64F12/drivers;../../../../../middleware/mbedtls/port/ksdk;../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/infra;../../../../../middleware/se_hostlib;../../../../../middleware/se_hostlib/hostlib/hostLib/inc;../../../../../middleware/se_hostlib/sss/inc;../../../../../middleware/se_hostlib/sss/port/ksdk;../../../../../middleware/se_hostlib/hostlib/hostLib/mbedtls/inc;../../../../../middleware/mbedtls/include;../../../../../middleware/mbedtls/library;../../../../../devices/MK64F12/utilities/str;../../../../../devices/MK64F12/utilities/debug_console;../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom;../../../../../middleware/se_hostlib/hostlib/hostLib/platform/inc;../../../../../middleware/se_hostlib/hostlib/hostLib/platform/ksdk;../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/scp;../../../../../middleware/se_hostlib/platform;../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/hostCrypto;../../../../../middleware/se_hostlib/hostlib/hostLib/tstUtil;../../../../../devices/MK64F12;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../CMSIS/Include
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: ../../../../../middleware/mmcau/asm-cm4-cm7/lib_mmcau.lib --remove --keep=*(.FlashConfig) --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x8000"
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source
    ../: fsl_sss_ftr.h a71ch_ex.h ex_aes.c ex_boot.c ex_config.c ex_debug.c ex_ecc_nohc.c ex_gpstorage.c ex_misc.c ex_psk.c ex_scp.c ex_sst.c ex_sst_kp.c ex_walkthrough.c mainA71CH.c
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK64F12/drivers/: fsl_rnga.c fsl_rnga.h fsl_i2c.h fsl_i2c.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_pit.c fsl_pit.h fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_gpio.h fsl_gpio.c fsl_port.h fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c
  group mbedtls/port/ksdk
    ../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c ecp_alt.h ecp_alt.c ecp_curves_alt.c ecp_alt_ksdk.c
  group se_hostlib/hostlib/hostLib/a71ch/src
    ../../../../../middleware/se_hostlib/hostlib/hostLib/a71ch/src/: a71ch_module.c a71ch_crypto_ecc.c a71ch_com_scp.c a71ch_sst.c a71ch_crypto_derive.c
  group se_hostlib/hostlib/hostLib/api/src
    ../../../../../middleware/se_hostlib/hostlib/hostLib/api/src/: A71HLSEWrapper.c ax_crypto_aes_key.c ax_crypto_ecc.c ax_crypto_rng.c ax_scp.c ax_switch.c ax_util.c
  group se_hostlib/hostlib/hostLib/libCommon/infra
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/infra/: a71_debug.c a71_debug.h sm_connect.c global_platf.c sm_api.h sm_demo_utils.h sm_apdu.h nxLog_UseCases.h sm_types.h nxLog_VCOM.h nxLog_App.h nxLog_hostLib.h nxLog_smCom.h nxLog_sscp.h nxLog.h app_boot_nfc.h a71_debug.h nxLog_mbedtls.h sm_errors.h global_platf.h app_boot.h nxLog_scp.h nxLog_DefaultConfig.h nxLog_sss.h cm_commands.h nxLog.c sm_apdu.c sm_errors.c sm_printf.c a71_debug.c sm_app_boot.c sm_demo_utils.c sm_demo_utils_rtos.c
  group mbedtls/include/mbedtls
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/library
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c chacha20.c chachapoly.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group utilities
    ../../../../../devices/MK64F12/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK64F12/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MK64F12/utilities/: fsl_assert.c
  group se_hostlib/hostlib/hostLib/libCommon/smCom
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/: apduComm.h sci2c.c sci2c.h sci2c_cfg.h smCom.c smCom.h smComSCI2C.c smComSCI2C.h smComT1oI2C.h
  group se_hostlib/hostlib/hostLib/inc
    ../../../../../middleware/se_hostlib/hostlib/hostLib/inc/: sm_const.h ax_common_a71cl.h ax_sss_scp.h ax_common_a71ch.h ax_scp_private.h nxEnsure.h nxScp03_Types.h HLSECrypto.h a71cl_util.h ax_util.h HLSEAPI.h se05x_ecc_curves_inc.h HLSEObjects.h a71cl_api.h scp.h ax_scp.h se05x_ftr.h HLSEMisc.h se05x_enums.h se05x_ecc_curves.h HLSETypes.h PlugAndTrust_HostLib_Ver.h se05x_const.h ax_api.h SE_HAL_Lib.h nxScp03_Const.h ledHandler.h ax_common_private.h PlugAndTrust_Pkg_Ver.h Applet_SE050_Ver.h se05x_ecc_curves_values.h a71ch_util.h se05x_tlv.h a71ch_api.h nxScp03_Apis.h ax_common.h HLSEComm.h
  group se_hostlib/hostlib/hostLib/libCommon/scp
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/scp/: scp_a7x.c
  group se_hostlib/hostlib/hostLib/platform/inc
    ../../../../../middleware/se_hostlib/hostlib/hostLib/platform/inc/: se_pit_config.h i2c_a7.h ax_reset.h se_reset_config.h se05x_apis.h sm_timer.h sm_printf.h
  group se_hostlib/hostlib/hostLib/platform/ksdk
    ../../../../../middleware/se_hostlib/hostlib/hostLib/platform/ksdk/: ax_reset.c i2c_frdm.c i2c_imxrt10xx.c timer_kinetis.c timer_kinetis_bm.c timer_kinetis_freertos.c
  group se_hostlib/sss/inc
    ../../../../../middleware/se_hostlib/sss/inc/: fsl_sss_util_asn1_der.h fsl_sss_config.h fsl_sss_mbedtls_types.h fsl_sss_api_ver.h fsl_sss_mbedtls_apis.h fsl_sss_ftr_default.h fsl_sss_sscp_config.h fsl_sscp_a71cl.h fsl_sss_keyid_map.h fsl_sscp_a71ch.h fsl_sss_lpc55s_apis.h fsl_sscp_commands.h fsl_sss_api.h fsl_sss_user_types.h fsl_sss_se05x_scp03.h fsl_sss_se05x_types.h fsl_sss_util_rsa_sign_utils.h fsl_sscp.h fsl_sss_policy.h fsl_sss_openssl_apis.h fsl_sss_se05x_policy.h fsl_sss_se05x_apis.h fsl_sss_openssl_types.h fsl_sss_user_apis.h fsl_sss_lpc55s_types.h fsl_sss_sscp.h fsl_sscp_mu.h
  group se_hostlib/sss/port/ksdk
    ../../../../../middleware/se_hostlib/sss/port/ksdk/: fsl_sss_types.h
  group se_hostlib/hostlib/hostLib/mbedtls/inc
    ../../../../../middleware/se_hostlib/hostlib/hostLib/mbedtls/inc/: a71ch_mbedtls_frdm_config.h ax_mbedtls.h
  group se_hostlib/hostlib/hostLib/mbedtls/src
    ../../../../../middleware/se_hostlib/hostlib/hostLib/mbedtls/src/: ax_mbedtls.c ecdh_alt_ax.c ecp_alt_ax.c
  group se_hostlib/hostlib/hostLib/tstUtil
    ../../../../../middleware/se_hostlib/hostlib/hostLib/tstUtil/: axWebUtil.h hkdf_mbedtls.c hkdf_mbedtls.h tst_a71ch_util.c tst_a71ch_util.h tst_sm_time.h tst_sm_time_kinetis.c tst_sm_util.c tst_sm_util.h tstHostCrypto.h tstHostCrypto_mbedtls.c tstHostCrypto_mbedtls_aes.c
  group device
    ../../../../../devices/MK64F12/: fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.c system_MK64F12.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MK64F12/arm/: startup_MK64F12.S
  group mmcau
    ../../../../../middleware/mmcau/: cau_api.h fsl_mmcau.h fsl_mmcau.c
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group se_hostlib/hostlib/hostLib/libCommon/hostCrypto
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/hostCrypto/: axHostCrypto.h axHostCryptombedtls.c hcAsn.c hcAsn.h HostCryptoAPI.h HostCryptoAPImbedtls.c
target a71ch_Main release (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: a71ch_Main.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MK64FN1M0VLL12, SDK_DEBUGCONSOLE=0, SDK_DEBUGCONSOLE_UART, TGT_A71CH=1, SCI2C=1, SSS_USE_FTR_FILE, MBEDTLS_CONFIG_FILE='\"a71ch_mbedtls_frdm_config.h\"', MBEDTLS, SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC, PRINTF_ADVANCED_ENABLE=1, FRDM_K64F, FREEDOM, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: as above
