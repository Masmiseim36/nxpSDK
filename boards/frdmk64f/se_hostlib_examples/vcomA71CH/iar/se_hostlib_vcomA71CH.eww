<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>se_hostlib_vcomA71CH</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>se_hostlib_vcomA71CH</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>se_hostlib_vcomA71CH</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>se_hostlib_vcomA71CH</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/se_hostlib_vcomA71CH.ewp</path>
  </project>
</workspace>
