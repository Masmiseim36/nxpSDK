# Keil uVision project a71ch_vcom.uvprojx, settings and files
target a71ch_vcom debug (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: a71ch_vcom.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MK64FN1M0VLL12, SDK_DEBUGCONSOLE=0, SDK_DEBUGCONSOLE_UART, TGT_A71CH, SCI2C=1, USB_STACK_BM, NO_SECURE_CHANNEL_SUPPORT, SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC, SSS_USE_FTR_FILE, FSL_OSA_BM_TIMER_CONFIG=0, SERIAL_PORT_TYPE_USBCDC=1, USB_ISR_REDIRECT, PRINTF_ADVANCED_ENABLE=1, FRDM_K64F, FREEDOM, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, USB_DEVICE_CONFIG_CDC_ACM=1, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../middleware/usb/device;../../../../../components/osa;../../../../../middleware/usb/include;../../../../../devices/MK64F12/drivers;../../../../../middleware/mmcau;../../../../../components/serial_manager;../../../../../components/lists;../../../../../components/serial_manager/usb_cdc_adapter;../../../../../middleware/se_hostlib/hostlib/hostLib/inc;../../../../../middleware/se_hostlib/hostlib/hostLib/platform/inc;../../../../../middleware/se_hostlib/hostlib/hostLib/platform/ksdk;../../../../../middleware/se_hostlib/sss/inc;../../../../../middleware/se_hostlib/sss/port/ksdk;../../../../../middleware/se_hostlib;../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/scp;../../../../../middleware/se_hostlib/platform;../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom;../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/infra;../../../../../devices/MK64F12/utilities/str;../../../../../devices/MK64F12/utilities/debug_console;../../../../../devices/MK64F12;../../../../../components/uart;../../../../../CMSIS/Include;../../../../../middleware/usb/output/source/device/class;../../../../../middleware/usb/output/source/device
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: ../../../../../middleware/mmcau/asm-cm4-cm7/lib_mmcau.lib --remove --keep=*(.FlashConfig)
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source
    ../: fsl_sss_ftr.h vcom2i2c.c vcom2i2c.h virtual_com.c virtual_com.h
  group doc
    ../: readme.txt
  group usb/device/include
    ../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group usb/device/source
    ../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h usb_device_dci.h
    ../../../../../middleware/usb/output/source/device/: usb_device_ch9.c usb_device_ch9.h
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c
  group usb/device/source/khci
    ../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
  group usb/include
    ../../../../../middleware/usb/include/: usb.h usb.h usb_misc.h usb_spec.h
  group drivers
    ../../../../../devices/MK64F12/drivers/: fsl_sysmpu.h fsl_sysmpu.c fsl_rnga.c fsl_rnga.h fsl_i2c.h fsl_i2c.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_pit.c fsl_pit.h fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_gpio.h fsl_gpio.c fsl_port.h fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_usb.h fsl_component_serial_port_usb.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/serial_manager/usb_cdc_adapter
    ../../../../../components/serial_manager/usb_cdc_adapter/: usb_device_descriptor.h usb_device_descriptor.c
    ../: usb_device_config.h
  group se_hostlib/hostlib/hostLib/inc
    ../../../../../middleware/se_hostlib/hostlib/hostLib/inc/: sm_const.h ax_common_a71cl.h ax_sss_scp.h ax_common_a71ch.h ax_scp_private.h nxEnsure.h nxScp03_Types.h HLSECrypto.h a71cl_util.h ax_util.h HLSEAPI.h se05x_ecc_curves_inc.h HLSEObjects.h a71cl_api.h scp.h ax_scp.h se05x_ftr.h HLSEMisc.h se05x_enums.h se05x_ecc_curves.h HLSETypes.h PlugAndTrust_HostLib_Ver.h se05x_const.h ax_api.h SE_HAL_Lib.h nxScp03_Const.h ledHandler.h ax_common_private.h PlugAndTrust_Pkg_Ver.h Applet_SE050_Ver.h se05x_ecc_curves_values.h a71ch_util.h se05x_tlv.h a71ch_api.h nxScp03_Apis.h ax_common.h HLSEComm.h
  group se_hostlib/hostlib/hostLib/libCommon/scp
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/scp/: scp_a7x.c
  group se_hostlib/hostlib/hostLib/platform/inc
    ../../../../../middleware/se_hostlib/hostlib/hostLib/platform/inc/: se_pit_config.h i2c_a7.h ax_reset.h se_reset_config.h se05x_apis.h sm_timer.h sm_printf.h
  group se_hostlib/hostlib/hostLib/platform/ksdk
    ../../../../../middleware/se_hostlib/hostlib/hostLib/platform/ksdk/: ax_reset.c i2c_frdm.c i2c_imxrt10xx.c timer_kinetis.c timer_kinetis_bm.c timer_kinetis_freertos.c
  group se_hostlib/sss/inc
    ../../../../../middleware/se_hostlib/sss/inc/: fsl_sss_util_asn1_der.h fsl_sss_config.h fsl_sss_mbedtls_types.h fsl_sss_api_ver.h fsl_sss_mbedtls_apis.h fsl_sss_ftr_default.h fsl_sss_sscp_config.h fsl_sscp_a71cl.h fsl_sss_keyid_map.h fsl_sscp_a71ch.h fsl_sss_lpc55s_apis.h fsl_sscp_commands.h fsl_sss_api.h fsl_sss_user_types.h fsl_sss_se05x_scp03.h fsl_sss_se05x_types.h fsl_sss_util_rsa_sign_utils.h fsl_sscp.h fsl_sss_policy.h fsl_sss_openssl_apis.h fsl_sss_se05x_policy.h fsl_sss_se05x_apis.h fsl_sss_openssl_types.h fsl_sss_user_apis.h fsl_sss_lpc55s_types.h fsl_sss_sscp.h fsl_sscp_mu.h
  group se_hostlib/sss/port/ksdk
    ../../../../../middleware/se_hostlib/sss/port/ksdk/: fsl_sss_types.h
  group se_hostlib/hostlib/hostLib/libCommon/smCom
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/: apduComm.h sci2c.c sci2c.h sci2c_cfg.h smCom.c smCom.h smComSCI2C.c smComSCI2C.h smComT1oI2C.h
  group se_hostlib/hostlib/hostLib/libCommon/infra
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/infra/: sm_connect.c global_platf.c sm_api.h sm_demo_utils.h sm_apdu.h nxLog_UseCases.h sm_types.h nxLog_VCOM.h nxLog_App.h nxLog_hostLib.h nxLog_smCom.h nxLog_sscp.h nxLog.h app_boot_nfc.h a71_debug.h nxLog_mbedtls.h sm_errors.h global_platf.h app_boot.h nxLog_scp.h nxLog_DefaultConfig.h nxLog_sss.h cm_commands.h nxLog.c sm_apdu.c sm_errors.c sm_printf.c a71_debug.c
  group utilities
    ../../../../../devices/MK64F12/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK64F12/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MK64F12/utilities/: fsl_assert.c
  group device
    ../../../../../devices/MK64F12/: fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.c system_MK64F12.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group startup
    ../../../../../devices/MK64F12/arm/: startup_MK64F12.S
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group mmcau
    ../../../../../middleware/mmcau/: cau_api.h fsl_mmcau.h fsl_mmcau.c
  group usb/device/class/cdc
    ../../../../../middleware/usb/output/source/device/class/: usb_device_cdc_acm.c usb_device_cdc_acm.h
  group usb/device/class
    ../../../../../middleware/usb/output/source/device/class/: usb_device_class.c usb_device_class.h
target a71ch_vcom release (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: a71ch_vcom.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MK64FN1M0VLL12, SDK_DEBUGCONSOLE=0, SDK_DEBUGCONSOLE_UART, TGT_A71CH, SCI2C=1, USB_STACK_BM, NO_SECURE_CHANNEL_SUPPORT, SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC, SSS_USE_FTR_FILE, FSL_OSA_BM_TIMER_CONFIG=0, SERIAL_PORT_TYPE_USBCDC=1, USB_ISR_REDIRECT, PRINTF_ADVANCED_ENABLE=1, FRDM_K64F, FREEDOM, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, USB_DEVICE_CONFIG_CDC_ACM=1, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: as above
