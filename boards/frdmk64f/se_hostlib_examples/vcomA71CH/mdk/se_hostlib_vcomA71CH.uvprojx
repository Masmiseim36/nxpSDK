# Keil uVision project se_hostlib_vcomA71CH.uvprojx, settings and files
target se_hostlib_vcomA71CH debug (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: se_hostlib_vcomA71CH.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VLL12, USB_STACK_BM, NO_SECURE_CHANNEL_SUPPORT, SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC, FRDM_K64F, FREEDOM, TGT_A71CH, I2C
  c misc: --library_interface=armcc 
--diag_suppress=1296,186
  c include: ..;../../../../../middleware/se_hostlib/hostLib/vcom/kinetis;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../middleware/mmcau;../../../../../middleware/se_hostlib;../../../../../middleware/usb/device;../../../../../middleware/usb/include;../../../../../middleware/usb/osa;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers;../../../../../components/serial_manager;../../../../../components/serial_manager/usb_cdc_adapter;../../../../../middleware/se_hostlib/hostLib/libCommon/infra;../../../../../middleware/se_hostlib/hostLib/libCommon/scp;../../../../../middleware/se_hostlib/hostLib/libCommon/smCom;../../../../../middleware/se_hostlib/hostLib/platform/inc;../../../../../middleware/se_hostlib/platform;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/utilities/str;../../../../../devices/MK64F12/utilities/debug_console;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../devices/MK64F12/utilities
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: ../../../../../middleware/mmcau/asm-cm4-cm7/lib_mmcau.lib 
--remove
  group source
    ../: virtual_com.c virtual_com.h vcom2i2c.c vcom2i2c.h usb_device_board_config.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group usb-device-source-khci
    ../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
  group usb-include
    ../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group osa
    ../../../../../middleware/usb/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group drivers
    ../../../../../devices/MK64F12/drivers/: fsl_sysmpu.h fsl_sysmpu.c fsl_rnga.c fsl_rnga.h fsl_i2c.h fsl_i2c.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_gpio.h fsl_gpio.c fsl_port.h fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c
  group mmcau-mmcau_include
    ../../../../../middleware/mmcau/: cau_api.h fsl_mmcau.h
  group mmcau-mmcau_source
    ../../../../../middleware/mmcau/: fsl_mmcau.c
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_usb.h serial_port_usb.c serial_port_uart.h serial_port_uart.c
  group component/serial_manager/usb_cdc_adapter
    ../../../../../components/serial_manager/usb_cdc_adapter/: usb_device_descriptor.h usb_device_descriptor.c usb_device_cdc_acm.c usb_device_cdc_acm.h usb_device_class.c usb_device_class.h usb_device_ch9.c usb_device_ch9.h
    ../../../../../devices/MK64F12/utilities/: usb_device_config.h
  group se_hostlib-common
    ../../../../../middleware/se_hostlib/hostLib/libCommon/infra/: global_platf.c global_platf.h sm_apdu.c sm_apdu.h sm_errors.c sm_errors.h sm_types.h nxLog.c nxLog.h nxLog_App.h nxLog_DefaultConfig.h
    ../../../../../middleware/se_hostlib/hostLib/libCommon/scp/: scp.c scp.h
    ../../../../../middleware/se_hostlib/hostLib/libCommon/smCom/: apduComm.h sci2c.c sci2c.h smCom.c smComSCI2C.c
  group se_hostlib-platform
    ../../../../../middleware/se_hostlib/hostLib/platform/generic/: sm_printf.c
    ../../../../../middleware/se_hostlib/hostLib/platform/inc/: i2c_a7.h sm_printf.h sm_timer.h
    ../../../../../middleware/se_hostlib/hostLib/platform/kinetis/: i2c_frdm.c i2c_imxrt10xx.c i2c_lpc54xxx.c timer_kinetis.c timer_kinetis_bm.c timer_kinetis_freertos.c
  group se_hostlib-inc
    ../../../../../middleware/se_hostlib/hostLib/libCommon/smCom/: smCom.h smComSCI2C.h sci2c_cfg.h
  group usb-device-include
    ../../../../../middleware/usb/device/: usb_device.h
  group usb-device-source
    ../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
  group utilities
    ../../../../../devices/MK64F12/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK64F12/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MK64F12/utilities/: fsl_assert.c
  group device
    ../../../../../devices/MK64F12/: fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.c system_MK64F12.h
  group component/uart
    ../../../../../components/uart/: uart.h uart_adapter.c
  group component/lists
    ../../../../../components/lists/: generic_list.h generic_list.c
  group startup
    ../../../../../devices/MK64F12/arm/: startup_MK64F12.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
target se_hostlib_vcomA71CH release (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: se_hostlib_vcomA71CH.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: NDEBUG, CPU_MK64FN1M0VLL12, USB_STACK_BM, NO_SECURE_CHANNEL_SUPPORT, SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC, FRDM_K64F, FREEDOM, TGT_A71CH, I2C
  c misc: --library_interface=armcc 
--diag_suppress=1296,186
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: as above
