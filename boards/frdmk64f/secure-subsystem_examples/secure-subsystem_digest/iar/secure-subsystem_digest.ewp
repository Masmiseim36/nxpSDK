# IAR project secure-subsystem_digest.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VLL12; SSS_HAVE_SOFTWARE=1; MBEDTLS_CONFIG_FILE="ksdk_mbedtls_config.h"; FRDM_K64F; FREEDOM; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.IExtraOptions: --diag_suppress Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../middleware/secure-subsystem/inc; ../../../../../devices/MK64F12/drivers; ../../../../../middleware/mmcau; ../../../../../middleware/mbedtls/include; ../../../../../middleware/mbedtls/library; ../../../../../devices/MK64F12/utilities/str; ../../../../../devices/MK64F12/utilities/debug_console; ../../../../../middleware/mbedtls/port/ksdk; ../../../../../middleware/secure-subsystem/port/ksdk; ../../../../../devices/MK64F12; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: secure-subsystem_digest.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x8000
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/mmcau/asm-cm4-cm7/lib_mmcau.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VLL12; SSS_HAVE_SOFTWARE=1; MBEDTLS_CONFIG_FILE="ksdk_mbedtls_config.h"; FRDM_K64F; FREEDOM; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: digest.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group secure-subsystem/inc
    ../../../../../middleware/secure-subsystem/inc/: fsl_sss_api.h fsl_sss_config.h fsl_sss_api.h fsl_sss_config.h fsl_sss_sscp.h fsl_sscp.h fsl_sscp_commands.h fsl_sscp_config.h
  group secure-subsystem/sscp
    ../../../../../middleware/secure-subsystem/src/sscp/: fsl_sss_sscp.c
    ../../../../../middleware/secure-subsystem/inc/: fsl_sss_sscp_config.h
  group secure-subsystem/port
    ../../../../../middleware/secure-subsystem/port/ksdk/: fsl_sss_types.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK64F12/drivers/: fsl_rnga.c fsl_rnga.h fsl_port.h fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c fsl_common.h fsl_common.c
  group mbedtls/include/mbedtls
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/library
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c chacha20.c chachapoly.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/port/ksdk
    ../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c ecp_alt.h ecp_alt.c ecp_curves_alt.c ecp_alt_ksdk.c
  group utilities
    ../../../../../devices/MK64F12/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK64F12/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MK64F12/utilities/: fsl_assert.c
  group device
    ../../../../../devices/MK64F12/: fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.c system_MK64F12.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MK64F12/iar/: startup_MK64F12.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group mmcau
    ../../../../../middleware/mmcau/: cau_api.h fsl_mmcau.h fsl_mmcau.c
