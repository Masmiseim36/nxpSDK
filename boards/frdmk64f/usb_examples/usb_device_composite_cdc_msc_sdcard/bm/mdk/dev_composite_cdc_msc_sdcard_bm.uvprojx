# Keil uVision project dev_composite_cdc_msc_sdcard_bm.uvprojx, settings and files
target dev_composite_cdc_msc_sdcard_bm Debug (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: dev_composite_cdc_msc_sdcard_bm.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: _DEBUG=1, CPU_MK64FN1M0VLL12, USB_STACK_BM, FRDM_K64F, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..;../../../..;../../../../../../CMSIS/Include;../../../../../../middleware/usb;../../../../../../middleware/usb/osa;../../../../../../middleware/usb/include;../../../../../../middleware/usb/device;../../../../../../devices/MK64F12/drivers;../../../../../../middleware/sdmmc/src;../../../../../../middleware/sdmmc/inc;../../../../../../middleware/sdmmc/port;../../../../../../devices/MK64F12/utilities/io;../../../../../../devices/MK64F12/utilities/str;../../../../../../devices/MK64F12/utilities/log;../../../../../../devices/MK64F12/utilities;../../../../../../devices/MK64F12
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove
  group sdmmc-port
    ../: fsl_sdmmc_host.c fsl_sdmmc_event.c fsl_sdmmc_event.h
  group doc
    ../: readme.txt
  group sources
    ../: composite.c composite.h disk_sdcard.c disk_sdcard.h usb_device_descriptor.c usb_device_descriptor.h virtual_com.c virtual_com.h usb_device_config.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group usb-device-source-khci
    ../../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
    ../../../../../../middleware/usb/include/: usb_khci.h
  group usb-include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group osa
    ../../../../../../middleware/usb/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group drivers
    ../../../../../../devices/MK64F12/drivers/: fsl_sdhc.h fsl_sdhc.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_port.h fsl_sim.h fsl_sim.c fsl_gpio.h fsl_gpio.c fsl_flash.c fsl_flash.h fsl_sysmpu.h fsl_sysmpu.c fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c
  group usb-device-include
    ../../../../../../middleware/usb/device/: usb_device.h
  group usb-device-source
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
    ../: usb_device_ch9.c usb_device_ch9.h
  group usb-device-class
    ../: usb_device_class.c usb_device_class.h
  group usb-device-class-cdc
    ../: usb_device_cdc_acm.c usb_device_cdc_acm.h
  group usb-device-class-msc
    ../: usb_device_msc.c usb_device_msc.h usb_device_msc_ufi.c usb_device_msc_ufi.h
  group sdmmc-src
    ../../../../../../middleware/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group sdmmc-inc
    ../../../../../../middleware/sdmmc/inc/: fsl_sd.h fsl_sdmmc_host.h fsl_sdmmc_common.h fsl_sdmmc_spec.h
  group utilities
    ../../../../../../devices/MK64F12/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../devices/MK64F12/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../devices/MK64F12/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group startup
    ../../../../../../devices/MK64F12/: system_MK64F12.c system_MK64F12.h
    ../../../../../../devices/MK64F12/arm/: startup_MK64F12.s
target dev_composite_cdc_msc_sdcard_bm Release (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: dev_composite_cdc_msc_sdcard_bm.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: _DEBUG=0, CPU_MK64FN1M0VLL12, USB_STACK_BM, FRDM_K64F, FREEDOM
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove
