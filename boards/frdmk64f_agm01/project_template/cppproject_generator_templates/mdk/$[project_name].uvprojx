# Keil uVision project $[project_name].uvprojx, settings and files
target $[project_name] Debug (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: cppproject_templates.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;../../../../../platform/drivers;../../../../../platform/drivers/uart;../../../../../platform/drivers/common;../../../../../platform/utilities/debug_console;../../../../../platform/drivers/smc;../../../../../platform/drivers/flash;../../../../../devices/MK64F12;../../../../../devices/MK64F12
  asm define: DEBUG
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../../devices/MK64F12/arm/MK64FN1M0xxx12_flash.scf
  link misc: --remove
  group startup
    ../../../../../devices/MK64F12/arm/: startup_MK64F12.s
    ../../../../../devices/MK64F12/: system_MK64F12.c system_MK64F12.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../platform/drivers/uart/: fsl_uart.h fsl_uart.c
    ../../../../../platform/drivers/common/: fsl_common.h fsl_common.c
    ../../../../../platform/drivers/smc/: fsl_smc.h fsl_smc.c
    ../../../../../platform/drivers/flash/: fsl_flash.c fsl_flash.h
    ../../../../../devices/MK64F12/: fsl_clock.h fsl_clock.c
  group utilities
    ../../../../../platform/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h
target $[project_name] Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: cppproject_templates.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG
  c misc: as above
  c include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../../devices/MK64F12/arm/MK64FN1M0xxx12_flash.scf
  link misc: --remove
