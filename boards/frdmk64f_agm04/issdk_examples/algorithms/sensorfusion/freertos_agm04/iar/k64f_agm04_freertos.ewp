# IAR project k64f_agm04_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VLL12; FSL_RTOS_FREE_RTOS; FRDM_K64F; FREEDOM; PRINTF_ADVANCED_ENABLE
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F; ../../../../../../../rtos/freertos_9.0.0/Source/include; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../platform/drivers; ../../../../../../../middleware/issdk_1.6/drivers/gpio; ../../../../../../../middleware/issdk_1.6/drivers/gpio/kinetis; ../../../../../../../middleware/issdk_1.6/drivers/systick; ../../../../../../../CMSIS/Driver/Include; ../../../../../../../middleware/issdk_1.6/sensors; ../../../../../../../middleware/issdk_1.6/algorithms/sensorfusion/sources; ../../../../..; ..; ../../../../../../../rtos/freertos_9.0.0/Source; ../../../../../../frdmk64f; ../../../../../../../devices/MK64F12/drivers; ../../../../../../../devices/MK64F12/cmsis_drivers; ../../../../../../../devices/MK64F12/utilities; ../../../../../../../devices/MK64F12
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: K64F-AGM04-SENSORFUSION-FREERTOS.bin
  ILINK.IlinkOutputFile: k64f_agm04_freertos.out
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VLL12; FSL_RTOS_FREE_RTOS; FRDM_K64F; FREEDOM; PRINTF_ADVANCED_ENABLE
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../../devices/MK64F12/iar/: startup_MK64F12.s
    ../../../../../../../devices/MK64F12/: system_MK64F12.c system_MK64F12.h
  group freertos
    ../../../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_1.c
    ../../../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
    ../../../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group freertos/portable
    ../../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F/: port.c fsl_tickless_systick.c fsl_tickless_generic.h portasm.s portmacro.h
  group doc
    ../: readme.txt
  group board
    ../../../../../: frdm_k64f.c frdm_k64f.h frdm_stbc_agm04_shield.h issdk_hal.h RTE_Device.h
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group sensors
    ../../../../../../../middleware/issdk_1.6/sensors/: register_io_i2c.c register_io_spi.c sensor_io_spi.c sensor_io_i2c.c register_io_i2c.h register_io_spi.h sensor_io_spi.h sensor_io_i2c.h sensor_drv.h fxas21002.h fxas21002_drv.h mma865x_drv.h mma865x.h mag3110_drv.h mag3110.h
  group drivers
    ../../../../../../../devices/MK64F12/drivers/: fsl_uart.h fsl_uart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_i2c.h fsl_i2c.c fsl_dmamux.h fsl_dmamux.c fsl_dspi.h fsl_dspi.c fsl_flash.c fsl_flash.h fsl_smc.h fsl_smc.c fsl_pit.c fsl_pit.h fsl_edma.h fsl_edma.c fsl_i2c_edma.c fsl_i2c_edma.h fsl_dspi_edma.h fsl_dspi_edma.c fsl_uart_edma.h fsl_uart_edma.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c
    ../../../../../../../devices/MK64F12/cmsis_drivers/: fsl_i2c_cmsis.h fsl_i2c_cmsis.c fsl_dspi_cmsis.h fsl_dspi_cmsis.c fsl_uart_cmsis.h fsl_uart_cmsis.c
  group drivers/freertos
    ../../../../../../../devices/MK64F12/drivers/: fsl_i2c_freertos.h fsl_i2c_freertos.c
  group gpio_driver
    ../../../../../../../middleware/issdk_1.6/drivers/gpio/kinetis/: gpio_driver_irq.c gpio_driver.c gpio_driver.h
    ../../../../../../../middleware/issdk_1.6/drivers/gpio/: Driver_GPIO.h
  group sensor_fusion
    ../../../../../../../middleware/issdk_1.6/algorithms/sensorfusion/sources/: approximations.c approximations.h calibration_storage.h calibration_storage.c control.c control.h debug.h debug.c DecodeCommandBytes.c driver_FXAS21002.c driver_MMA8652.c driver_MAG3110.c driver_KSDK_NVM.c driver_KSDK_NVM.h driver_pit.c driver_pit.h driver_systick.c drivers.h fusion.h fusion.c hal_frdm_fxs_mult2_b.c magnetic.c magnetic.h matrix.c matrix.h orientation.c orientation.h output_stream.c precisionAccelerometer.c precisionAccelerometer.h sensor_fusion.h sensor_fusion.c status.c status.h
  group source
    ../: build.h FreeRTOSConfig.h
    ../../../../../../../middleware/issdk_1.6/algorithms/sensorfusion/sources/: main_agm04_freertos_two_tasks.c
  group utilities
    ../../../../../../../middleware/issdk_1.6/drivers/systick/: systick_utils.c systick_utils.h
    ../../../../../../../devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h
