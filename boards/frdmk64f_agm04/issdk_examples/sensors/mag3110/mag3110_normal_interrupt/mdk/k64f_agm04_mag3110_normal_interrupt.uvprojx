# Keil uVision project k64f_agm04_mag3110_normal_interrupt.uvprojx, settings and files
target k64f_agm04_mag3110_normal_interrupt Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: k64f_agm04_mag3110_normal_interrupt.out
  AfterMake: fromelf.exe --m32combined  --output  "$L@L.bin"  "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VLL12, FRDM_K64F, FREEDOM, PRINTF_ADVANCED_ENABLE
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../platform/drivers;../../../../../../../middleware/issdk_1.6/drivers/gpio;../../../../../../../middleware/issdk_1.6/drivers/gpio/kinetis;../../../../../../../middleware/issdk_1.6/drivers/systick;../../../../../../../CMSIS/Driver/Include;../../../../../../../middleware/issdk_1.6/sensors;../../../../..;..;../../../../../../frdmk64f;../../../../../../../devices/MK64F12/drivers;../../../../../../../devices/MK64F12/cmsis_drivers;../../../../../../../devices/MK64F12/utilities;../../../../../../../devices/MK64F12
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove
  group startup
    ../../../../../../../devices/MK64F12/arm/: startup_MK64F12.s
    ../../../../../../../devices/MK64F12/: system_MK64F12.c system_MK64F12.h
  group doc
    ../: readme.txt
  group board
    ../../../../../: frdm_k64f.c frdm_k64f.h frdm_stbc_agm04_shield.h issdk_hal.h RTE_Device.h
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group sensors
    ../../../../../../../middleware/issdk_1.6/driverexamples/mag3110/: mag3110_normal_interrupt.c
    ../../../../../../../middleware/issdk_1.6/sensors/: mag3110.h mag3110_drv.h mag3110_drv.c
  group interface
    ../../../../../../../middleware/issdk_1.6/sensors/: sensor_drv.h register_io_i2c.c register_io_i2c.h sensor_io_i2c.c sensor_io_i2c.h register_io_spi.c register_io_spi.h sensor_io_spi.c sensor_io_spi.h
  group utilities
    ../../../../../../../middleware/issdk_1.6/drivers/systick/: systick_utils.c systick_utils.h
    ../../../../../../../devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h
  group drivers
    ../../../../../../../devices/MK64F12/drivers/: fsl_uart.h fsl_uart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_i2c.h fsl_i2c.c fsl_dspi.h fsl_dspi.c fsl_lptmr.c fsl_lptmr.h fsl_smc.h fsl_smc.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_i2c_edma.c fsl_i2c_edma.h fsl_dspi_edma.h fsl_dspi_edma.c fsl_uart_edma.h fsl_uart_edma.c fsl_common.h fsl_common.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
    ../../../../../../../devices/MK64F12/cmsis_drivers/: fsl_i2c_cmsis.h fsl_i2c_cmsis.c fsl_dspi_cmsis.h fsl_dspi_cmsis.c fsl_uart_cmsis.h fsl_uart_cmsis.c
  group gpio_driver
    ../../../../../../../middleware/issdk_1.6/drivers/gpio/kinetis/: gpio_driver_irq.c gpio_driver.c gpio_driver.h
    ../../../../../../../middleware/issdk_1.6/drivers/gpio/: Driver_GPIO.h
target k64f_agm04_mag3110_normal_interrupt Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: k64f_agm04_mag3110_normal_interrupt.out
  AfterMake: fromelf.exe --m32combined  --output  "$L@L.bin"  "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MK64FN1M0VLL12, FRDM_K64F, FREEDOM, PRINTF_ADVANCED_ENABLE
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove
