# IAR project k64f_mult2b_host_demo_template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VLL12; FRDM_K64F; FREEDOM; PRINTF_ADVANCED_ENABLE
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../platform/drivers; ../../../../../../../middleware/issdk_1.6/drivers/gpio/kinetis; ../../../../../../../middleware/issdk_1.6/drivers/gpio; ../../../../../../../middleware/issdk_1.6/drivers/host; ../../../../../../../middleware/issdk_1.6/drivers/ads; ../../../../../../../middleware/issdk_1.6/drivers/ads/kinetis; ../../../../../../../middleware/issdk_1.6/drivers/systick; ../../../../../../../CMSIS/Driver/Include; ../../../../../../../middleware/issdk_1.6/sensors; ../../../../..; ..; ../../../../../../frdmk64f; ../../../../../../../devices/MK64F12/drivers; ../../../../../../../devices/MK64F12/cmsis_drivers; ../../../../../../../devices/MK64F12/utilities; ../../../../../../../devices/MK64F12
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: K64F-MULT2B-HOST-DEMO.bin
  ILINK.IlinkOutputFile: k64f_mult2b_host_demo_template.out
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VLL12; FRDM_K64F; FREEDOM; PRINTF_ADVANCED_ENABLE
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../../devices/MK64F12/iar/: startup_MK64F12.s
    ../../../../../../../devices/MK64F12/: system_MK64F12.c system_MK64F12.h
  group doc
    ../: readme.txt
  group board
    ../../../../../: frdm_k64f.c frdm_k64f.h frdm_fxs_mult2b_shield.h issdk_hal.h RTE_Device.h
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group sensors
    ../../../../../../../middleware/issdk_1.6/driverexamples/demos/: host_demo.c
    ../../../../../../../middleware/issdk_1.6/sensors/: fxas21002.h fxlc95000.h fxls8471q.h fxls8962.h fxos8700.h fxpq3115.h mag3110.h mma845x.h mma865x.h mma8491q.h mma9553.h mpl3115.h diff_p.h
  group interface
    ../../../../../../../middleware/issdk_1.6/sensors/: sensor_drv.h register_io_i2c.c register_io_i2c.h sensor_io_i2c.c sensor_io_i2c.h register_io_spi.c register_io_spi.h sensor_io_spi.c sensor_io_spi.h
  group utilities
    ../../../../../../../middleware/issdk_1.6/drivers/systick/: systick_utils.c systick_utils.h
    ../../../../../../../devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h
  group drivers
    ../../../../../../../devices/MK64F12/drivers/: fsl_uart.h fsl_uart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_i2c.h fsl_i2c.c fsl_dspi.h fsl_dspi.c fsl_lptmr.c fsl_lptmr.h fsl_smc.h fsl_smc.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_i2c_edma.c fsl_i2c_edma.h fsl_dspi_edma.h fsl_dspi_edma.c fsl_uart_edma.h fsl_uart_edma.c fsl_common.h fsl_common.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
    ../../../../../../../devices/MK64F12/cmsis_drivers/: fsl_i2c_cmsis.h fsl_i2c_cmsis.c fsl_dspi_cmsis.h fsl_dspi_cmsis.c fsl_uart_cmsis.h fsl_uart_cmsis.c
  group gpio_driver
    ../../../../../../../middleware/issdk_1.6/drivers/gpio/kinetis/: gpio_driver_irq.c gpio_driver.c gpio_driver.h
    ../../../../../../../middleware/issdk_1.6/drivers/gpio/: Driver_GPIO.h
  group host
    ../../../../../../../middleware/issdk_1.6/sensors/: host_io_uart.c host_io_uart.h
    ../../../../../../../middleware/issdk_1.6/drivers/host/: comm_if_uart.c comm_interface.h data_format_hdlc.c data_format_hdlc.h data_format_json.c data_format_json.h data_format_service.h host_interface_service.c host_interface_service.h
  group ads
    ../../../../../../../middleware/issdk_1.6/drivers/ads/kinetis/: auto_detection_service.c auto_detection_service.h
    ../../../../../../../middleware/issdk_1.6/drivers/ads/: auto_detection_shield.h
