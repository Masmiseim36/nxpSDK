# Keil uVision project hostdemo_mult2b.uvprojx, settings and files
target hostdemo_mult2b Debug (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: hostdemo_mult2b.out
  AfterMake: fromelf.exe --m32combined  --output  "$L@L.bin"  "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VLL12, FRDM_K64F, FREEDOM, PRINTF_ADVANCED_ENABLE
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../platform/drivers;../../../../../../frdmk64f;../../../../..;..;../../../../../../../devices/MK64F12/drivers;../../../../../../../devices/MK64F12/utilities/io;../../../../../../../devices/MK64F12/utilities/str;../../../../../../../devices/MK64F12/utilities/log;../../../../../../../devices/MK64F12/utilities;../../../../../../../devices/MK64F12;../../../../../../../devices/MK64F12/cmsis_drivers;../../../../../../../CMSIS/Driver/Include;../../../../../../../middleware/issdk/drivers/systick;../../../../../../../middleware/issdk/drivers/gpio;../../../../../../../middleware/issdk/drivers/gpio/kinetis;../../../../../../../middleware/issdk/sensors;../../../../../../../middleware/issdk/drivers/ads;../../../../../../../middleware/issdk/drivers/ads/kinetis;../../../../../../../middleware/issdk/drivers/host
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove
  group board
    ../../../../../: frdm_k64f.c frdm_k64f.h frdm_fxs_mult2b_shield.h issdk_hal.h RTE_Device.h
    ../: pin_mux.c pin_mux.h clock_config.c clock_config.h board.c board.h
  group source
    ../: host_demo.c
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MK64F12/drivers/: fsl_flash.c fsl_flash.h fsl_gpio.h fsl_gpio.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_port.h fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c fsl_uart_edma.h fsl_uart_edma.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_i2c.h fsl_i2c.c fsl_i2c_edma.c fsl_i2c_edma.h fsl_dspi.h fsl_dspi.c fsl_dspi_edma.h fsl_dspi_edma.c fsl_lptmr.c fsl_lptmr.h
    ../../../../../../../devices/MK64F12/cmsis_drivers/: fsl_uart_cmsis.h fsl_uart_cmsis.c fsl_i2c_cmsis.h fsl_i2c_cmsis.c fsl_dspi_cmsis.h fsl_dspi_cmsis.c
  group utilities
    ../../../../../../../devices/MK64F12/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../../devices/MK64F12/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../../devices/MK64F12/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
    ../../../../../../../middleware/issdk/drivers/systick/: systick_utils.c systick_utils.h
  group startup
    ../../../../../../../devices/MK64F12/: system_MK64F12.c system_MK64F12.h
    ../../../../../../../devices/MK64F12/arm/: startup_MK64F12.s
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_USART.h Driver_Common.h Driver_I2C.h Driver_SPI.h
  group gpio_driver
    ../../../../../../../middleware/issdk/drivers/gpio/kinetis/: gpio_driver_irq.c gpio_driver.c gpio_driver.h
    ../../../../../../../middleware/issdk/drivers/gpio/: Driver_GPIO.h
  group interfaces
    ../../../../../../../middleware/issdk/sensors/: register_io_i2c.c register_io_spi.c sensor_io_spi.c sensor_io_i2c.c register_io_i2c.h register_io_spi.h sensor_io_spi.h sensor_io_i2c.h sensor_drv.h
  group sensors
    ../../../../../../../middleware/issdk/sensors/: fxas21002.h fxos8700.h mpl3115.h fxlc95000.h fxls8471q.h fxls8962.h fxpq3115.h mag3110.h mma845x.h mma865x.h mma8491q.h mma9553.h diff_p.h
  group ads
    ../../../../../../../middleware/issdk/drivers/ads/kinetis/: auto_detection_service.c auto_detection_service.h
    ../../../../../../../middleware/issdk/drivers/ads/: auto_detection_shield.h
  group host
    ../../../../../../../middleware/issdk/sensors/: host_io_uart.c host_io_uart.h
    ../../../../../../../middleware/issdk/drivers/host/: comm_if_uart.c comm_interface.h data_format_hdlc.c data_format_hdlc.h data_format_json.c data_format_json.h data_format_service.h host_interface_service.c host_interface_service.h
target hostdemo_mult2b Release (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: hostdemo_mult2b.out
  AfterMake: fromelf.exe --m32combined  --output  "$L@L.bin"  "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MK64FN1M0VLL12, FRDM_K64F, FREEDOM, PRINTF_ADVANCED_ENABLE
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove
