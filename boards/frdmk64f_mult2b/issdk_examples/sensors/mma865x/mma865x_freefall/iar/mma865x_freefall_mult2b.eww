<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>mma865x_freefall_mult2b</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>mma865x_freefall_mult2b</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>mma865x_freefall_mult2b</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>mma865x_freefall_mult2b</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/mma865x_freefall_mult2b.ewp</path>
  </project>
</workspace>
