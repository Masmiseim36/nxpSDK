# Keil uVision project led_demo_freedom_a000.uvprojx, settings and files
target led_demo_freedom_a000 release (ARM-ADS)
  device: MK66FN2M0VMD18 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: led_demo_freedom_a000.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MK66FN2M0VMD18, CPU_IS_ARM_CORTEX_M4=1, FREEDOM, FRDM_K66F
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -Wno-null-dereference  -Wno-unknown-attributes  -Wno-expansion-to-defined  -Wno-invalid-noreturn
  c include: ..;../../../../../../middleware/mcu-boot/apps/led_demo/src;../../../../../../devices/MK66F18/drivers;../../../../../../devices/MK66F18;../../../../../../middleware/mcu-boot/src/include;../../../../../../middleware/mcu-boot/src/startup;../../../../../../CMSIS/Include
  asm define: CPU_MK66FN2M0VMI18, NDEBUG, KEIL,FRDM_K66F, FREEDOM, NDEBUG, BL_HAS_BOOTLOADER_CONFIG=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../../../middleware/mcu-boot/targets/common/linker/arm/MK66F18/MK66FN2M0xxx18_application_0xa000.scf
  link misc: --remove --keep=*(.FlashConfig) --datacompressor off
  group board
    ../: pin_mux.c pin_mux.h
  group MK66F18
    ../: main.c
    ../../../../../../middleware/mcu-boot/apps/led_demo/src/: milliseconds_delay.h milliseconds_delay.c
    ../../../../../../middleware/mcu-boot/src/utilities/src/: bootloader_tree_stub.c
  group drivers
    ../../../../../../devices/MK66F18/drivers/: fsl_port.h fsl_gpio.h fsl_gpio.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c
  group device
    ../../../../../../devices/MK66F18/: fsl_device_registers.h MK66F18.h MK66F18_features.h system_MK66F18.h system_MK66F18.c
  group startup
    ../../../../../../middleware/mcu-boot/targets/MK66F18/src/startup/arm/: startup_MK66F18.S
    ../../../../../../middleware/mcu-boot/src/startup/: startup.c
  group source/include
    ../../../../../../middleware/mcu-boot/src/include/: bootloader_core.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
