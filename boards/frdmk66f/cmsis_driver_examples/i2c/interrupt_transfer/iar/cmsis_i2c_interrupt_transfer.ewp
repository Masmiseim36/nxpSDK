# IAR project cmsis_i2c_interrupt_transfer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FN2M0xxx18 NXP MK66FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK66FN2M0VMD18; FRDM_K66F; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../devices; ..; ../../../../../../CMSIS/Driver/Include; ../../../..; ../../../../../../devices/MK66F18/drivers; ../../../../../../devices/MK66F18/cmsis_drivers; ../../../../../../devices/MK66F18/utilities; ../../../../../../devices/MK66F18
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: cmsis_i2c_interrupt_transfer.out
  ILINK.IlinkIcfFile: MK66FN2M0xxx18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK66FN2M0VMD18; FRDM_K66F; FREEDOM
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/MK66F18/iar/: startup_MK66F18.s
    ../../../../../../devices/MK66F18/: system_MK66F18.c system_MK66F18.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MK66F18/drivers/: fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_clock.h fsl_clock.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_i2c.h fsl_i2c.c fsl_i2c_edma.c fsl_i2c_edma.h fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
    ../../../../../../devices/MK66F18/cmsis_drivers/: fsl_i2c_cmsis.h fsl_i2c_cmsis.c
  group source
    ../: cmsis_i2c_interrupt_transfer.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../devices/MK66F18/utilities/: fsl_debug_console.c fsl_debug_console.h
