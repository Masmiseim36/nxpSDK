<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>ftm_pdb_adc16_peripheral</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>ftm_pdb_adc16_peripheral</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>ftm_pdb_adc16_peripheral</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>ftm_pdb_adc16_peripheral</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/ftm_pdb_adc16_peripheral.ewp</path>
  </project>
</workspace>
