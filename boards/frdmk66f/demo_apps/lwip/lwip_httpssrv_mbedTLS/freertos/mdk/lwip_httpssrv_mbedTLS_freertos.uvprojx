# Keil uVision project lwip_httpssrv_mbedTLS_freertos.uvprojx, settings and files
target lwip_httpssrv_mbedTLS_freertos Debug (ARM-ADS)
  device: MK66FN2M0VMD18 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: lwip_httpssrv_mbedTLS_freertos.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MK66FN2M0VMD18, FRDM_K66F, FREEDOM, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, HTTPSRV_CFG_WEBSOCKET_ENABLED=1, HTTPSRV_CFG_MBEDTLS_ENABLE=1, FSL_RTOS_FREE_RTOS, MBEDTLS_CONFIG_FILE='\"ksdk_mbedtls_config.h\"'
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186 
--diag_suppress=177
  c include: ../../../../../../../rtos/freertos/Source/portable/RVDS/ARM_CM4F;../../../../../../../platform/components/phyksz8081;../../../../../../../CMSIS/Include;../../../../../../../devices;..;../../../../../../../middleware/lwip/src/apps/httpsrv;../../../../..;../../../../../../../middleware/mmcau;../../../../../../../rtos/freertos/Source/include;../../../../../../../middleware/mbedtls/include;../../../../../../../middleware/mbedtls/port/ksdk;../../../../../../../devices/MK66F18/drivers;../../../../../../../devices/MK66F18;../../../../../../../devices/MK66F18/utilities/io;../../../../../../../devices/MK66F18/utilities/str;../../../../../../../devices/MK66F18/utilities/log;../../../../../../../devices/MK66F18/utilities;../../../../../../../middleware/lwip/port;../../../../../../../middleware/lwip/src;../../../../../../../middleware/lwip/src/include;../../../../../../../middleware/lwip/contrib/apps
  asm define: CPU_MK66FN2M0VMD18, DEBUG,__CC_ARM,KEIL,FRDM_K66F180M, FREEDOM, DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: ../../../../../../../middleware/mmcau/asm-cm4-cm7/lib_mmcau.lib 
--remove
  group source
    ../: lwip_httpssrv_mbedTLS_freertos.c lwipopts.h FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h fsl_phy.h fsl_phy.c
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MK66F18/drivers/: fsl_rnga.c fsl_rnga.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_flash.c fsl_flash.h fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c fsl_sim.h fsl_sim.c fsl_enet.h fsl_enet.c
  group mmcau-mmcau_include
    ../../../../../../../middleware/mmcau/: cau_api.h fsl_mmcau.h
  group mmcau-mmcau_source
    ../../../../../../../middleware/mmcau/: fsl_mmcau.c
  group startup
    ../../../../../../../devices/MK66F18/: system_MK66F18.c system_MK66F18.h
    ../../../../../../../devices/MK66F18/arm/: startup_MK66F18.s
  group utilities
    ../../../../../../../devices/MK66F18/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../../devices/MK66F18/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../../devices/MK66F18/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MK66F18/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group lwip-src-apps-httpsrv
    ../../../../../../../middleware/lwip/src/apps/httpsrv/: httpsrv.c httpsrv.h httpsrv_base64.c httpsrv_base64.h httpsrv_config.h httpsrv_fs.c httpsrv_fs.h httpsrv_fs_data.c httpsrv_port.h httpsrv_prv.h httpsrv_script.c httpsrv_script.h httpsrv_sha1.c httpsrv_sha1.h httpsrv_supp.c httpsrv_supp.h httpsrv_task.c httpsrv_tls.c httpsrv_tls.h httpsrv_utf8.c httpsrv_utf8.h httpsrv_ws.c httpsrv_ws.h httpsrv_ws_api.c httpsrv_ws_prv.h
  group lwip-port
    ../../../../../../../middleware/lwip/port/: ethernetif.c ethernetif.h sys_arch.c
  group lwip-port-arch
    ../../../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip-src-api
    ../../../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-src-core
    ../../../../../../../middleware/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip-src-core-ipv4
    ../../../../../../../middleware/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip-src-core-ipv6
    ../../../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip-src-include-lwip
    ../../../../../../../middleware/lwip/src/include/lwip/: api.h arch.h debug.h dhcp.h dns.h errno.h ethip6.h icmp6.h inet.h init.h ip_addr.h ip4_addr.h ip6.h ip6_frag.h memp.h nd6.h netdb.h netifapi.h pbuf.h sio.h sockets.h sys.h tcpip.h udp.h autoip.h def.h dhcp6.h err.h etharp.h icmp.h igmp.h inet_chksum.h ip.h ip4.h ip4_frag.h ip6_addr.h mem.h mld6.h netbuf.h netif.h opt.h raw.h snmp.h stats.h tcp.h timeouts.h
  group lwip-src-include-lwip-priv
    ../../../../../../../middleware/lwip/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h nd6_priv.h tcp_priv.h tcpip_priv.h
  group lwip-src-include-lwip-prot
    ../../../../../../../middleware/lwip/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h ethernet.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip-src-include-netif
    ../../../../../../../middleware/lwip/src/include/netif/: etharp.h ethernet.h lowpan6.h lowpan6_opts.h slipif.h
  group lwip-src-include-netif-ppp
    ../../../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap_ms.h chap-md5.h chap-new.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip-src-include-netif-ppp-polarssl
    ../../../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip-src-include-posix
    ../../../../../../../middleware/lwip/src/include/posix/: errno.h netdb.h
  group lwip-src-include-posix-sys
    ../../../../../../../middleware/lwip/src/include/posix/sys/: socket.h
  group lwip-src-netif
    ../../../../../../../middleware/lwip/src/netif/: ethernet.c lowpan6.c slipif.c
  group lwip-src-netif-ppp
    ../../../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group freertos-portable
    ../../../../../../../rtos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../../../../rtos/freertos/Source/portable/: readme.txt
    ../../../../../../../rtos/freertos/Source/portable/RVDS/ARM_CM4F/: fsl_tickless_systick.c fsl_tickless_generic.h port.c portmacro.h
  group freertos
    ../../../../../../../rtos/freertos/: FreeRTOS_for_Kinetis_SDK_v2.0.txt
  group freertos-license
    ../../../../../../../rtos/freertos/License/: license.txt
  group freertos-include
    ../../../../../../../rtos/freertos/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h stdint.readme task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
  group freertos-source
    ../../../../../../../rtos/freertos/Source/: croutine.c list.c queue.c readme.txt tasks.c timers.c event_groups.c
  group mbedTLS-mbedTLS_include
    ../../../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h ripemd160.h rsa.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedTLS-mbedTLS_source
    ../../../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedTLS-mbedTLS_port
    ../../../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c
target lwip_httpssrv_mbedTLS_freertos Release (ARM-ADS)
  device: MK66FN2M0VMD18 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: lwip_httpssrv_mbedTLS_freertos.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MK66FN2M0VMD18, FRDM_K66F, FREEDOM, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, HTTPSRV_CFG_WEBSOCKET_ENABLED=1, HTTPSRV_CFG_MBEDTLS_ENABLE=1, FSL_RTOS_FREE_RTOS, MBEDTLS_CONFIG_FILE='\"ksdk_mbedtls_config.h\"'
  c misc: as above
  c include: as above
  asm define: CPU_MK66FN2M0VMI18, NDEBUG,__CC_ARM,KEIL,FRDM_K66F, FREEDOM, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: as above
