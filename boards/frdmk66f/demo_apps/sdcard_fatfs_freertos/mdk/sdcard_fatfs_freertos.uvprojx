# Keil uVision project sdcard_fatfs_freertos.uvprojx, settings and files
target sdcard_fatfs_freertos debug (ARM-ADS)
  device: MK66FN2M0VMD18 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: sdcard_fatfs_freertos.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG, CPU_MK66FN2M0VMD18, FRDM_K66F, FREEDOM, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc --diag_suppress=1296,186
  c include: ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F;..;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../rtos/amazon-freertos/lib/include;../../../../../rtos/amazon-freertos/lib/include/private;../../../../../devices/MK66F18/drivers;../../../../../middleware/sdmmc/port;../../../../../devices/MK66F18/drivers;../../../../../middleware/sdmmc/port;../../../../../middleware/fatfs/source/fsl_sd_disk;../../../../../devices/MK66F18/drivers;../../../../../devices/MK66F18/drivers;../../../../../devices/MK66F18/drivers;../../../../../devices/MK66F18/drivers;../../../../../devices/MK66F18/drivers;../../../../../devices/MK66F18;../../../../../devices/MK66F18/utilities/str;../../../../../devices/MK66F18/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/serial_manager;../../../../../devices/MK66F18/drivers;../../../../../components/lists;../../../../../devices/MK66F18/drivers;../../../../../devices/MK66F18/drivers;../../../../../middleware/sdmmc/inc;../../../../../middleware/sdmmc/src;../../../../../middleware/fatfs/source
  asm define: CPU_MK66FN2M0VMD18, DEBUG,__CC_ARM,KEIL,FRDM_K66F180M, FREEDOM, DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: --remove --predefine="-D__stack_size__=0x1000" --predefine="-D__heap_size__=0x1000"
  group source
    ../: sdcard_fatfs_freertos.c ffconf.h FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK66F18/drivers/: fsl_sdhc.c fsl_sdhc.h fsl_sysmpu.c fsl_sysmpu.h fsl_port.h fsl_gpio.c fsl_gpio.h fsl_clock.c fsl_clock.h fsl_flash.h fsl_ftfx_adapter.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_features.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_ftfx_utilities.h fsl_common.c fsl_common.h fsl_uart.c fsl_uart.h fsl_lpuart.c fsl_lpuart.h fsl_smc.c fsl_smc.h
  group sdmmc-port
    ../../../../../middleware/sdmmc/port/: fsl_sdmmc_event.h
    ../../../../../middleware/sdmmc/port/sdhc/freertos/: fsl_sdmmc_event.c fsl_sdmmc_host.c
  group sdmmc-inc
    ../../../../../middleware/sdmmc/inc/: fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
  group sdmmc-src
    ../../../../../middleware/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group fatfs-fatfs_source
    ../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c
    ../../../../../middleware/fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group fatfs-fatfs_include
    ../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.h
    ../../../../../middleware/fatfs/source/: diskio.h ff.h integer.h
  group amazon-freertos-freertos
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos-freertos-portable
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
  group amazon-freertos-include
    ../../../../../rtos/amazon-freertos/lib/include/: FreeRTOS.h event_groups.h freertos_tasks_c_additions.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
    ../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h stack_macros.h threading_alt.h
  group device
    ../../../../../devices/MK66F18/: MK66F18.h MK66F18_features.h fsl_device_registers.h system_MK66F18.c system_MK66F18.h
  group utilities
    ../../../../../devices/MK66F18/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MK66F18/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK66F18/utilities/: fsl_assert.c
  group component-uart
    ../../../../../components/uart/: uart.h uart_adapter.c
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MK66F18/arm/: startup_MK66F18.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h
target sdcard_fatfs_freertos release (ARM-ADS)
  device: MK66FN2M0VMD18 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: sdcard_fatfs_freertos.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: NDEBUG, CPU_MK66FN2M0VMD18, FRDM_K66F, FREEDOM, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc --diag_suppress=1296,186
  c include: as above
  asm define: CPU_MK66FN2M0VMI18, NDEBUG,__CC_ARM,KEIL,FRDM_K66F, FREEDOM, NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: as above
