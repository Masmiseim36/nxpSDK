# Keil uVision project dspi_half_duplex_edma_slave.uvprojx, settings and files
target dspi_half_duplex_edma_slave Debug (ARM-ADS)
  device: MK66FN2M0VMD18 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: dspi_half_duplex_edma_slave.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MK66FN2M0VMD18, FRDM_K66F, FREEDOM, PRINTF_ADVANCED_ENABLE=1
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../../../CMSIS/Include;../../../../../../../../devices;..;../../../../../..;../../../../../../../../devices/MK66F18/drivers;../../../../../../../../devices/MK66F18;../../../../../../../../devices/MK66F18/utilities/io;../../../../../../../../devices/MK66F18/utilities/str;../../../../../../../../devices/MK66F18/utilities/log;../../../../../../../../devices/MK66F18/utilities
  asm define: CPU_MK66FN2M0VMD18, DEBUG,__CC_ARM,KEIL,FRDM_K66F180M, FREEDOM, DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: --remove
  group source
    ../: dspi_half_duplex_edma_slave.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../../devices/MK66F18/drivers/: fsl_clock.h fsl_clock.c fsl_flash.c fsl_flash.h fsl_common.h fsl_common.c fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c fsl_dspi.h fsl_dspi.c fsl_dspi_edma.h fsl_dspi_edma.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c
  group startup
    ../../../../../../../../devices/MK66F18/: system_MK66F18.c system_MK66F18.h
    ../../../../../../../../devices/MK66F18/arm/: startup_MK66F18.s
  group utilities
    ../../../../../../../../devices/MK66F18/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../../../devices/MK66F18/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../../../devices/MK66F18/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../../devices/MK66F18/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
target dspi_half_duplex_edma_slave Release (ARM-ADS)
  device: MK66FN2M0VMD18 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: dspi_half_duplex_edma_slave.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MK66FN2M0VMD18, FRDM_K66F, FREEDOM, PRINTF_ADVANCED_ENABLE=1
  c misc: as above
  c include: as above
  asm define: CPU_MK66FN2M0VMI18, NDEBUG,__CC_ARM,KEIL,FRDM_K66F, FREEDOM, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: --remove
