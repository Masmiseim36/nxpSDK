# IAR project enet_txrx_ptp1588_transfer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FN2M0xxx18 NXP MK66FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK66FN2M0VMD18; ENET_ENHANCEDBUFFERDESCRIPTOR_MODE; FRDM_K66F; FREEDOM; ENET_ENHANCEDBUFFERDESCRIPTOR_MODE=1; PRINTF_ADVANCED_ENABLE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../platform/components/phyksz8041; ../../../../../../CMSIS/Include; ../../../../../../devices; ..; ../../../..; ../../../../../../devices/MK66F18/drivers; ../../../../../../devices/MK66F18; ../../../../../../devices/MK66F18/utilities/io; ../../../../../../devices/MK66F18/utilities/str; ../../../../../../devices/MK66F18/utilities/log; ../../../../../../devices/MK66F18/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: enet_txrx_ptp1588_transfer.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1
  ILINK.IlinkIcfFile: MK66FN2M0xxx18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK66FN2M0VMD18; ENET_ENHANCEDBUFFERDESCRIPTOR_MODE; FRDM_K66F; FREEDOM; ENET_ENHANCEDBUFFERDESCRIPTOR_MODE=1; PRINTF_ADVANCED_ENABLE=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: enet_txrx_ptp1588_transfer.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h fsl_phy.h fsl_phy.c
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MK66F18/drivers/: fsl_clock.h fsl_clock.c fsl_flash.c fsl_flash.h fsl_common.h fsl_common.c fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c fsl_sysmpu.h fsl_sysmpu.c fsl_sim.h fsl_sim.c fsl_enet.h fsl_enet.c
  group startup
    ../../../../../../devices/MK66F18/: system_MK66F18.c system_MK66F18.h
    ../../../../../../devices/MK66F18/iar/: startup_MK66F18.s
  group utilities
    ../../../../../../devices/MK66F18/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../devices/MK66F18/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../devices/MK66F18/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MK66F18/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
