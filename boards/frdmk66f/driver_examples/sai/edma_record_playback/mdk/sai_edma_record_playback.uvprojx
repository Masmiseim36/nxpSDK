# Keil uVision project sai_edma_record_playback.uvprojx, settings and files
target sai_edma_record_playback debug (ARM-ADS)
  device: MK66FN2M0VMD18 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: sai_edma_record_playback.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MK66FN2M0VMD18, FRDM_K66F, FREEDOM, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_DA7212_ENABLE
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../devices/MK66F18/drivers;../../../../../../components/codec/da7212;../../../../../../components/codec;../../../../../../components/codec/port/da7212;../../../../../../components/codec/i2c;../../../../../../components/i2c;../../../../../../devices/MK66F18/utilities/debug_console_lite;../../../../../../devices/MK66F18;../../../../../../components/uart;../../../../../../components/lists;../../../../../../CMSIS/Include
  asm define: CPU_MK66FN2M0VMD18, DEBUG, KEIL, FRDM_K66F180M, FREEDOM, DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
  group source
    ../: sai_edma_record_playback.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MK66F18/drivers/: fsl_i2c.h fsl_i2c.c fsl_common.h fsl_common.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_sai.h fsl_sai.c fsl_sai_edma.h fsl_sai_edma.c fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_smc.h fsl_smc.c
  group codec
    ../../../../../../components/codec/da7212/: fsl_dialog7212.h fsl_dialog7212.c
    ../../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../../components/codec/port/da7212/: fsl_codec_adapter.c fsl_codec_adapter.h
    ../../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
  group component/i2c
    ../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_i2c.c
  group utilities
    ../../../../../../devices/MK66F18/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group device
    ../../../../../../devices/MK66F18/: fsl_device_registers.h MK66F18.h MK66F18_features.h system_MK66F18.c system_MK66F18.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MK66F18/arm/: startup_MK66F18.S
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
target sai_edma_record_playback release (ARM-ADS)
  device: MK66FN2M0VMD18 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: sai_edma_record_playback.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MK66FN2M0VMD18, FRDM_K66F, FREEDOM, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_DA7212_ENABLE
  c misc: as above
  c include: as above
  asm define: CPU_MK66FN2M0VMI18, NDEBUG, KEIL,FRDM_K66F, FREEDOM, NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
