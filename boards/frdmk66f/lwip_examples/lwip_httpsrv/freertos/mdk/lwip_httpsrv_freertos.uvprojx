# Keil uVision project lwip_httpsrv_freertos.uvprojx, settings and files
target lwip_httpsrv_freertos debug (ARM-ADS)
  device: MK66FN2M0VMD18 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: lwip_httpsrv_freertos.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MK66FN2M0VMD18, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, HTTPSRV_CFG_WEBSOCKET_ENABLED=1, FRDM_K66F, FREEDOM, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../components/phy/mdio/enet;../../../../../../components/phy/device/phyksz8081;../../../../../../middleware/lwip/src/apps/httpsrv;../../../../../../middleware/lwip/src/include/lwip/apps;../../../../../../middleware/lwip/port;../../../../../../middleware/lwip/src;../../../../../../middleware/lwip/src/include;../../../../../../devices/MK66F18/utilities/str;../../../../../../devices/MK66F18/utilities/debug_console;../../../../../../components/phy;../../../../../../devices/MK66F18/drivers;../../../../../../devices/MK66F18;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../CMSIS/Include;../../../../../../rtos/freertos/freertos_kernel/include;../../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM4F
  asm define: CPU_MK66FN2M0VMD18, DEBUG, KEIL, FRDM_K66F180M, FREEDOM, DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --predefine="-D__stack_size__=2048" --predefine="-D__heap_size__=60000"
  group source
    ../: lwip_httpsrv_freertos.c lwipopts.h FreeRTOSConfig.h httpsrv_fs_data.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group mdio
    ../../../../../../components/phy/mdio/enet/: fsl_enet_mdio.h fsl_enet_mdio.c
    ../../../../../../components/phy/: fsl_mdio.h
  group phy
    ../../../../../../components/phy/device/phyksz8081/: fsl_phyksz8081.h fsl_phyksz8081.c
    ../../../../../../components/phy/: fsl_phy.h
  group lwip/src/apps/httpsrv
    ../../../../../../middleware/lwip/src/apps/httpsrv/: httpsrv.c httpsrv.h httpsrv_base64.c httpsrv_base64.h httpsrv_config.h httpsrv_fs.c httpsrv_fs.h httpsrv_port.h httpsrv_prv.h httpsrv_script.c httpsrv_script.h httpsrv_sha1.c httpsrv_sha1.h httpsrv_supp.c httpsrv_supp.h httpsrv_task.c httpsrv_tls.c httpsrv_tls.h httpsrv_utf8.c httpsrv_utf8.h httpsrv_ws.c httpsrv_ws.h httpsrv_ws_api.c httpsrv_ws_prv.h
  group lwip/src/apps/mdns
    ../../../../../../middleware/lwip/src/apps/mdns/: mdns.c mdns_domain.c mdns_out.c
  group lwip/src/include/lwip/apps
    ../../../../../../middleware/lwip/src/include/lwip/apps/: mdns.h mdns_domain.h mdns_priv.h mdns_opts.h mdns_out.h
  group lwip/port
    ../../../../../../middleware/lwip/port/: sys_arch.c enet_ethernetif.c enet_ethernetif.h enet_ethernetif_priv.h enet_ethernetif_kinetis.c
  group lwip/port/arch
    ../../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src/api
    ../../../../../../middleware/lwip/src/api/: api_lib.c tcpip.c netdb.c sockets.c if_api.c netbuf.c netifapi.c api_msg.c err.c
  group lwip/src/core
    ../../../../../../middleware/lwip/src/core/: altcp.c sys.c stats.c def.c ip.c netif.c dns.c tcp_out.c pbuf.c timeouts.c init.c tcp_in.c altcp_tcp.c raw.c tcp.c udp.c altcp_alloc.c mem.c inet_chksum.c memp.c
  group lwip/src/core/ipv6
    ../../../../../../middleware/lwip/src/core/ipv6/: icmp6.c ethip6.c nd6.c ip6_frag.c inet6.c ip6.c dhcp6.c mld6.c ip6_addr.c
  group lwip/src/core/ipv4
    ../../../../../../middleware/lwip/src/core/ipv4/: igmp.c ip4.c dhcp.c etharp.c ip4_frag.c icmp.c autoip.c acd.c ip4_addr.c
  group lwip/src/include/compat/stdc
    ../../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/compat/posix
    ../../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/sys
    ../../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/compat/posix/net
    ../../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/lwip
    ../../../../../../middleware/lwip/src/include/lwip/: err.h sio.h ip6.h netdb.h altcp_tcp.h arch.h debug.h ip6_addr.h sockets.h if_api.h init.h tcpbase.h tcpip.h def.h inet_chksum.h snmp.h api.h ip4.h inet.h igmp.h altcp_tls.h netif.h opt.h ip.h acd.h tcp.h ip6_frag.h altcp.h ip4_addr.h ip4_frag.h netbuf.h autoip.h dns.h sys.h dhcp.h ip_addr.h icmp6.h mem.h raw.h ip6_zone.h stats.h ethip6.h icmp.h pbuf.h netifapi.h nd6.h etharp.h errno.h mld6.h timeouts.h dhcp6.h udp.h memp.h
  group lwip/src/include/lwip/priv
    ../../../../../../middleware/lwip/src/include/lwip/priv/: api_msg.h tcpip_priv.h mem_priv.h altcp_priv.h nd6_priv.h tcp_priv.h memp_std.h sockets_priv.h raw_priv.h memp_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../../middleware/lwip/src/include/lwip/prot/: ip6.h ethernet.h ip4.h igmp.h ip.h acd.h tcp.h ieee.h iana.h autoip.h dns.h dhcp.h icmp6.h icmp.h nd6.h etharp.h mld6.h dhcp6.h udp.h
  group lwip/src/include/netif
    ../../../../../../middleware/lwip/src/include/netif/: bridgeif_opts.h ethernet.h zepif.h ieee802154.h lowpan6.h lowpan6_common.h lowpan6_ble.h lowpan6_opts.h bridgeif.h slipif.h etharp.h
  group lwip/src/include/netif/ppp
    ../../../../../../middleware/lwip/src/include/netif/ppp/: eap.h pppol2tp.h chap-md5.h pppcrypt.h ppp.h upap.h pppapi.h ipv6cp.h pppdebug.h pppoe.h mppe.h pppos.h ppp_opts.h chap-new.h ipcp.h lcp.h ccp.h ppp_impl.h eui64.h vj.h ecp.h magic.h fsm.h chap_ms.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: sha1.h md5.h arc4.h md4.h des.h
  group lwip/src/netif
    ../../../../../../middleware/lwip/src/netif/: lowpan6.c lowpan6_ble.c ethernet.c lowpan6_common.c slipif.c bridgeif.c bridgeif_fdb.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../../middleware/lwip/src/netif/ppp/: utils.c pppol2tp.c chap_ms.c vj.c pppos.c lwip_ecp.c magic.c eui64.c chap-md5.c auth.c ppp.c ccp.c pppapi.c eap.c mppe.c ipv6cp.c ipcp.c lcp.c pppcrypt.c pppoe.c chap-new.c demand.c upap.c multilink.c fsm.c
  group utilities
    ../../../../../../devices/MK66F18/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MK66F18/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MK66F18/utilities/: fsl_assert.c
  group drivers
    ../../../../../../devices/MK66F18/drivers/: fsl_enet.h fsl_enet.c fsl_port.h fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_common.h fsl_common.c fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_3.c ReadMe.url
  group device
    ../../../../../../devices/MK66F18/: fsl_device_registers.h MK66F18.h MK66F18_features.h system_MK66F18.c system_MK66F18.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MK66F18/arm/: startup_MK66F18.S
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group freertos/freertos_kernel
    ../../../../../../rtos/freertos/freertos_kernel/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    ../../../../../../rtos/freertos/freertos_kernel/include/: croutine.h StackMacros.h atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos_kernel/portable/GCC/ARM_CM4F
    ../../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos/freertos_kernel/portable
    ../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
target lwip_httpsrv_freertos release (ARM-ADS)
  device: MK66FN2M0VMD18 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: lwip_httpsrv_freertos.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MK66FN2M0VMD18, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, HTTPSRV_CFG_WEBSOCKET_ENABLED=1, FRDM_K66F, FREEDOM, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: CPU_MK66FN2M0VMI18, NDEBUG, KEIL,FRDM_K66F, FREEDOM, NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: as above
