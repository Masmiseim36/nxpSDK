<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>erpc_client_matrix_multiply_spi</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>erpc_client_matrix_multiply_spi</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>erpc_client_matrix_multiply_spi</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>erpc_client_matrix_multiply_spi</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/erpc_client_matrix_multiply_spi.ewp</path>
  </project>
</workspace>
