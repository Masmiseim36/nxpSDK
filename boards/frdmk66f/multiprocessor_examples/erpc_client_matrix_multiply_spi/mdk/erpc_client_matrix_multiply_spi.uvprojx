# Keil uVision project erpc_client_matrix_multiply_spi.uvprojx, settings and files
target erpc_client_matrix_multiply_spi Debug (ARM-ADS)
  device: MK66FN2M0VMD18 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: erpc_client_matrix_multiply_spi.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MK66FN2M0VMD18, FRDM_K66F, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;..;../../erpc_common/erpc_matrix_multiply/service;../../erpc_common;../../..;../../../../../middleware/multicore/erpc/erpc_c/infra;../../../../../middleware/multicore/erpc/erpc_c/port;../../../../../middleware/multicore/erpc/erpc_c/setup;../../../../../middleware/multicore/erpc/erpc_c/transports;../../../../../devices/MK66F18/drivers;../../../../../devices/MK66F18;../../../../../devices/MK66F18/utilities/io;../../../../../devices/MK66F18/utilities/str;../../../../../devices/MK66F18/utilities/log;../../../../../devices/MK66F18/utilities
  asm define: CPU_MK66FN2M0VMD18, DEBUG,__CC_ARM,KEIL,FRDM_K66F180M, FREEDOM, DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: --remove 
--muldefweak
  group source
    ../: main_client.c erpc_config.h
  group erpc
    ../../erpc_common/: erpc_error_handler.h erpc_error_handler.cpp
  group erpc-service
    ../../erpc_common/erpc_matrix_multiply/service/: erpc_crc16.h erpc_matrix_multiply.erpc erpc_matrix_multiply.h erpc_matrix_multiply_client.cpp
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group erpc-transports
    ../../../../../middleware/multicore/erpc/erpc_c/transports/: dspi_master_transport.h dspi_master_transport.cpp
  group erpc-infra
    ../../../../../middleware/multicore/erpc/erpc_c/infra/: framed_transport.h framed_transport.cpp erpc_version.h codec.h basic_codec.h transport.h message_buffer.h message_loggers.h erpc_common.h manually_constructed.h crc16.h basic_codec.cpp message_buffer.cpp message_loggers.cpp crc16.cpp client_manager.h client_manager.cpp
  group erpc-setup
    ../../../../../middleware/multicore/erpc/erpc_c/setup/: erpc_setup_mbf_dynamic.cpp erpc_transport_setup.h erpc_mbf_setup.h erpc_setup_dspi_master.cpp erpc_client_setup.h erpc_client_setup.cpp
  group drivers
    ../../../../../devices/MK66F18/drivers/: fsl_dspi.h fsl_dspi.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_flash.c fsl_flash.h fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c
  group startup
    ../../../../../devices/MK66F18/: system_MK66F18.c system_MK66F18.h
    ../../../../../devices/MK66F18/arm/: startup_MK66F18.s
  group utilities
    ../../../../../devices/MK66F18/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MK66F18/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MK66F18/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK66F18/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group erpc-port
    ../../../../../middleware/multicore/erpc/erpc_c/port/: erpc_port.h erpc_port_stdlib.cpp erpc_config_internal.h
target erpc_client_matrix_multiply_spi Release (ARM-ADS)
  device: MK66FN2M0VMD18 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: erpc_client_matrix_multiply_spi.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MK66FN2M0VMD18, FRDM_K66F, FREEDOM
  c misc: as above
  c include: as above
  asm define: CPU_MK66FN2M0VMI18, NDEBUG,__CC_ARM,KEIL,FRDM_K66F, FREEDOM, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: --remove 
--muldefweak
