# Keil uVision project erpc_remote_control.uvprojx, settings and files
target erpc_remote_control debug (ARM-ADS)
  device: MK66FN2M0VMD18 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: erpc_remote_control.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MK66FN2M0VMD18, SDK_I2C_BASED_COMPONENT_USED=1, FRDM_K66F, FREEDOM, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../erpc_common;..;../service;../../../../../devices/MK66F18/drivers;../../../../../components/fxos8700cq;../../../../../devices/MK66F18/cmsis_drivers;../../../../../middleware/multicore/erpc/erpc_c/infra;../../../../../middleware/multicore/erpc/erpc_c/setup;../../../../../middleware/multicore/erpc/erpc_c/port;../../../../../middleware/multicore/erpc/erpc_c/transports;../../../../../devices/MK66F18;../../../../../devices/MK66F18/utilities/str;../../../../../devices/MK66F18/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../CMSIS/Include;../../../../../CMSIS/Driver/Include;../../../../../middleware/multicore/erpc/erpc_c;../../../../../rtos/freertos/freertos_kernel/include;../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM4F
  asm define: CPU_MK66FN2M0VMD18, DEBUG, KEIL, FRDM_K66F180M, FREEDOM, DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --muldefweak
  group source
    ../../erpc_common/: erpc_error_handler.h erpc_error_handler.cpp
    ../: remote_control.c FreeRTOSConfig.h erpc_config.h
  group erpc/service
    ../service/: erpc_remote_control.erpc erpc_remote_control.h erpc_remote_control_app_0.h erpc_remote_control_app_0_server.h erpc_remote_control_app_0_server.cpp erpc_remote_control_app_1.h erpc_remote_control_app_1_client.cpp
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK66F18/drivers/: fsl_edma.h fsl_edma.c fsl_uart.h fsl_uart.c fsl_uart_edma.h fsl_uart_edma.c fsl_dac.c fsl_dac.h fsl_gpio.h fsl_gpio.c fsl_port.h fsl_i2c.h fsl_i2c.c fsl_adc16.c fsl_adc16.h fsl_dmamux.h fsl_dmamux.c fsl_clock.h fsl_clock.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_smc.h fsl_smc.c
    ../../../../../devices/MK66F18/cmsis_drivers/: fsl_uart_cmsis.h fsl_uart_cmsis.c
  group accel
    ../../../../../components/fxos8700cq/: fsl_fxos.h fsl_fxos.c
  group erpc/infra
    ../../../../../middleware/multicore/erpc/erpc_c/infra/: erpc_arbitrated_client_manager.h erpc_arbitrated_client_manager.cpp erpc_client_manager.h erpc_client_manager.cpp erpc_simple_server.h erpc_simple_server.cpp erpc_server.h erpc_server.cpp erpc_transport_arbitrator.h erpc_transport_arbitrator.cpp erpc_framed_transport.h erpc_framed_transport.cpp erpc_version.h erpc_codec.h erpc_basic_codec.h erpc_transport.h erpc_message_buffer.h erpc_message_loggers.h erpc_common.h erpc_manually_constructed.h erpc_crc16.h erpc_basic_codec.cpp erpc_message_buffer.cpp erpc_message_loggers.cpp erpc_crc16.cpp erpc_client_server_common.h erpc_pre_post_action.h erpc_pre_post_action.cpp
  group erpc/setup
    ../../../../../middleware/multicore/erpc/erpc_c/setup/: erpc_arbitrated_client_setup.h erpc_arbitrated_client_setup.cpp erpc_server_setup.h erpc_server_setup.cpp erpc_setup_uart_cmsis.cpp erpc_setup_mbf_dynamic.cpp erpc_transport_setup.h erpc_mbf_setup.h
  group erpc/port
    ../../../../../middleware/multicore/erpc/erpc_c/port/: erpc_threading.h erpc_threading_freertos.cpp erpc_port.h erpc_port_freertos.cpp erpc_config_internal.h erpc_threading.h erpc_threading_freertos.cpp erpc_setup_extensions.h erpc_setup_extensions_freertos.cpp erpc_setup_extensions.h
  group erpc/transports
    ../../../../../middleware/multicore/erpc/erpc_c/transports/: erpc_uart_cmsis_transport.h erpc_uart_cmsis_transport.cpp
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group device
    ../../../../../devices/MK66F18/: fsl_device_registers.h MK66F18.h MK66F18_features.h system_MK66F18.c system_MK66F18.h
  group utilities
    ../../../../../devices/MK66F18/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK66F18/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MK66F18/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MK66F18/arm/: startup_MK66F18.S
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group CMSIS_driver
    ../../../../../CMSIS/Driver/Include/: Driver_USART.h Driver_Common.h
  group freertos/freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    ../../../../../rtos/freertos/freertos_kernel/include/: croutine.h StackMacros.h atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos_kernel/portable/GCC/ARM_CM4F
    ../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos/freertos_kernel/portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
target erpc_remote_control release (ARM-ADS)
  device: MK66FN2M0VMD18 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: erpc_remote_control.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MK66FN2M0VMD18, SDK_I2C_BASED_COMPONENT_USED=1, FRDM_K66F, FREEDOM, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: CPU_MK66FN2M0VMI18, NDEBUG, KEIL,FRDM_K66F, FREEDOM, NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --muldefweak
