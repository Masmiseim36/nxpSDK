<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>erpc_server_matrix_multiply_uart</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>erpc_server_matrix_multiply_uart</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>erpc_server_matrix_multiply_uart</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>erpc_server_matrix_multiply_uart</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/erpc_server_matrix_multiply_uart.ewp</path>
  </project>
</workspace>
