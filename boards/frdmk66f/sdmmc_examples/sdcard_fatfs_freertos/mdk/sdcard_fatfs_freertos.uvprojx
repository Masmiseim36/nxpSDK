# Keil uVision project sdcard_fatfs_freertos.uvprojx, settings and files
target sdcard_fatfs_freertos debug (ARM-ADS)
  device: MK66FN2M0VMD18 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: sdcard_fatfs_freertos.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MK66FN2M0VMD18, FRDM_K66F, FREEDOM, SD_ENABLED, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../devices/MK66F18/drivers;../../../../../middleware/sdmmc/sd;../../../../../middleware/sdmmc/common;../../../../../middleware/sdmmc/host/sdhc;../../../../../middleware/fatfs/source;../../../../../middleware/fatfs/source/fsl_sd_disk;../../../../../devices/MK66F18;../../../../../devices/MK66F18/utilities/str;../../../../../devices/MK66F18/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../CMSIS/Include;../../../../../middleware/sdmmc/osa;../../../../../components/osa;../../../../../rtos/freertos/freertos_kernel/include;../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM4F
  asm define: CPU_MK66FN2M0VMD18, DEBUG, KEIL, FRDM_K66F180M, FREEDOM, DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --predefine="-D__stack_size__=0x1000" --predefine="-D__heap_size__=0x1000"
  group source
    ../: sdcard_fatfs_freertos.c ffconf.h FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h sdmmc_config.c sdmmc_config.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK66F18/drivers/: fsl_sdhc.h fsl_sdhc.c fsl_sysmpu.h fsl_sysmpu.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_common.h fsl_common.c fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_smc.h fsl_smc.c
  group sdmmc/src
    ../../../../../middleware/sdmmc/sd/: fsl_sd.c
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc/sd/: fsl_sd.h
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sd
    ../../../../../middleware/sdmmc/sd/: ChangeLogKSDK.txt
  group sdmmc/host
    ../../../../../middleware/sdmmc/host/sdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt
    ../../../../../middleware/sdmmc/host/sdhc/non_blocking/: fsl_sdmmc_host.c
  group fatfs/source
    ../../../../../middleware/fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c diskio.h ff.h
  group fatfs/source/fsl_sd_disk
    ../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.h fsl_sd_disk.c
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group device
    ../../../../../devices/MK66F18/: fsl_device_registers.h MK66F18.h MK66F18_features.h system_MK66F18.c system_MK66F18.h
  group utilities
    ../../../../../devices/MK66F18/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK66F18/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MK66F18/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MK66F18/arm/: startup_MK66F18.S
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group sdmmc/osa
    ../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c
  group freertos/freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    ../../../../../rtos/freertos/freertos_kernel/include/: croutine.h StackMacros.h atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos_kernel/portable/GCC/ARM_CM4F
    ../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos/freertos_kernel/portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
target sdcard_fatfs_freertos release (ARM-ADS)
  device: MK66FN2M0VMD18 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: sdcard_fatfs_freertos.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MK66FN2M0VMD18, FRDM_K66F, FREEDOM, SD_ENABLED, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: CPU_MK66FN2M0VMI18, NDEBUG, KEIL,FRDM_K66F, FREEDOM, NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: as above
