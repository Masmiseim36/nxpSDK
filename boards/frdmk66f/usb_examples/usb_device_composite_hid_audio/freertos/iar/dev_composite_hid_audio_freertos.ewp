# IAR project dev_composite_hid_audio_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FN2M0xxx18 NXP MK66FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; CPU_MK66FN2M0VMD18; USB_STACK_FREERTOS_HEAP_SIZE=32768; USB_STACK_FREERTOS; FSL_RTOS_FREE_RTOS; FRDM_K66F; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F; ../../../../../../rtos/freertos_9.0.0/Source/include; ..; ../../../../../../rtos/freertos_9.0.0/Source; ../../../../../../middleware/usb_1.6.3; ../../../../../../middleware/usb_1.6.3/osa; ../../../../../../middleware/usb_1.6.3/include; ../../../../../../middleware/usb_1.6.3/device; ../../../../../../CMSIS/Include; ../../../..; ../../../../../../middleware/usb_1.6.3/phy; ../../../../../../devices/MK66F18/drivers; ../../../../../../devices/MK66F18/utilities; ../../../../../../devices/MK66F18
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../..; ..
  ILINK.IlinkOutputFile: dev_composite_hid_audio_freertos.out
  ILINK.IlinkIcfFile: MK66FN2M0xxx18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK66FN2M0VMD18; USB_STACK_FREERTOS_HEAP_SIZE=32768; USB_STACK_FREERTOS; FSL_RTOS_FREE_RTOS; FRDM_K66F; FREEDOM
  ICCARM.CCOptLevel: 3
  group freertos
    ../../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
    ../../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
    ../../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group freertos/portable
    ../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F/: port.c fsl_tickless_systick.c fsl_tickless_generic.h portasm.s portmacro.h
  group startup
    ../../../../../../devices/MK66F18/iar/: startup_MK66F18.s
    ../../../../../../devices/MK66F18/: system_MK66F18.c system_MK66F18.h
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb_1.6.3/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/khci
    ../../../../../../middleware/usb_1.6.3/device/: usb_device_khci.c usb_device_khci.h
    ../../../../../../middleware/usb_1.6.3/include/: usb_khci.h
  group usb/device/source/ehci
    ../../../../../../middleware/usb_1.6.3/device/: usb_device_ehci.c usb_device_ehci.h
    ../../../../../../middleware/usb_1.6.3/include/: usb_ehci.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/audio
    ../: usb_device_audio.c usb_device_audio.h
  group usb/device/class/hid
    ../: usb_device_hid.c usb_device_hid.h
  group usb/device/include
    ../../../../../../middleware/usb_1.6.3/device/: usb_device.h
  group usb/phy
    ../../../../../../middleware/usb_1.6.3/phy/: usb_phy.c usb_phy.h
  group usb/include
    ../../../../../../middleware/usb_1.6.3/include/: usb.h usb_misc.h usb_spec.h
  group drivers
    ../../../../../../devices/MK66F18/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c fsl_port.h fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_sysmpu.h fsl_sysmpu.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group osa
    ../../../../../../middleware/usb_1.6.3/osa/: usb_osa.h usb_osa_freertos.h usb_osa_freertos.c
  group sources
    ../: audio_data.c audio_generator.c audio_generator.h composite.c composite.h mouse.c mouse.h usb_device_descriptor.c usb_device_descriptor.h usb_device_config.h FreeRTOSConfig.h usb_audio_config.h
  group utilities
    ../../../../../../devices/MK66F18/utilities/: fsl_debug_console.c fsl_debug_console.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
