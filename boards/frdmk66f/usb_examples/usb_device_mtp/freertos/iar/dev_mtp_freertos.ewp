# IAR project dev_mtp_freertos.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FN2M0xxx18 NXP MK66FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; DEBUG; CPU_MK66FN2M0VMD18; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; USB_STACK_FREERTOS_HEAP_SIZE=20480; USB_STACK_FREERTOS; SD_ENABLED; FSL_RTOS_FREE_RTOS; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SERIAL_PORT_TYPE_UART=1; SDK_DEBUGCONSOLE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../..; ..; ../../../../../../middleware/usb/device; ../../../../../../middleware/usb/include; ../../../../../../devices/MK66F18/drivers; ../../../../../../middleware/sdmmc/sd; ../../../../../../middleware/sdmmc/common; ../../../../../../middleware/sdmmc/host/sdhc; ../../../../../../middleware/fatfs/source; ../../../../../../middleware/fatfs/source/fsl_sd_disk; ../../../../../../rtos/freertos/freertos_kernel/include; ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F; ../../../../../../devices/MK66F18; ../../../../../../devices/MK66F18/utilities/str; ../../../../../../devices/MK66F18/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../components/osa; ../../../../../../CMSIS/Include; ../../../../../../middleware/sdmmc/osa; ../../../../../../middleware/usb/phy
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../../../..
  ILINK.IlinkOutputFile: dev_mtp_freertos.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x100
  ILINK.IlinkIcfFile: MK66FN2M0xxx18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; NDEBUG; CPU_MK66FN2M0VMD18; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; USB_STACK_FREERTOS_HEAP_SIZE=20480; USB_STACK_FREERTOS; SD_ENABLED; FSL_RTOS_FREE_RTOS; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SERIAL_PORT_TYPE_UART=1; SDK_DEBUGCONSOLE=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../../../../: sdmmc_config.c sdmmc_config.h
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group source
    ../: ffconf.h mtp.c mtp.h mtp_operation.c mtp_operation.h mtp_file_system_adapter.c mtp_file_system_adapter.h mtp_object_handle.c mtp_object_handle.h usb_device_descriptor.c usb_device_descriptor.h usb_device_config.h FreeRTOSConfig.h
  group doc
    ../: readme.txt
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h usb_device_dci.h
  group usb/device/source/khci
    ../../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
  group usb/device/source/ehci
    ../../../../../../middleware/usb/device/: usb_device_ehci.c usb_device_ehci.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/mtp
    ../: usb_device_mtp.c usb_device_mtp.h usb_device_mtp_operation.c usb_device_mtp_operation.h
  group usb/device/include
    ../../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb.h usb_misc.h usb_spec.h
  group usb/phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group drivers
    ../../../../../../devices/MK66F18/drivers/: fsl_sdhc.h fsl_sdhc.c fsl_smc.h fsl_smc.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c fsl_gpio.h fsl_gpio.c fsl_sysmpu.h fsl_sysmpu.c fsl_port.h
  group sdmmc/src
    ../../../../../../middleware/sdmmc/sd/: fsl_sd.c
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../../middleware/sdmmc/sd/: fsl_sd.h
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sd
    ../../../../../../middleware/sdmmc/sd/: ChangeLogKSDK.txt
  group sdmmc/host
    ../../../../../../middleware/sdmmc/host/sdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt
    ../../../../../../middleware/sdmmc/host/sdhc/non_blocking/: fsl_sdmmc_host.c
  group sdmmc/osa
    ../../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group fatfs/source
    ../../../../../../middleware/fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c diskio.h ff.h
  group fatfs/source/fsl_sd_disk
    ../../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.h fsl_sd_disk.c
  group freertos/freertos_kernel
    ../../../../../../rtos/freertos/freertos_kernel/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/include
    ../../../../../../rtos/freertos/freertos_kernel/include/: croutine.h StackMacros.h atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group device
    ../../../../../../devices/MK66F18/: fsl_device_registers.h MK66F18.h MK66F18_features.h system_MK66F18.c system_MK66F18.h
  group startup
    ../../../../../../devices/MK66F18/iar/: startup_MK66F18.s
  group utilities
    ../../../../../../devices/MK66F18/utilities/: fsl_assert.c
    ../../../../../../devices/MK66F18/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MK66F18/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
