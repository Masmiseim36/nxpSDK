# IAR project pin_detect_hid_msd_bm.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FN2M0xxx18 NXP MK66FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK66FN2M0VMD18; USB_STACK_BM; SDK_DEBUGCONSOLE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../middleware/usb/host; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/device; ../../../../../../middleware/usb/phy; ../../../../../../devices/MK66F18/utilities/debug_console_lite; ../../../../../../middleware/fatfs/source; ../../../../../../middleware/fatfs/source/fsl_usb_disk; ../../../../../../devices/MK66F18/drivers; ../../../../../../devices/MK66F18; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../../../middleware/usb/host/class; ../../../../../../components/osa; ../../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: pin_detect_hid_msd_bm.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000
  ILINK.IlinkIcfFile: MK66FN2M0xxx18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK66FN2M0VMD18; USB_STACK_BM; SDK_DEBUGCONSOLE=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: app.c app.h device_mouse.c device_mouse.h host_msd_fatfs.c host_msd_fatfs.h ffconf.h usb_device_descriptor.c usb_device_descriptor.h usb_host_config.h usb_device_config.h host_app.c host_app.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group usb/host
    ../../../../../../middleware/usb/host/: usb_host_khci.c usb_host_khci.h usb_host_ehci.c usb_host_ehci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c usb_host.h usb_host_hci.h usb_host_devices.h usb_host_framework.h
  group usb/host/class
    ../../../../../../middleware/usb/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_msd.c usb_host_msd.h usb_host_msd_ufi.c
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h usb_device_dci.h
  group usb/device/source/khci
    ../../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
  group usb/device/source/ehci
    ../../../../../../middleware/usb/device/: usb_device_ehci.c usb_device_ehci.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/hid
    ../: usb_device_hid.c usb_device_hid.h
  group usb/device/include
    ../../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb.h usb_misc.h usb_spec.h
  group usb/phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group utilities
    ../../../../../../devices/MK66F18/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group fatfs/source
    ../../../../../../middleware/fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c diskio.h ff.h
  group fatfs/source/fsl_usb_disk
    ../../../../../../middleware/fatfs/source/fsl_usb_disk/: fsl_usb_disk.h fsl_usb_disk_bm.c
  group drivers
    ../../../../../../devices/MK66F18/drivers/: fsl_smc.h fsl_smc.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c fsl_gpio.h fsl_gpio.c fsl_sysmpu.h fsl_sysmpu.c fsl_port.h
  group device
    ../../../../../../devices/MK66F18/: fsl_device_registers.h MK66F18.h MK66F18_features.h system_MK66F18.c system_MK66F18.h
  group startup
    ../../../../../../devices/MK66F18/iar/: startup_MK66F18.s
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
