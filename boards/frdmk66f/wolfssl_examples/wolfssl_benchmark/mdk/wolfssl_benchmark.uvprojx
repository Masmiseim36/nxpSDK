# Keil uVision project wolfssl_benchmark.uvprojx, settings and files
target wolfssl_benchmark debug (ARM-ADS)
  device: MK66FN2M0VMD18 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: wolfssl_benchmark.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG, CPU_MK66FN2M0VMD18, PRINTF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, FREESCALE_KSDK_BM, WOLFSSL_USER_SETTINGS, FRDM_K66F, FREEDOM
  c misc: --library_interface=armcc 
--diag_suppress=1296,186 
--diag_suppress=177,1293
  c include: ..;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../middleware/mmcau;../../../../../middleware/wolfssl;../../../../../middleware/wolfssl/wolfssl/wolfcrypt/port;../../../../../devices/MK66F18/drivers;../../../../../devices/MK66F18/drivers;../../../../../devices/MK66F18/drivers;../../../../../devices/MK66F18/drivers;../../../../../devices/MK66F18/drivers;../../../../../devices/MK66F18;../../../../../devices/MK66F18/utilities/str;../../../../../devices/MK66F18/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/serial_manager;../../../../../devices/MK66F18/drivers;../../../../../components/lists;../../../../../devices/MK66F18/drivers;../../../../../devices/MK66F18/drivers;../../../../../devices/MK66F18/drivers
  asm define: CPU_MK66FN2M0VMD18, DEBUG,__CC_ARM,KEIL,FRDM_K66F180M, FREEDOM, DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: ../../../../../middleware/mmcau/asm-cm4-cm7/lib_mmcau.lib 
--remove 
--predefine="-D__stack_size__=25000" 
--predefine="-D__heap_size__=40000"
  group source
    ../: wolfssl_benchmark.c user_settings.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK66F18/drivers/: fsl_rnga.c fsl_rnga.h fsl_port.h fsl_clock.h fsl_clock.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_common.h fsl_common.c fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c
  group mmcau-mmcau_include
    ../../../../../middleware/mmcau/: cau_api.h fsl_mmcau.h
  group mmcau-mmcau_source
    ../../../../../middleware/mmcau/: fsl_mmcau.c
  group wolfssl-wolfssl_include
    ../../../../../middleware/wolfssl/wolfssl/: callbacks.h certs_test.h crl.h error-ssl.h internal.h ocsp.h options.h sniffer.h sniffer_error.h ssl.h test.h version.h
    ../../../../../middleware/wolfssl/wolfssl/openssl/: ec.h ssl.h bn.h
    ../../../../../middleware/wolfssl/wolfssl/wolfcrypt/: aes.h arc4.h asn.h asn_public.h blake2.h blake2-impl.h blake2-int.h camellia.h cmac.h chacha.h chacha20_poly1305.h coding.h compress.h curve25519.h des3.h dh.h dsa.h ecc.h ed25519.h error-crypt.h fe_operations.h fips_test.h ge_operations.h hash.h hc128.h hmac.h integer.h idea.h logging.h md2.h md4.h md5.h mem_track.h memory.h misc.h mpi_class.h mpi_superclass.h pkcs7.h poly1305.h pwdbased.h rabbit.h random.h ripemd.h rsa.h settings.h sha.h sha256.h sha512.h signature.h srp.h tfm.h types.h visibility.h wc_encrypt.h wc_port.h
  group wolfssl-wolfssl_source
    ../../../../../middleware/wolfssl/wolfcrypt/src/: aes.c arc4.c asm.c asn.c blake2b.c camellia.c cmac.c chacha.c chacha20_poly1305.c coding.c compress.c curve25519.c des3.c dh.c dsa.c ecc.c ecc_fp.c ed25519.c error.c fe_low_mem.c fe_operations.c ge_low_mem.c ge_operations.c hash.c hc128.c hmac.c integer.c idea.c logging.c md2.c md4.c md5.c memory.c misc.c pkcs7.c poly1305.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha512.c signature.c srp.c tfm.c wc_encrypt.c wc_port.c
    ../../../../../middleware/wolfssl/src/: async.c crl.c internal.c io.c keys.c ocsp.c sniffer.c ssl.c tls.c
  group wolfssl-wolfssl_port
    ../../../../../middleware/wolfssl/wolfcrypt/src/port/nxp/: ksdk_port.c
    ../../../../../middleware/wolfssl/wolfssl/wolfcrypt/port/nxp/: ksdk_port.h
  group device
    ../../../../../devices/MK66F18/: fsl_device_registers.h MK66F18.h MK66F18_features.h system_MK66F18.c system_MK66F18.h
  group utilities
    ../../../../../devices/MK66F18/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK66F18/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MK66F18/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: uart.h uart_adapter.c
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: generic_list.h generic_list.c
  group startup
    ../../../../../devices/MK66F18/arm/: startup_MK66F18.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
target wolfssl_benchmark release (ARM-ADS)
  device: MK66FN2M0VMD18 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: wolfssl_benchmark.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: NDEBUG, CPU_MK66FN2M0VMD18, PRINTF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, FREESCALE_KSDK_BM, WOLFSSL_USER_SETTINGS, FRDM_K66F, FREEDOM
  c misc: as above
  c include: as above
  asm define: CPU_MK66FN2M0VMI18, NDEBUG,__CC_ARM,KEIL,FRDM_K66F, FREEDOM, NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: as above
