# IAR project cmsis_spi_interrupt_b2b_transfer_master.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: MKE04Z8xxx4 NXP MKE04Z8xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CPU_MKE04Z8VFK4; FRDM_KE04Z; FREEDOM; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../../devices/MKE04Z4/utilities/debug_console_lite; ../../../../../../../devices/MKE04Z4/drivers; ../../../../../../../devices/MKE04Z4/cmsis_drivers; ../../../../../../../devices/MKE04Z4; ../../../../../../../components/uart; ../../../../../../../components/lists; ../../../../../../../CMSIS/Core/Include; ../../../../../../../CMSIS/Driver/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG
  ILINK.IlinkOutputFile: cmsis_spi_interrupt_b2b_transfer_master.out
  ILINK.IlinkIcfFile: MKE04Z8xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group source
    ../: cmsis_spi_interrupt_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../../../devices/MKE04Z4/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../../devices/MKE04Z4/drivers/: fsl_clock.h fsl_clock.c fsl_spi.h fsl_spi.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_uart.h fsl_uart.c fsl_port.h fsl_port.c fsl_gpio.h fsl_gpio.c
    ../../../../../../../devices/MKE04Z4/cmsis_drivers/: fsl_spi_cmsis.h fsl_spi_cmsis.c
  group device
    ../../../../../../../devices/MKE04Z4/: fsl_device_registers.h MKE04Z4.h MKE04Z4_features.h system_MKE04Z4.c system_MKE04Z4.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../../devices/MKE04Z4/iar/: startup_MKE04Z4.s
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h mpu_armv7.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_SPI.h Driver_Common.h
