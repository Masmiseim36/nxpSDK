# Keil uVision project spi_interrupt_b2b_transfer_master.uvprojx, settings and files
target spi_interrupt_b2b_transfer_master debug (ARM-ADS)
  device: MKE04Z8VFK4 NXP
  pack: Keil.Kinetis_KExx_DFP.1.8.0-dev1
  cpu: CPUTYPE("Cortex-M0+")
  output: spi_interrupt_b2b_transfer_master.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MKE04Z8VFK4, DEBUG_CONSOLE_ASSERT_DISABLE=1, FRDM_KE04Z, FREEDOM, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../../devices/MKE04Z4/utilities/debug_console_lite;../../../../../../../devices/MKE04Z4/drivers;../../../../../../../devices/MKE04Z4;../../../../../../../components/uart;../../../../../../../components/lists;../../../../../../../CMSIS/Core/Include
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x1fffff00 size 0x400
  scatter file: MKE04Z8xxx4_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --entry=Reset_Handler
  group source
    ../: spi_interrupt_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../../../devices/MKE04Z4/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../../devices/MKE04Z4/drivers/: fsl_spi.h fsl_spi.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_uart.h fsl_uart.c fsl_port.h fsl_port.c fsl_gpio.h fsl_gpio.c
  group device
    ../../../../../../../devices/MKE04Z4/: fsl_device_registers.h MKE04Z4.h MKE04Z4_features.h system_MKE04Z4.c system_MKE04Z4.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../../devices/MKE04Z4/arm/: startup_MKE04Z4.S
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h mpu_armv7.h
target spi_interrupt_b2b_transfer_master release (ARM-ADS)
  device: MKE04Z8VFK4 NXP
  pack: Keil.Kinetis_KExx_DFP.1.8.0-dev1
  cpu: CPUTYPE("Cortex-M0+")
  output: spi_interrupt_b2b_transfer_master.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MKE04Z8VFK4, DEBUG_CONSOLE_ASSERT_DISABLE=1, FRDM_KE04Z, FREEDOM, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x1fffff00 size 0x400
  scatter file: MKE04Z8xxx4_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --entry=Reset_Handler
