# Keil uVision project rtc_func.uvprojx, settings and files
target rtc_func debug (ARM-ADS)
  device: MKE15Z256VLL7 NXP
  pack: Keil.Kinetis_KExx_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M0+")
  output: rtc_func.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_MKE15Z256VLL7, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1, DEBUG_CONSOLE_PRINTF_MAX_LOG_LEN=200, FRDM_KE15Z, FREEDOM, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../devices/MKE15Z7/drivers;../../../../../devices/MKE15Z7;../../../../../devices/MKE15Z7/utilities/str;../../../../../devices/MKE15Z7/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../CMSIS/Core/Include
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: MKE15Z256xxx7_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --entry=Reset_Handler
  group source
    ../: rtc_func.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKE15Z7/drivers/: fsl_rtc.c fsl_rtc.h fsl_port.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_smc.h fsl_smc.c
  group device
    ../../../../../devices/MKE15Z7/: fsl_device_registers.h MKE15Z7.h MKE15Z7_features.h system_MKE15Z7.c system_MKE15Z7.h
  group utilities
    ../../../../../devices/MKE15Z7/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MKE15Z7/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MKE15Z7/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MKE15Z7/arm/: startup_MKE15Z7.S
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h mpu_armv7.h
target rtc_func release (ARM-ADS)
  device: MKE15Z256VLL7 NXP
  pack: Keil.Kinetis_KExx_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M0+")
  output: rtc_func.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_MKE15Z256VLL7, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1, DEBUG_CONSOLE_PRINTF_MAX_LOG_LEN=200, FRDM_KE15Z, FREEDOM, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: MKE15Z256xxx7_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --entry=Reset_Handler
