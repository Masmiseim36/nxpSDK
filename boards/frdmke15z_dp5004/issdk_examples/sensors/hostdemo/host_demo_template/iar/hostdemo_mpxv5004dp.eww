<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>hostdemo_mpxv5004dp</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>hostdemo_mpxv5004dp</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>hostdemo_mpxv5004dp</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>hostdemo_mpxv5004dp</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/hostdemo_mpxv5004dp.ewp</path>
  </project>
</workspace>
