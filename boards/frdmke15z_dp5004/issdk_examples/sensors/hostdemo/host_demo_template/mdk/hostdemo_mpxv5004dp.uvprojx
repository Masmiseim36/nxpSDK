# Keil uVision project hostdemo_mpxv5004dp.uvprojx, settings and files
target hostdemo_mpxv5004dp debug (ARM-ADS)
  device: MKE15Z256VLL7 NXP
  pack: Keil.Kinetis_KExx_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M0+")
  output: hostdemo_mpxv5004dp.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_MKE15Z256VLL7, FRDM_KE15Z, FREEDOM, PRINTF_ADVANCED_ENABLE, PRINTF_FLOAT_ENABLE, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../..;..;../../../../../../../middleware/issdk/drivers/gpio/kinetis;../../../../../../../middleware/issdk/drivers/gpio;../../../../../../../devices/MKE15Z7/drivers;../../../../../../../devices/MKE15Z7/cmsis_drivers;../../../../../../../middleware/issdk/drivers/systick;../../../../../../../middleware/issdk/sensors;../../../../../../../middleware/issdk/drivers/ads/kinetis;../../../../../../../middleware/issdk/drivers/ads;../../../../../../../middleware/issdk/drivers/host;../../../../../../../devices/MKE15Z7;../../../../../../../devices/MKE15Z7/utilities/str;../../../../../../../devices/MKE15Z7/utilities/debug_console;../../../../../../../components/uart;../../../../../../../components/serial_manager;../../../../../../../components/lists;../../../../../../../CMSIS/Core/Include;../../../../../../../CMSIS/Driver/Include
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: MKE15Z256xxx7_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --entry=Reset_Handler
  group board
    ../../../../../: frdm_ke15z.c frdm_ke15z.h frdm-stbc-dp5004_shield.h issdk_hal.h RTE_Device.h
    ../: pin_mux.c pin_mux.h clock_config.c clock_config.h board.c board.h
  group source
    ../: host_demo.c
  group doc
    ../: readme.txt readme.txt
  group gpio_driver
    ../../../../../../../middleware/issdk/drivers/gpio/kinetis/: gpio_driver_irq_ke15z.c gpio_driver.c gpio_driver.h
    ../../../../../../../middleware/issdk/drivers/gpio/: Driver_GPIO.h
  group drivers
    ../../../../../../../devices/MKE15Z7/drivers/: fsl_port.h fsl_adc12.c fsl_adc12.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.h fsl_lpspi_edma.c fsl_lpuart.h fsl_lpuart.c fsl_lpuart_edma.h fsl_lpuart_edma.c fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_trgmux.h fsl_trgmux.c fsl_lptmr.c fsl_lptmr.h fsl_clock.h fsl_clock.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c
    ../../../../../../../devices/MKE15Z7/cmsis_drivers/: fsl_lpi2c_cmsis.h fsl_lpi2c_cmsis.c fsl_lpspi_cmsis.h fsl_lpspi_cmsis.c fsl_lpuart_cmsis.h fsl_lpuart_cmsis.c
  group utilities
    ../../../../../../../middleware/issdk/drivers/systick/: systick_utils.c systick_utils.h
    ../../../../../../../devices/MKE15Z7/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MKE15Z7/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/MKE15Z7/utilities/: fsl_assert.c
  group interfaces
    ../../../../../../../middleware/issdk/sensors/: register_io_i2c.c register_io_spi.c sensor_io_spi.c sensor_io_i2c.c register_io_i2c.h register_io_spi.h sensor_io_spi.h sensor_io_i2c.h sensor_drv.h
  group sensors
    ../../../../../../../middleware/issdk/sensors/: fxas21002.h fxos8700.h mpl3115.h fxlc95000.h fxls8471q.h fxls8962.h fxpq3115.h mag3110.h mma845x.h mma865x.h mma8491q.h mma9553.h diff_p.h dbap.h
  group ads
    ../../../../../../../middleware/issdk/drivers/ads/kinetis/: auto_detection_service.c auto_detection_service.h
    ../../../../../../../middleware/issdk/drivers/ads/: auto_detection_shield.h
  group host
    ../../../../../../../middleware/issdk/sensors/: host_io_uart.c host_io_uart.h
    ../../../../../../../middleware/issdk/drivers/host/: comm_if_uart.c comm_interface.h data_format_hdlc.c data_format_hdlc.h data_format_json.c data_format_json.h data_format_service.h host_interface_service.c host_interface_service.h
  group device
    ../../../../../../../devices/MKE15Z7/: fsl_device_registers.h MKE15Z7.h MKE15Z7_features.h system_MKE15Z7.c system_MKE15Z7.h
  group startup
    ../../../../../../../devices/MKE15Z7/arm/: startup_MKE15Z7.S
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h mpu_armv7.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_I2C.h Driver_Common.h Driver_SPI.h Driver_USART.h
target hostdemo_mpxv5004dp release (ARM-ADS)
  device: MKE15Z256VLL7 NXP
  pack: Keil.Kinetis_KExx_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M0+")
  output: hostdemo_mpxv5004dp.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_MKE15Z256VLL7, FRDM_KE15Z, FREEDOM, PRINTF_ADVANCED_ENABLE, PRINTF_FLOAT_ENABLE, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: MKE15Z256xxx7_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --entry=Reset_Handler
