<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>mpxv5004dp_interrupt</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>mpxv5004dp_interrupt</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>mpxv5004dp_interrupt</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>mpxv5004dp_interrupt</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/mpxv5004dp_interrupt.ewp</path>
  </project>
</workspace>
