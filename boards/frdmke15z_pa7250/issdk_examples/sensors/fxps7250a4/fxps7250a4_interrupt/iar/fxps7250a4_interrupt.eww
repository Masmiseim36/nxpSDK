<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>fxps7250a4_interrupt</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>fxps7250a4_interrupt</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>fxps7250a4_interrupt</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>fxps7250a4_interrupt</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/fxps7250a4_interrupt.ewp</path>
  </project>
</workspace>
