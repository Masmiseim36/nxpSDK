# IAR project fxps7250d4_app.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKE15Z256xxx7 NXP MKE15Z256xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKE15Z256VLL7; FRDM_KE15Z; FREEDOM; PRINTF_ADVANCED_ENABLE; PRINTF_FLOAT_ENABLE; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../..; ..; ../../../../../../../middleware/issdk/drivers/gpio/kinetis; ../../../../../../../middleware/issdk/drivers/gpio; ../../../../../../../devices/MKE15Z7/drivers; ../../../../../../../devices/MKE15Z7/cmsis_drivers; ../../../../../../../middleware/issdk/drivers/systick; ../../../../../../../middleware/issdk/sensors; ../../../../../../../devices/MKE15Z7; ../../../../../../../devices/MKE15Z7/utilities/str; ../../../../../../../devices/MKE15Z7/utilities/debug_console; ../../../../../../../components/uart; ../../../../../../../components/serial_manager; ../../../../../../../components/lists; ../../../../../../../CMSIS/Core/Include; ../../../../../../../CMSIS/Driver/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: KE15Z-PD7250-APP.bin
  ILINK.IlinkOutputFile: fxps7250d4_app.out
  ILINK.IlinkIcfFile: MKE15Z256xxx7_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKE15Z256VLL7; FRDM_KE15Z; FREEDOM; PRINTF_ADVANCED_ENABLE; PRINTF_FLOAT_ENABLE; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group board
    ../../../../../: frdm_ke15z.c frdm_ke15z.h frdm-stba-pd7250_shield.h issdk_hal.h RTE_Device.h
    ../: pin_mux.c pin_mux.h clock_config.c clock_config.h board.c board.h
  group source
    ../: dbap_app.c
  group doc
    ../: readme.txt readme.txt
  group gpio_driver
    ../../../../../../../middleware/issdk/drivers/gpio/kinetis/: gpio_driver_irq_ke15z.c gpio_driver.c gpio_driver.h
    ../../../../../../../middleware/issdk/drivers/gpio/: Driver_GPIO.h
  group drivers
    ../../../../../../../devices/MKE15Z7/drivers/: fsl_port.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.h fsl_lpspi_edma.c fsl_lpuart.h fsl_lpuart.c fsl_lpuart_edma.h fsl_lpuart_edma.c fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_trgmux.h fsl_trgmux.c fsl_lptmr.c fsl_lptmr.h fsl_clock.h fsl_clock.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c
    ../../../../../../../devices/MKE15Z7/cmsis_drivers/: fsl_lpi2c_cmsis.h fsl_lpi2c_cmsis.c fsl_lpspi_cmsis.h fsl_lpspi_cmsis.c fsl_lpuart_cmsis.h fsl_lpuart_cmsis.c
  group utilities
    ../../../../../../../middleware/issdk/drivers/systick/: systick_utils.c systick_utils.h
    ../../../../../../../devices/MKE15Z7/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MKE15Z7/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/MKE15Z7/utilities/: fsl_assert.c
  group interfaces
    ../../../../../../../middleware/issdk/sensors/: register_io_i2c.c register_io_spi.c sensor_io_spi.c sensor_io_i2c.c register_io_i2c.h register_io_spi.h sensor_io_spi.h sensor_io_i2c.h sensor_drv.h
  group sensors
    ../../../../../../../middleware/issdk/sensors/: dbap.h dbap_drv.h dbap_drv.c
  group device
    ../../../../../../../devices/MKE15Z7/: fsl_device_registers.h MKE15Z7.h MKE15Z7_features.h system_MKE15Z7.c system_MKE15Z7.h
  group startup
    ../../../../../../../devices/MKE15Z7/iar/: startup_MKE15Z7.s
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h mpu_armv7.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_I2C.h Driver_Common.h Driver_SPI.h Driver_USART.h
