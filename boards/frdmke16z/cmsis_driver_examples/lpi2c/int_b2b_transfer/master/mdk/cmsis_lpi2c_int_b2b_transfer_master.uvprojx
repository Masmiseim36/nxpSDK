# Keil uVision project cmsis_lpi2c_int_b2b_transfer_master.uvprojx, settings and files
target cmsis_lpi2c_int_b2b_transfer_master debug (ARM-ADS)
  device: MKE16Z64VLF4 NXP
  pack: NXP.MKE16Z4_DFP.10.0.0
  cpu: CPUTYPE("Cortex-M0+")
  output: cmsis_lpi2c_int_b2b_transfer_master.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_MKE16Z64VLF4, FRDM_KE16Z, FREEDOM, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../../devices/MKE16Z4/utilities/debug_console_lite;../../../../../../../devices/MKE16Z4/drivers;../../../../../../../devices/MKE16Z4/cmsis_drivers;../../../../../../../devices/MKE16Z4;../../../../../../../components/uart;../../../../../../../components/lists;../../../../../../../CMSIS/Core/Include;../../../../../../../CMSIS/Driver/Include
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff800 size 0x2000
  scatter file: MKE16Z64xxx4_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --entry=Reset_Handler
  group source
    ../: cmsis_lpi2c_int_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../../../devices/MKE16Z4/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../../devices/MKE16Z4/drivers/: fsl_port.h fsl_clock.h fsl_clock.c fsl_lpi2c.c fsl_lpi2c.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c
    ../../../../../../../devices/MKE16Z4/cmsis_drivers/: fsl_lpi2c_cmsis.h fsl_lpi2c_cmsis.c
  group device
    ../../../../../../../devices/MKE16Z4/: fsl_device_registers.h MKE16Z4.h MKE16Z4_features.h system_MKE16Z4.c system_MKE16Z4.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../../devices/MKE16Z4/arm/: startup_MKE16Z4.S
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h mpu_armv7.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_I2C.h Driver_Common.h
target cmsis_lpi2c_int_b2b_transfer_master release (ARM-ADS)
  device: MKE16Z64VLF4 NXP
  pack: NXP.MKE16Z4_DFP.10.0.0
  cpu: CPUTYPE("Cortex-M0+")
  output: cmsis_lpi2c_int_b2b_transfer_master.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_MKE16Z64VLF4, FRDM_KE16Z, FREEDOM, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff800 size 0x2000
  scatter file: MKE16Z64xxx4_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --entry=Reset_Handler
