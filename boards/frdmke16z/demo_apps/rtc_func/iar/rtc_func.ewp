# IAR project rtc_func.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKE16Z64xxx4 NXP MKE16Z64xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKE16Z64VLF4; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; DEBUG_CONSOLE_PRINTF_MAX_LOG_LEN=200; FRDM_KE16Z; FREEDOM; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../devices/MKE16Z4/drivers; ../../../../../devices/MKE16Z4; ../../../../../devices/MKE16Z4/utilities/str; ../../../../../devices/MKE16Z4/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: rtc_func.out
  ILINK.IlinkIcfFile: MKE16Z64xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKE16Z64VLF4; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; DEBUG_CONSOLE_PRINTF_MAX_LOG_LEN=200; FRDM_KE16Z; FREEDOM; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: rtc_func.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKE16Z4/drivers/: fsl_rtc.c fsl_rtc.h fsl_port.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_smc.h fsl_smc.c
  group device
    ../../../../../devices/MKE16Z4/: fsl_device_registers.h MKE16Z4.h MKE16Z4_features.h system_MKE16Z4.c system_MKE16Z4.h
  group utilities
    ../../../../../devices/MKE16Z4/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MKE16Z4/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MKE16Z4/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MKE16Z4/iar/: startup_MKE16Z4.s
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h mpu_armv7.h
