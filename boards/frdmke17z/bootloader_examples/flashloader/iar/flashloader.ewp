# IAR project flashloader.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKE17Z256xxx7 NXP MKE17Z256xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKE17Z256VLL7; CPU_IS_ARM_CORTEX_M0P=1; BL_TARGET_RAM; FRDM_KE17Z7; FSL_OSA_BM_TIMER_CONFIG=FSL_OSA_BM_TIMER_NONE
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050,Pe1105,Pe1305,Pa182
  ICCARM.CCIncludePath2: ..; ../../../../../devices/MKE17Z7/drivers; ../../../../../devices/MKE17Z7; ../../../../../middleware/mcu-boot/src/autobaud; ../../../../../middleware/mcu-boot/src/bootloader; ../../../../../middleware/mcu-boot/src/crc; ../../../../../middleware/mcu-boot/src/include; ../../../../../middleware/mcu-boot/src/memory; ../../../../../middleware/mcu-boot/src/memory/src; ../../../../../middleware/mcu-boot/src/startup; ../../../../../middleware/mcu-boot/src/packet; ../../../../../middleware/mcu-boot/src/property; ../../../../../middleware/mcu-boot/src/sbloader; ../../../../../middleware/mcu-boot/src/utilities; ../../../../../middleware/mcu-boot/src/drivers/smc; ../../../../../middleware/mcu-boot/targets/MKE17Z7/src; ../../../../../middleware/mcu-boot/src/drivers/microseconds; ../../../../../components/osa; ../../../../../CMSIS/Core/Include; ../../../../../components/lists
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../../middleware/mcu-boot/src/startup
  OBJCOPY.OOCOutputFile: generic.srec
  postbuild: cmd /c ..\..\..\..\..\middleware\mcu-boot\bin\create_flashloader_image.bat $PROJ_DIR$ Debug
  ILINK.IlinkOutputFile: flashloader.out
  ILINK.IlinkIcfFile: ../../../../../middleware/mcu-boot/targets/common/linker/iar/MKE17Z7/MKE17Z256xxx7_ram_flashloader.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKE17Z256VLL7; CPU_IS_ARM_CORTEX_M0P=1; BL_TARGET_RAM; FRDM_KE17Z7; FSL_OSA_BM_TIMER_CONFIG=FSL_OSA_BM_TIMER_NONE
  AARM.ADefines: NDEBUG
  postbuild: cmd /c ..\..\..\..\..\middleware\mcu-boot\bin\create_flashloader_image.bat $PROJ_DIR$ Release
  group board
    ../: pin_mux.c pin_mux.h clock_config.c clock_config.h
  group drivers
    ../../../../../devices/MKE17Z7/drivers/: fsl_clock.h fsl_clock.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_lpi2c.c fsl_lpi2c.h fsl_port.h fsl_lpspi.c fsl_lpspi.h fsl_crc.c fsl_crc.h fsl_smc.h fsl_smc.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h
  group device
    ../../../../../devices/MKE17Z7/: fsl_device_registers.h MKE17Z7.h MKE17Z7_features.h system_MKE17Z7.h system_MKE17Z7.c
  group startup
    ../../../../../middleware/mcu-boot/src/startup/: crt0.s ar_asm_macros.h startup.c
    ../../../../../middleware/mcu-boot/targets/MKE17Z7/src/startup/iar/: startup_MKE17Z7.s
  group source/autobaud
    ../../../../../middleware/mcu-boot/src/autobaud/: autobaud.h
    ../../../../../middleware/mcu-boot/src/autobaud/src/: autobaud_irq.c
  group source/bootloader
    ../../../../../middleware/mcu-boot/src/bootloader/: bl_peripheral_interface.h bl_user_entry.h bl_version.h bootloader.h bl_command.h bl_context.h bl_peripheral.h bl_shutdown_cleanup.h bl_irq_common.h bl_app_crc_check.h bl_reliable_update.h
  group source/bootloader/src
    ../../../../../middleware/mcu-boot/src/bootloader/src/: bl_user_entry.c bl_main.c bl_context.c bl_exception_handler.c bl_tree_root.c bl_command.c bl_shutdown_cleanup.c bl_app_crc_check.c bl_misc.c bl_reliable_update.c lpuart_peripheral_interface.c lpspi_peripheral_interface.c lpi2c_peripheral_interface.c
  group source/crc
    ../../../../../middleware/mcu-boot/src/crc/: crc16.h crc32.h
    ../../../../../middleware/mcu-boot/src/crc/src/: crc16.c crc32.c
  group source/include
    ../../../../../middleware/mcu-boot/src/include/: bootloader_common.h bootloader_core.h
  group source/memory
    ../../../../../middleware/mcu-boot/src/memory/: memory.h
  group source/memory/src
    ../../../../../middleware/mcu-boot/src/memory/src/: sram_init.h memory.c normal_memory.h normal_memory.c pattern_fill.s pattern_fill.h flash_memory.h flash_memory.c sram_init_cm0plus.c
  group source/packet
    ../../../../../middleware/mcu-boot/src/packet/: command_packet.h serial_packet.h
  group source/packet/src
    ../../../../../middleware/mcu-boot/src/packet/src/: serial_packet.c
  group source/property
    ../../../../../middleware/mcu-boot/src/property/: property.h
  group source/property/src
    ../../../../../middleware/mcu-boot/src/property/src/: property_kinetis.c
  group source/sbloader
    ../../../../../middleware/mcu-boot/src/sbloader/: sbloader.h sb_file_format.h
  group source/sbloader/src
    ../../../../../middleware/mcu-boot/src/sbloader/src/: sbloader.c
  group source/utilities
    ../../../../../middleware/mcu-boot/src/utilities/: fsl_rtos_abstraction.h fsl_assert.h vector_table_info.h kinetis_family.h
  group source/utilities/src
    ../../../../../middleware/mcu-boot/src/utilities/src/: fsl_assert.c fsl_rtos_abstraction.c debug_util.c
  group source/drivers/smc
    ../../../../../middleware/mcu-boot/src/drivers/smc/: smc.c smc.h
  group source/drivers/microseconds
    ../../../../../middleware/mcu-boot/src/drivers/microseconds/: microseconds.h
    ../../../../../middleware/mcu-boot/src/drivers/microseconds/src/: microseconds_sysclk.c
  group MKE17Z7
    ../../../../../middleware/mcu-boot/targets/MKE17Z7/src/: bootloader_config.h bl_clock_config_MKE17Z7.c hardware_init_MKE17Z7.c memory_map_MKE17Z7.c bl_peripherals_MKE17Z7.c peripherals_pinmux.h target_config.h
    ../../../../../middleware/mcu-boot/targets/common/src/: pinmux_utility_common.c bl_lpi2c_irq_config_common.c bl_lpuart_irq_config_common.c bl_lpspi_irq_config_common.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h mpu_armv7.h
