# Keil uVision project flashloader_loader.uvprojx, settings and files
target flashloader_loader debug (ARM-ADS)
  device: MKE17Z256VLL7 NXP
  pack: Keil.Kinetis_KExx_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M0+")
  output: flashloader_loader.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_MKE17Z256VLL7, CPU_IS_ARM_CORTEX_M0P=1, BL_TARGET_FLASH, FRDM_KE17Z
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -Wno-null-dereference  -Wno-unknown-attributes  -Wno-expansion-to-defined  -Wno-invalid-noreturn
  c include: ../../flashloader/mdk;../../../../../middleware/mcu-boot/targets/MKE17Z7/src;../../../../../devices/MKE17Z7/drivers;../../../../../devices/MKE17Z7;../../../../../middleware/mcu-boot/src/bootloader;../../../../../middleware/mcu-boot/src/include;../../../../../middleware/mcu-boot/src/utilities;../../../../../middleware/mcu-boot/src/startup;../../../../../CMSIS/Core/Include
  asm define: DEBUG, BL_HAS_BOOTLOADER_CONFIG=0, LITE_FOOTPRINT
  asm include: ../../../../../middleware/mcu-boot/src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: ../../../../../middleware/mcu-boot/targets/common/linker/arm/MKE17Z7/MKE17Z256xxx7_flashloader_loader.scf
  link misc: --remove --keep=*(.FlashConfig) --datacompressor off
  group doc
    ../: readme.txt
  group MKE17Z7
    ../../../../../middleware/mcu-boot/targets/MKE17Z7/src/: bootloader_config.h target_config.h
  group drivers
    ../../../../../devices/MKE17Z7/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h
  group device
    ../../../../../devices/MKE17Z7/: fsl_device_registers.h MKE17Z7.h MKE17Z7_features.h system_MKE17Z7.h system_MKE17Z7.c
  group startup
    ../../../../../middleware/mcu-boot/targets/MKE17Z7/src/startup/arm/: startup_MKE17Z7.S
    ../../../../../middleware/mcu-boot/src/startup/: startup.c
  group source/bootloader
    ../../../../../middleware/mcu-boot/src/bootloader/: flashloader_image.h
    ../../../../../middleware/mcu-boot/src/bootloader/src/: bl_flashloader.c bl_exception_handler.c
  group source/include
    ../../../../../middleware/mcu-boot/src/include/: bootloader_common.h bootloader_core.h
  group source/utilities
    ../../../../../middleware/mcu-boot/src/utilities/: fsl_assert.h vector_table_info.h
  group source/utilities/src
    ../../../../../middleware/mcu-boot/src/utilities/src/: fsl_assert.c
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h mpu_armv7.h
target flashloader_loader release (ARM-ADS)
  device: MKE17Z256VLL7 NXP
  pack: Keil.Kinetis_KExx_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M0+")
  output: flashloader_loader.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_MKE17Z256VLL7, CPU_IS_ARM_CORTEX_M0P=1, BL_TARGET_FLASH, FRDM_KE17Z
  c misc: as above
  c include: as above
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=0, LITE_FOOTPRINT
  asm include: ../../../../../middleware/mcu-boot/src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: as above
  link misc: --remove --keep=*(.FlashConfig) --datacompressor off
