# IAR project cmsis_lpspi_edma_b2b_transfer_master.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKE17Z256xxx7 NXP MKE17Z256xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKE17Z256VLL7; FRDM_KE17Z; FREEDOM; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../../devices/MKE17Z7/utilities/debug_console_lite; ../../../../../../../devices/MKE17Z7/drivers; ../../../../../../../devices/MKE17Z7/cmsis_drivers; ../../../../../../../devices/MKE17Z7; ../../../../../../../components/uart; ../../../../../../../components/lists; ../../../../../../../CMSIS/Core/Include; ../../../../../../../CMSIS/Driver/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: cmsis_lpspi_edma_b2b_transfer_master.out
  ILINK.IlinkIcfFile: MKE17Z256xxx7_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKE17Z256VLL7; FRDM_KE17Z; FREEDOM; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: cmsis_lpspi_edma_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../../../devices/MKE17Z7/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../../devices/MKE17Z7/drivers/: fsl_port.h fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.h fsl_lpspi_edma.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_smc.h fsl_smc.c
    ../../../../../../../devices/MKE17Z7/cmsis_drivers/: fsl_lpspi_cmsis.h fsl_lpspi_cmsis.c
  group device
    ../../../../../../../devices/MKE17Z7/: fsl_device_registers.h MKE17Z7.h MKE17Z7_features.h system_MKE17Z7.c system_MKE17Z7.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../../devices/MKE17Z7/iar/: startup_MKE17Z7.s
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h mpu_armv7.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_SPI.h Driver_Common.h
