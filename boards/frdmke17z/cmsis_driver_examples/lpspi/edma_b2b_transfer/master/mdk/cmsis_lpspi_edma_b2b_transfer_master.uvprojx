# Keil uVision project cmsis_lpspi_edma_b2b_transfer_master.uvprojx, settings and files
target cmsis_lpspi_edma_b2b_transfer_master debug (ARM-ADS)
  device: MKE17Z256VLL7 NXP
  pack: Keil.Kinetis_KExx_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M0+")
  output: cmsis_lpspi_edma_b2b_transfer_master.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_MKE17Z256VLL7, FRDM_KE17Z, FREEDOM, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../../devices/MKE17Z7/utilities/debug_console_lite;../../../../../../../devices/MKE17Z7/drivers;../../../../../../../devices/MKE17Z7/cmsis_drivers;../../../../../../../devices/MKE17Z7;../../../../../../../components/uart;../../../../../../../components/lists;../../../../../../../CMSIS/Core/Include;../../../../../../../CMSIS/Driver/Include
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: MKE17Z256xxx7_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --entry=Reset_Handler
  group source
    ../: cmsis_lpspi_edma_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../../../devices/MKE17Z7/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../../devices/MKE17Z7/drivers/: fsl_port.h fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.h fsl_lpspi_edma.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_smc.h fsl_smc.c
    ../../../../../../../devices/MKE17Z7/cmsis_drivers/: fsl_lpspi_cmsis.h fsl_lpspi_cmsis.c
  group device
    ../../../../../../../devices/MKE17Z7/: fsl_device_registers.h MKE17Z7.h MKE17Z7_features.h system_MKE17Z7.c system_MKE17Z7.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../../devices/MKE17Z7/arm/: startup_MKE17Z7.S
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h mpu_armv7.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_SPI.h Driver_Common.h
target cmsis_lpspi_edma_b2b_transfer_master release (ARM-ADS)
  device: MKE17Z256VLL7 NXP
  pack: Keil.Kinetis_KExx_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M0+")
  output: cmsis_lpspi_edma_b2b_transfer_master.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_MKE17Z256VLL7, FRDM_KE17Z, FREEDOM, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: MKE17Z256xxx7_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --entry=Reset_Handler
