# IAR project hello_world.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL02Z32xxx4 NXP MKL02Z32xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKL02Z32VFM4; FRDM_KL02Z; FREEDOM; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../..; ../../../../../devices; ..; ../../../../../devices/MKL02Z4/drivers; ../../../../../devices/MKL02Z4; ../../../../../devices/MKL02Z4/utilities/io; ../../../../../devices/MKL02Z4/utilities/str; ../../../../../devices/MKL02Z4/utilities/log; ../../../../../devices/MKL02Z4/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: MKL02Z32xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL02Z32VFM4; FRDM_KL02Z; FREEDOM; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0
  ICCARM.CCOptLevel: 3
  group source
    ../: hello_world.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKL02Z4/drivers/: fsl_clock.h fsl_clock.c fsl_flash.c fsl_flash.h fsl_common.h fsl_common.c fsl_lpsci.h fsl_lpsci.c fsl_smc.h fsl_smc.c fsl_port.h fsl_gpio.h fsl_gpio.c
  group startup
    ../../../../../devices/MKL02Z4/: system_MKL02Z4.c system_MKL02Z4.h
    ../../../../../devices/MKL02Z4/iar/: startup_MKL02Z4.s
  group utilities
    ../../../../../devices/MKL02Z4/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MKL02Z4/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MKL02Z4/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MKL02Z4/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
