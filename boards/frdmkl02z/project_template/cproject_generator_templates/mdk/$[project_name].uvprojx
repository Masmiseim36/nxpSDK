# Keil uVision project $[project_name].uvprojx, settings and files
target $[project_name] Debug (ARM-ADS)
  device: MKL02Z32VFM4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M0+")
  output: cproject_templates.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;../../../../../platform/drivers;../../../../../platform/drivers/common;../../../../../devices/MKL02Z4/drivers;../../../../../devices/MKL02Z4/utilities;../../../../../devices/MKL02Z4
  asm define: DEBUG
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKL02Z32xxx4_flash.scf
  link misc: --remove
  group startup
    ../../../../../devices/MKL02Z4/arm/: startup_MKL02Z4.s
    ../../../../../devices/MKL02Z4/: system_MKL02Z4.c system_MKL02Z4.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKL02Z4/drivers/: fsl_lpsci.h fsl_lpsci.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group utilities
    ../../../../../devices/MKL02Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
target $[project_name] Release (ARM-ADS)
  device: MKL02Z32VFM4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M0+")
  output: cproject_templates.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG
  c misc: as above
  c include: as above
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKL02Z32xxx4_flash.scf
  link misc: --remove
