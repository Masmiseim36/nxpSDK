# IAR project cmsis_spi_interrupt_b2b_transfer_master.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL03Z32xxx4 NXP MKL03Z32xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKL03Z32VFK4; FRDM_KL03Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..; ../../../../../../../CMSIS/Driver/Include; ../../../../..; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../devices/MKL03Z4/drivers; ../../../../../../../devices/MKL03Z4/cmsis_drivers; ../../../../../../../devices/MKL03Z4; ../../../../../../../devices/MKL03Z4/utilities/io; ../../../../../../../devices/MKL03Z4/utilities/str; ../../../../../../../devices/MKL03Z4/utilities/log; ../../../../../../../devices/MKL03Z4/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: cmsis_spi_interrupt_b2b_transfer_master.out
  ILINK.IlinkIcfFile: MKL03Z32xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL03Z32VFK4; FRDM_KL03Z; FREEDOM
  ICCARM.CCOptLevel: 3
  group source
    ../: cmsis_spi_interrupt_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MKL03Z4/drivers/: fsl_port.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_spi.h fsl_spi.c fsl_flash.c fsl_flash.h fsl_smc.h fsl_smc.c
    ../../../../../../../devices/MKL03Z4/cmsis_drivers/: fsl_spi_cmsis.h fsl_spi_cmsis.c
  group startup
    ../../../../../../../devices/MKL03Z4/: system_MKL03Z4.c system_MKL03Z4.h
    ../../../../../../../devices/MKL03Z4/iar/: startup_MKL03Z4.s
  group utilities
    ../../../../../../../devices/MKL03Z4/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../../devices/MKL03Z4/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../../devices/MKL03Z4/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MKL03Z4/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
