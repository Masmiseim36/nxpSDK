# Keil uVision project cmsis_spi_interrupt_b2b_transfer_master.uvprojx, settings and files
target cmsis_spi_interrupt_b2b_transfer_master debug (ARM-ADS)
  device: MKL03Z32VFK4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M0+")
  output: cmsis_spi_interrupt_b2b_transfer_master.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKL03Z32VFK4, FRDM_KL03Z, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..;../../../../../../../CMSIS/Driver/Include;../../../../..;../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../devices/MKL03Z4/drivers;../../../../../../../devices/MKL03Z4/cmsis_drivers;../../../../../../../devices/MKL03Z4;../../../../../../../devices/MKL03Z4/utilities/io;../../../../../../../devices/MKL03Z4/utilities/str;../../../../../../../devices/MKL03Z4/utilities/log;../../../../../../../devices/MKL03Z4/utilities
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKL03Z32xxx4_flash.scf
  link misc: --remove
  group source
    ../: cmsis_spi_interrupt_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MKL03Z4/drivers/: fsl_port.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_spi.h fsl_spi.c fsl_flash.c fsl_flash.h fsl_smc.h fsl_smc.c
    ../../../../../../../devices/MKL03Z4/cmsis_drivers/: fsl_spi_cmsis.h fsl_spi_cmsis.c
  group startup
    ../../../../../../../devices/MKL03Z4/: system_MKL03Z4.c system_MKL03Z4.h
    ../../../../../../../devices/MKL03Z4/arm/: startup_MKL03Z4.s
  group utilities
    ../../../../../../../devices/MKL03Z4/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../../devices/MKL03Z4/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../../devices/MKL03Z4/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MKL03Z4/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
target cmsis_spi_interrupt_b2b_transfer_master release (ARM-ADS)
  device: MKL03Z32VFK4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M0+")
  output: cmsis_spi_interrupt_b2b_transfer_master.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKL03Z32VFK4, FRDM_KL03Z, FREEDOM
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKL03Z32xxx4_flash.scf
  link misc: --remove
