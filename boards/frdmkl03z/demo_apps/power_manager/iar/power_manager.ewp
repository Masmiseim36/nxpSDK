# IAR project power_manager.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL03Z32xxx4 NXP MKL03Z32xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKL03Z32VFK4; FRDM_KL03Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ..; ../../../../../platform/utilities/notifier; ../../..; ../../../../../devices/MKL03Z4/drivers; ../../../../../devices/MKL03Z4; ../../../../../devices/MKL03Z4/utilities/io; ../../../../../devices/MKL03Z4/utilities/str; ../../../../../devices/MKL03Z4/utilities/log; ../../../../../devices/MKL03Z4/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: power_manager.out
  ILINK.IlinkIcfFile: MKL03Z32xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL03Z32VFK4; FRDM_KL03Z; FREEDOM
  ICCARM.CCOptLevel: 3
  group source
    ../: clock_mcglite.c power_manager.h power_manager.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKL03Z4/drivers/: fsl_clock.h fsl_clock.c fsl_flash.c fsl_flash.h fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c fsl_llwu.h fsl_llwu.c fsl_pmc.h fsl_pmc.c fsl_rcm.c fsl_rcm.h fsl_lptmr.c fsl_lptmr.h
  group startup
    ../../../../../devices/MKL03Z4/: system_MKL03Z4.c system_MKL03Z4.h
    ../../../../../devices/MKL03Z4/iar/: startup_MKL03Z4.s
  group utilities
    ../../../../../devices/MKL03Z4/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MKL03Z4/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MKL03Z4/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MKL03Z4/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c fsl_notifier.c fsl_notifier.h
