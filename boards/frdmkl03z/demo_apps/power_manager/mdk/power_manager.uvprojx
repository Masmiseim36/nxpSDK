# Keil uVision project power_manager.uvprojx, settings and files
target power_manager debug (ARM-ADS)
  device: MKL03Z32VFK4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M0+")
  output: power_manager.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKL03Z32VFK4, FRDM_KL03Z, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;..;../../../../../platform/utilities/notifier;../../..;../../../../../devices/MKL03Z4/drivers;../../../../../devices/MKL03Z4;../../../../../devices/MKL03Z4/utilities/io;../../../../../devices/MKL03Z4/utilities/str;../../../../../devices/MKL03Z4/utilities/log;../../../../../devices/MKL03Z4/utilities
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKL03Z32xxx4_flash.scf
  link misc: --remove
  group source
    ../: clock_mcglite.c power_manager.h power_manager.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKL03Z4/drivers/: fsl_clock.h fsl_clock.c fsl_flash.c fsl_flash.h fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c fsl_llwu.h fsl_llwu.c fsl_pmc.h fsl_pmc.c fsl_rcm.c fsl_rcm.h fsl_lptmr.c fsl_lptmr.h
  group startup
    ../../../../../devices/MKL03Z4/: system_MKL03Z4.c system_MKL03Z4.h
    ../../../../../devices/MKL03Z4/arm/: startup_MKL03Z4.s
  group utilities
    ../../../../../devices/MKL03Z4/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MKL03Z4/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MKL03Z4/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MKL03Z4/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c fsl_notifier.c fsl_notifier.h
target power_manager release (ARM-ADS)
  device: MKL03Z32VFK4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M0+")
  output: power_manager.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKL03Z32VFK4, FRDM_KL03Z, FREEDOM
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKL03Z32xxx4_flash.scf
  link misc: --remove
