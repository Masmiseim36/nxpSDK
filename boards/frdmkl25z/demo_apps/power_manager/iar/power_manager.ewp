# IAR project power_manager.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 NXP MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKL25Z128VLK4; FRDM_KL25Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ..; ../../../../../platform/utilities/notifier; ../../..; ../../../../../devices/MKL25Z4/drivers; ../../../../../devices/MKL25Z4/utilities; ../../../../../devices/MKL25Z4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: power_manager.out
  ILINK.IlinkIcfFile: MKL25Z128xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL25Z128VLK4; FRDM_KL25Z; FREEDOM
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../devices/MKL25Z4/iar/: startup_MKL25Z4.s
    ../../../../../devices/MKL25Z4/: system_MKL25Z4.c system_MKL25Z4.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKL25Z4/drivers/: fsl_lpsci.h fsl_lpsci.c fsl_uart.h fsl_uart.c fsl_port.h fsl_llwu.h fsl_llwu.c fsl_pmc.h fsl_pmc.c fsl_smc.h fsl_smc.c fsl_rcm.c fsl_rcm.h fsl_lptmr.c fsl_lptmr.h fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group source
    ../: power_manager.h power_manager.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MKL25Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
  group notifier
    ../../../../../devices/MKL25Z4/utilities/: fsl_notifier.c fsl_notifier.h
