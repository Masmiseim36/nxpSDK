# Keil uVision project power_manager.uvprojx, settings and files
target power_manager Debug (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  cpu: CPUTYPE("Cortex-M0+")
  output: power_manager.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKL25Z128VLK4, FRDM_KL25Z, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;..;../../../../../platform/utilities/notifier;../../..;../../../../../devices/MKL25Z4/drivers;../../../../../devices/MKL25Z4/utilities;../../../../../devices/MKL25Z4
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: MKL25Z128xxx4_flash.scf
  link misc: --remove
  group startup
    ../../../../../devices/MKL25Z4/arm/: startup_MKL25Z4.s
    ../../../../../devices/MKL25Z4/: system_MKL25Z4.c system_MKL25Z4.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKL25Z4/drivers/: fsl_lpsci.h fsl_lpsci.c fsl_uart.h fsl_uart.c fsl_port.h fsl_llwu.h fsl_llwu.c fsl_pmc.h fsl_pmc.c fsl_smc.h fsl_smc.c fsl_rcm.c fsl_rcm.h fsl_lptmr.c fsl_lptmr.h fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group source
    ../: power_manager.h power_manager.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MKL25Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
  group notifier
    ../../../../../devices/MKL25Z4/utilities/: fsl_notifier.c fsl_notifier.h
target power_manager Release (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  cpu: CPUTYPE("Cortex-M0+")
  output: power_manager.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKL25Z128VLK4, FRDM_KL25Z, FREEDOM
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: MKL25Z128xxx4_flash.scf
  link misc: --remove
