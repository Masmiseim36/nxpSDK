# IAR project kl25z_mma8451_pedometer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 NXP MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKL25Z128VLK4; FRDM_KL25Z; FREEDOM; PRINTF_ADVANCED_ENABLE
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../platform/drivers; ../../../../../../../middleware/issdk_1.6/drivers/gpio; ../../../../../../../middleware/issdk_1.6/drivers/gpio/kinetis; ../../../../../../../middleware/issdk_1.6/drivers/systick; ../../../../../../../CMSIS/Driver/Include; ../../../../../../../middleware/issdk_1.6/sensors; ../../../../../../../middleware/issdk_1.6/algorithms/pedometer/include; ../../../../../../../middleware/issdk_1.6/algorithms/pedometer/include/libinclude; ../../../..; ..; ../../../../..; ../../../../../../../devices/MKL25Z4/drivers; ../../../../../../../devices/MKL25Z4/cmsis_drivers; ../../../../../../../devices/MKL25Z4/utilities; ../../../../../../../devices/MKL25Z4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: KL25Z-MMA8451-PEDOMETER.srec
  ILINK.IlinkOutputFile: kl25z_mma8451_pedometer.out
  ILINK.IlinkIcfFile: MKL25Z128xxx4_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../middleware/issdk_1.6/algorithms/pedometer/lib/LibPedometer_m0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL25Z128VLK4; FRDM_KL25Z; FREEDOM; PRINTF_ADVANCED_ENABLE
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../../devices/MKL25Z4/iar/: startup_MKL25Z4.s
    ../../../../../../../devices/MKL25Z4/: system_MKL25Z4.c system_MKL25Z4.h
  group doc
    ../: readme.txt
  group board
    ../../../../: frdm_kl25z.c frdm_kl25z.h issdk_hal.h RTE_Device.h
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group sensors
    ../../../../../../../middleware/issdk_1.6/sensors/: sensor_drv.h mma845x_drv.h mma845x_drv.c mma845x.h
    ../../../../../../../middleware/issdk_1.6/algorithms/pedometer/source/: pedometer.c
    ../../../../../../../middleware/issdk_1.6/algorithms/pedometer/include/: pedometer.h
    ../../../../../../../middleware/issdk_1.6/algorithms/pedometer/include/libinclude/: KeynetikPedometer.h
    ../../../../../../../middleware/issdk_1.6/algorithms/pedometer/examples/: pedometer_stepcount_mma8451.c
  group utilities
    ../../../../../../../middleware/issdk_1.6/drivers/systick/: systick_utils.c systick_utils.h
    ../../../../../../../devices/MKL25Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
  group drivers
    ../../../../../../../devices/MKL25Z4/drivers/: fsl_lpsci.h fsl_lpsci.c fsl_uart.h fsl_uart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_i2c.h fsl_i2c.c fsl_dmamux.h fsl_dmamux.c fsl_lptmr.c fsl_lptmr.h fsl_smc.h fsl_smc.c fsl_dma.h fsl_dma.c fsl_i2c_dma.c fsl_i2c_dma.h fsl_uart_dma.h fsl_uart_dma.c fsl_common.h fsl_common.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
    ../../../../../../../devices/MKL25Z4/cmsis_drivers/: fsl_i2c_cmsis.h fsl_i2c_cmsis.c
  group gpio_driver
    ../../../../../../../middleware/issdk_1.6/drivers/gpio/kinetis/: gpio_driver_irq.c gpio_driver.c gpio_driver.h
    ../../../../../../../middleware/issdk_1.6/drivers/gpio/: Driver_GPIO.h
  group interface
    ../../../../../../../middleware/issdk_1.6/sensors/: register_io_i2c.c register_io_i2c.h sensor_io_i2c.c sensor_io_i2c.h register_io_spi.c register_io_spi.h sensor_io_spi.c sensor_io_spi.h
