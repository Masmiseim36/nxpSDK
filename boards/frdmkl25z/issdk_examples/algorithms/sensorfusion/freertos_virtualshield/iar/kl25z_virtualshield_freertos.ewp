# IAR project kl25z_virtualshield_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 NXP MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKL25Z128VLK4; FSL_RTOS_FREE_RTOS; FRDM_KL25Z; FREEDOM; PRINTF_ADVANCED_ENABLE
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM0; ../../../../../../../rtos/freertos_9.0.0/Source/include; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../platform/drivers; ../../../../../../../middleware/issdk_1.6/drivers/gpio; ../../../../../../../middleware/issdk_1.6/drivers/gpio/kinetis; ../../../../../../../middleware/issdk_1.6/drivers/systick; ../../../../../../../CMSIS/Driver/Include; ../../../../../../../middleware/issdk_1.6/sensors; ../../../../../../../middleware/issdk_1.6/algorithms/sensorfusion/sources; ..; ../../../../../../../rtos/freertos_9.0.0/Source; ../../../../..; ../../../../../../../devices/MKL25Z4/drivers; ../../../../../../../devices/MKL25Z4/cmsis_drivers; ../../../../../../../devices/MKL25Z4/utilities; ../../../../../../../devices/MKL25Z4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: KL25Z-VIRTUALSHIELD-FREERTOS.srec
  ILINK.IlinkOutputFile: kl25z_virtualshield_freertos.out
  ILINK.IlinkIcfFile: MKL25Z128xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL25Z128VLK4; FSL_RTOS_FREE_RTOS; FRDM_KL25Z; FREEDOM; PRINTF_ADVANCED_ENABLE
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../../devices/MKL25Z4/iar/: startup_MKL25Z4.s
    ../../../../../../../devices/MKL25Z4/: system_MKL25Z4.c system_MKL25Z4.h
  group freertos
    ../../../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_3.c
    ../../../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
    ../../../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group freertos/portable
    ../../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM0/: port.c fsl_tickless_systick.c fsl_tickless_generic.h portasm.s portmacro.h
  group doc
    ../: readme.txt
  group board
    ../: frdm_kl25z.c frdm_kl25z.h issdk_hal.h virtual_shield.h RTE_Device.h pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group sensors
    ../../../../../../../middleware/issdk_1.6/sensors/: register_io_i2c.c register_io_spi.c sensor_io_spi.c sensor_io_i2c.c register_io_i2c.h register_io_spi.h sensor_io_spi.h sensor_io_i2c.h sensor_drv.h fxas21002.h fxas21002_drv.h fxos8700_drv.h fxos8700.h mpl3115_drv.h mpl3115.h
  group drivers
    ../../../../../../../devices/MKL25Z4/drivers/: fsl_lpsci.h fsl_lpsci.c fsl_uart.h fsl_uart.c fsl_port.h fsl_i2c.h fsl_i2c.c fsl_flash.c fsl_flash.h fsl_dmamux.h fsl_dmamux.c fsl_lptmr.c fsl_lptmr.h fsl_pit.c fsl_pit.h fsl_smc.h fsl_smc.c fsl_i2c_dma.c fsl_i2c_dma.h fsl_uart_dma.h fsl_uart_dma.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c
    ../../../../../../../devices/MKL25Z4/cmsis_drivers/: fsl_i2c_cmsis.h fsl_i2c_cmsis.c
  group drivers/freertos
    ../../../../../../../devices/MKL25Z4/drivers/: fsl_i2c_freertos.h fsl_i2c_freertos.c
  group gpio_driver
    ../../../../../../../middleware/issdk_1.6/drivers/gpio/kinetis/: gpio_driver.h
    ../../../../../../../middleware/issdk_1.6/drivers/gpio/: Driver_GPIO.h
  group sensor_fusion
    ../../../../../../../middleware/issdk_1.6/algorithms/sensorfusion/sources/: approximations.c approximations.h calibration_storage.h calibration_storage.c control_lpsci.c control.h debug.h debug.c DecodeCommandBytes.c driver_FXAS21002.c driver_FXOS8700.c driver_MPL3115.c driver_KSDK_NVM.c driver_KSDK_NVM.h driver_pit.c driver_pit.h driver_systick.c drivers.h fusion.h fusion.c hal_frdm_fxs_mult2_b.c magnetic.c magnetic.h matrix.c matrix.h orientation.c orientation.h output_stream.c precisionAccelerometer.c precisionAccelerometer.h sensor_fusion.h sensor_fusion.c status.c status.h
  group source
    ../: build.h FreeRTOSConfig.h
    ../../../../../../../middleware/issdk_1.6/algorithms/sensorfusion/sources/: main_freertos_two_tasks.c
  group utilities
    ../../../../../../../middleware/issdk_1.6/drivers/systick/: systick_utils.c systick_utils.h
    ../../../../../../../devices/MKL25Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
