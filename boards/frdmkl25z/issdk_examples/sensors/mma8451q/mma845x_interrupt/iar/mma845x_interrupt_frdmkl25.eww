<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>mma845x_interrupt_frdmkl25</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>mma845x_interrupt_frdmkl25</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>mma845x_interrupt_frdmkl25</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>mma845x_interrupt_frdmkl25</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/mma845x_interrupt_frdmkl25.ewp</path>
  </project>
</workspace>
