# IAR project erpc_remote_control.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 NXP MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKL25Z128VLK4; FSL_RTOS_FREE_RTOS; FRDM_KL25Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM0; ../../../../../rtos/freertos_9.0.0/Source/include; ../../../../../CMSIS/Include; ../../../../../devices; ..; ../service; ../../../../../CMSIS/Driver/Include; ../../..; ../../../../../middleware/multicore_2.2.0/erpc/erpc_c/infra; ../../../../../middleware/multicore_2.2.0/erpc/erpc_c/port; ../../../../../middleware/multicore_2.2.0/erpc/erpc_c/setup; ../../../../../middleware/multicore_2.2.0/erpc/erpc_c/transports; ../../../../../middleware/multicore_2.2.0/erpc/erpcgen/src; ../../../../../rtos/freertos_9.0.0/Source; ../../../../../devices/MKL25Z4/drivers; ../../../../../devices/MKL25Z4/cmsis_drivers; ../../../../../devices/MKL25Z4/utilities; ../../../../../devices/MKL25Z4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..; ../service; ../../../../../CMSIS/Driver/Include; ../../..
  ILINK.IlinkOutputFile: erpc_remote_control.out
  ILINK.IlinkIcfFile: MKL25Z128xxx4_flash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL25Z128VLK4; FSL_RTOS_FREE_RTOS; FRDM_KL25Z; FREEDOM
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../devices/MKL25Z4/iar/: startup_MKL25Z4.s
    ../../../../../devices/MKL25Z4/: system_MKL25Z4.c system_MKL25Z4.h
  group freertos
    ../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
    ../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
    ../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group freertos/portable
    ../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM0/: port.c fsl_tickless_systick.c fsl_tickless_generic.h portasm.s portmacro.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKL25Z4/drivers/: fsl_dma.h fsl_dma.c fsl_lpsci.h fsl_lpsci.c fsl_lpsci_dma.h fsl_lpsci_dma.c fsl_dac.c fsl_dac.h fsl_uart.h fsl_uart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_i2c.h fsl_i2c.c fsl_adc16.c fsl_adc16.h fsl_dmamux.h fsl_dmamux.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
    ../../../../../CMSIS/Driver/Include/: Driver_Common.h Driver_USART.h
  group drivers/drivers
    ../../../../../devices/MKL25Z4/cmsis_drivers/: fsl_lpsci_cmsis.h fsl_lpsci_cmsis.c
  group accel
    ../: fsl_mma.h fsl_mma.c
  group erpc/infra
    ../../../../../middleware/multicore_2.2.0/erpc/erpc_c/infra/: arbitrated_client_manager.h arbitrated_client_manager.cpp client_manager.h client_manager.cpp simple_server.h simple_server.cpp server.h server.cpp transport_arbitrator.h transport_arbitrator.cpp framed_transport.h framed_transport.cpp erpc_version.h codec.h basic_codec.h transport.h message_buffer.h erpc_common.h manually_constructed.h basic_codec.cpp message_buffer.cpp
  group erpc/setup
    ../../../../../middleware/multicore_2.2.0/erpc/erpc_c/setup/: erpc_arbitrated_client_setup.h erpc_arbitrated_client_setup.cpp erpc_server_setup.h erpc_server_setup.cpp erpc_setup_uart_cmsis.cpp erpc_setup_mbf_dynamic.cpp erpc_transport_setup.h erpc_mbf_setup.h
  group erpc/port
    ../../../../../middleware/multicore_2.2.0/erpc/erpc_c/port/: erpc_threading.h erpc_threading_freertos.cpp erpc_port.h erpc_port_freertos.cpp erpc_config_internal.h
  group erpc/transports
    ../../../../../middleware/multicore_2.2.0/erpc/erpc_c/transports/: uart_cmsis_transport.h uart_cmsis_transport.cpp
  group erpc/service
    ../service/: erpc_remote_control.erpc erpc_remote_control.h erpc_remote_control_app_0.h erpc_remote_control_app_0_server.h erpc_remote_control_app_0_server.cpp erpc_remote_control_app_1.h erpc_remote_control_app_1_client.cpp
  group source
    ../: remote_control.c FreeRTOSConfig.h erpc_config.h
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MKL25Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
