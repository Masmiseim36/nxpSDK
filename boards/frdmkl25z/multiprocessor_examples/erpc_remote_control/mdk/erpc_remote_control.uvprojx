# Keil uVision project erpc_remote_control.uvprojx, settings and files
target erpc_remote_control Debug (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  cpu: CPUTYPE("Cortex-M0+")
  output: erpc_remote_control.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKL25Z128VLK4, FSL_RTOS_FREE_RTOS, FRDM_KL25Z, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../rtos/freertos_9.0.0/Source/portable/RVDS/ARM_CM0;../../../../../rtos/freertos_9.0.0/Source/include;../../../../../CMSIS/Include;../../../../../devices;..;../service;../../../../../CMSIS/Driver/Include;../../..;../../../../../middleware/multicore_2.2.0/erpc/erpc_c/infra;../../../../../middleware/multicore_2.2.0/erpc/erpc_c/port;../../../../../middleware/multicore_2.2.0/erpc/erpc_c/setup;../../../../../middleware/multicore_2.2.0/erpc/erpc_c/transports;../../../../../middleware/multicore_2.2.0/erpc/erpcgen/src;../../../../../rtos/freertos_9.0.0/Source;../../../../../devices/MKL25Z4/drivers;../../../../../devices/MKL25Z4/cmsis_drivers;../../../../../devices/MKL25Z4/utilities;../../../../../devices/MKL25Z4
  asm define: DEBUG
  asm include: ..;../service;../../../../../CMSIS/Driver/Include;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: MKL25Z128xxx4_flash.scf
  link misc: --remove
  group startup
    ../../../../../devices/MKL25Z4/arm/: startup_MKL25Z4.s
    ../../../../../devices/MKL25Z4/: system_MKL25Z4.c system_MKL25Z4.h
  group freertos:portable
    ../../../../../rtos/freertos_9.0.0/Source/portable/RVDS/ARM_CM0/: port.c fsl_tickless_systick.c fsl_tickless_generic.h portmacro.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKL25Z4/drivers/: fsl_dma.h fsl_dma.c fsl_lpsci.h fsl_lpsci.c fsl_lpsci_dma.h fsl_lpsci_dma.c fsl_dac.c fsl_dac.h fsl_uart.h fsl_uart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_i2c.h fsl_i2c.c fsl_adc16.c fsl_adc16.h fsl_dmamux.h fsl_dmamux.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
    ../../../../../CMSIS/Driver/Include/: Driver_Common.h Driver_USART.h
  group drivers-drivers
    ../../../../../devices/MKL25Z4/cmsis_drivers/: fsl_lpsci_cmsis.h fsl_lpsci_cmsis.c
  group accel
    ../: fsl_mma.h fsl_mma.c
  group erpc-infra
    ../../../../../middleware/multicore_2.2.0/erpc/erpc_c/infra/: arbitrated_client_manager.h arbitrated_client_manager.cpp client_manager.h client_manager.cpp simple_server.h simple_server.cpp server.h server.cpp transport_arbitrator.h transport_arbitrator.cpp framed_transport.h framed_transport.cpp erpc_version.h codec.h basic_codec.h transport.h message_buffer.h erpc_common.h manually_constructed.h basic_codec.cpp message_buffer.cpp
  group erpc-setup
    ../../../../../middleware/multicore_2.2.0/erpc/erpc_c/setup/: erpc_arbitrated_client_setup.h erpc_arbitrated_client_setup.cpp erpc_server_setup.h erpc_server_setup.cpp erpc_setup_uart_cmsis.cpp erpc_setup_mbf_dynamic.cpp erpc_transport_setup.h erpc_mbf_setup.h
  group erpc-port
    ../../../../../middleware/multicore_2.2.0/erpc/erpc_c/port/: erpc_threading.h erpc_threading_freertos.cpp erpc_port.h erpc_port_freertos.cpp erpc_config_internal.h
  group erpc-transports
    ../../../../../middleware/multicore_2.2.0/erpc/erpc_c/transports/: uart_cmsis_transport.h uart_cmsis_transport.cpp
  group freertos
    ../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
    ../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
    ../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group source
    ../: remote_control.c FreeRTOSConfig.h erpc_config.h
  group erpc-service
    ../service/: erpc_remote_control.erpc erpc_remote_control.h erpc_remote_control_app_0.h erpc_remote_control_app_0_server.h erpc_remote_control_app_0_server.cpp erpc_remote_control_app_1.h erpc_remote_control_app_1_client.cpp
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MKL25Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
target erpc_remote_control Release (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  cpu: CPUTYPE("Cortex-M0+")
  output: erpc_remote_control.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKL25Z128VLK4, FSL_RTOS_FREE_RTOS, FRDM_KL25Z, FREEDOM
  c misc: as above
  c include: as above
  asm include: ..;../service;../../../../../CMSIS/Driver/Include;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: MKL25Z128xxx4_flash.scf
  link misc: --remove
