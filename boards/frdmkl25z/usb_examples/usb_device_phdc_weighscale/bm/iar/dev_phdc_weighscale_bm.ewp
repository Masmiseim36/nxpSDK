# IAR project dev_phdc_weighscale_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 NXP MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: _DEBUG=1; CPU_MKL25Z128VLK4; USB_STACK_BM; FRDM_KL25Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..; ../../../../../../middleware/usb_1.6.3; ../../../../../../middleware/usb_1.6.3/osa; ../../../../../../middleware/usb_1.6.3/include; ../../../../../../middleware/usb_1.6.3/device; ../../../../../../CMSIS/Include; ../../../..; ../../../../../../devices/MKL25Z4/drivers; ../../../../../../devices/MKL25Z4/utilities; ../../../../../../devices/MKL25Z4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: dev_phdc_weighscale_bm.out
  ILINK.IlinkIcfFile: MKL25Z128xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MKL25Z128VLK4; USB_STACK_BM; FRDM_KL25Z; FREEDOM
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/MKL25Z4/iar/: startup_MKL25Z4.s
    ../../../../../../devices/MKL25Z4/: system_MKL25Z4.c system_MKL25Z4.h
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb_1.6.3/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/khci
    ../../../../../../middleware/usb_1.6.3/device/: usb_device_khci.c usb_device_khci.h
    ../../../../../../middleware/usb_1.6.3/include/: usb_khci.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/phdc
    ../: usb_device_phdc.c usb_device_phdc.h
  group usb/device/include
    ../../../../../../middleware/usb_1.6.3/device/: usb_device.h
  group usb/include
    ../../../../../../middleware/usb_1.6.3/include/: usb.h usb_misc.h usb_spec.h
  group drivers
    ../../../../../../devices/MKL25Z4/drivers/: fsl_uart.h fsl_uart.c fsl_lpsci.h fsl_lpsci.c fsl_port.h fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group osa
    ../../../../../../middleware/usb_1.6.3/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group sources
    ../: usb_device_descriptor.c usb_device_descriptor.h usb_shim_agent.c usb_shim_agent.h weighscale.c weighscale.h usb_device_config.h
  group sources/ieee11073_agent
    ../: ieee11073_agent.c ieee11073_agent.h ieee11073_types.h ieee11073_timer.c ieee11073_timer.h
  group utilities
    ../../../../../../devices/MKL25Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
