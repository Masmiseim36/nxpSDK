# IAR project host_phdc_manager_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 NXP MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: _DEBUG=1; CPU_MKL25Z128VLK4; USB_STACK_BM; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; FRDM_KL25Z; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..; ../../../../../../middleware/usb_1.6.3; ../../../../../../middleware/usb_1.6.3/osa; ../../../../../../middleware/usb_1.6.3/include; ../../../../../../CMSIS/Include; ../../../..; ../../../../../../middleware/usb_1.6.3/host; ../../../../../../devices/MKL25Z4/drivers; ../../../../../../middleware/usb_1.6.3/host/class; ../../../../../../devices/MKL25Z4/utilities; ../../../../../../devices/MKL25Z4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: host_phdc_manager_bm.out
  ILINK.IlinkIcfFile: MKL25Z128xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MKL25Z128VLK4; USB_STACK_BM; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; FRDM_KL25Z; TOWER
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/MKL25Z4/iar/: startup_MKL25Z4.s
    ../../../../../../devices/MKL25Z4/: system_MKL25Z4.c system_MKL25Z4.h
  group usb/host
    ../../../../../../middleware/usb_1.6.3/host/: usb_host_khci.c usb_host_khci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c
  group usb/host/class
    ../../../../../../middleware/usb_1.6.3/host/class/: usb_host_phdc.c usb_host_phdc.h usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h
  group usb/include
    ../../../../../../middleware/usb_1.6.3/include/: usb.h usb_misc.h usb_spec.h
  group drivers
    ../../../../../../devices/MKL25Z4/drivers/: fsl_uart.h fsl_uart.c fsl_lpsci.h fsl_lpsci.c fsl_port.h fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group osa
    ../../../../../../middleware/usb_1.6.3/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group sources
    ../: app.c host_phdc_manager.c host_phdc_manager.h ieee11073_nomenclature.h ieee11073_nomenclature.c ieee11073_types.h usb_host_config.h
  group utilities
    ../../../../../../devices/MKL25Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
