<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>kl25z_a8491_host_demo_template</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>kl25z_a8491_host_demo_template</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>kl25z_a8491_host_demo_template</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>kl25z_a8491_host_demo_template</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/kl25z_a8491_host_demo_template.ewp</path>
  </project>
</workspace>
