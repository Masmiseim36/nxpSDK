# Keil uVision project kl25z_p3115_host_demo_template.uvprojx, settings and files
target kl25z_p3115_host_demo_template Debug (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  cpu: CPUTYPE("Cortex-M0+")
  output: kl25z_p3115_host_demo_template.out
  AfterMake: fromelf.exe --m32combined  --output  "$L@L.srec"  "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKL25Z128VLK4, FRDM_KL25Z, FREEDOM, PRINTF_ADVANCED_ENABLE
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../platform/drivers;../../../../../../../middleware/issdk_1.6/drivers/gpio/kinetis;../../../../../../../middleware/issdk_1.6/drivers/gpio;../../../../../../../middleware/issdk_1.6/drivers/host;../../../../../../../middleware/issdk_1.6/drivers/ads;../../../../../../../middleware/issdk_1.6/drivers/ads/kinetis;../../../../../../../middleware/issdk_1.6/drivers/systick;../../../../../../../CMSIS/Driver/Include;../../../../../../../middleware/issdk_1.6/sensors;../../../../..;..;../../../../../../frdmkl25z;../../../../../../../devices/MKL25Z4/drivers;../../../../../../../devices/MKL25Z4/cmsis_drivers;../../../../../../../devices/MKL25Z4/utilities;../../../../../../../devices/MKL25Z4
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: MKL25Z128xxx4_flash.scf
  link misc: --remove
  group startup
    ../../../../../../../devices/MKL25Z4/arm/: startup_MKL25Z4.s
    ../../../../../../../devices/MKL25Z4/: system_MKL25Z4.c system_MKL25Z4.h
  group doc
    ../: readme.txt
  group board
    ../../../../../: frdm_kl25z.c frdm_kl25z.h frdm_stbc_p3115_shield.h issdk_hal.h RTE_Device.h
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group sensors
    ../../../../../../../middleware/issdk_1.6/driverexamples/demos/: host_demo.c
    ../../../../../../../middleware/issdk_1.6/sensors/: fxas21002.h fxlc95000.h fxls8471q.h fxls8962.h fxos8700.h fxpq3115.h mag3110.h mma845x.h mma865x.h mma8491q.h mma9553.h mpl3115.h diff_p.h
  group interface
    ../../../../../../../middleware/issdk_1.6/sensors/: sensor_drv.h register_io_i2c.c register_io_i2c.h sensor_io_i2c.c sensor_io_i2c.h register_io_spi.c register_io_spi.h sensor_io_spi.c sensor_io_spi.h
  group utilities
    ../../../../../../../middleware/issdk_1.6/drivers/systick/: systick_utils.c systick_utils.h
    ../../../../../../../devices/MKL25Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
  group drivers
    ../../../../../../../devices/MKL25Z4/drivers/: fsl_lpsci.h fsl_lpsci.c fsl_uart.h fsl_uart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_spi.h fsl_spi.c fsl_lptmr.c fsl_lptmr.h fsl_i2c.h fsl_i2c.c fsl_smc.h fsl_smc.c fsl_dma.h fsl_dma.c fsl_dmamux.h fsl_dmamux.c fsl_i2c_dma.c fsl_i2c_dma.h fsl_spi_dma.h fsl_spi_dma.c fsl_lpsci_dma.h fsl_lpsci_dma.c fsl_uart_dma.h fsl_uart_dma.c fsl_common.h fsl_common.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
    ../../../../../../../devices/MKL25Z4/cmsis_drivers/: fsl_i2c_cmsis.h fsl_i2c_cmsis.c fsl_spi_cmsis.h fsl_spi_cmsis.c fsl_lpsci_cmsis.h fsl_lpsci_cmsis.c
  group gpio_driver
    ../../../../../../../middleware/issdk_1.6/drivers/gpio/kinetis/: gpio_driver_irq.c gpio_driver.c gpio_driver.h
    ../../../../../../../middleware/issdk_1.6/drivers/gpio/: Driver_GPIO.h
  group host
    ../../../../../../../middleware/issdk_1.6/sensors/: host_io_uart.c host_io_uart.h
    ../../../../../../../middleware/issdk_1.6/drivers/host/: comm_if_uart.c comm_interface.h data_format_hdlc.c data_format_hdlc.h data_format_json.c data_format_json.h data_format_service.h host_interface_service.c host_interface_service.h
  group ads
    ../../../../../../../middleware/issdk_1.6/drivers/ads/kinetis/: auto_detection_service.c auto_detection_service.h
    ../../../../../../../middleware/issdk_1.6/drivers/ads/: auto_detection_shield.h
target kl25z_p3115_host_demo_template Release (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  cpu: CPUTYPE("Cortex-M0+")
  output: kl25z_p3115_host_demo_template.out
  AfterMake: fromelf.exe --m32combined  --output  "$L@L.srec"  "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKL25Z128VLK4, FRDM_KL25Z, FREEDOM, PRINTF_ADVANCED_ENABLE
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: MKL25Z128xxx4_flash.scf
  link misc: --remove
