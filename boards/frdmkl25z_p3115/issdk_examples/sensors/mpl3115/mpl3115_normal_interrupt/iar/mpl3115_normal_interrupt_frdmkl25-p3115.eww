<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>mpl3115_normal_interrupt_frdmkl25-p3115</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>mpl3115_normal_interrupt_frdmkl25-p3115</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>mpl3115_normal_interrupt_frdmkl25-p3115</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>mpl3115_normal_interrupt_frdmkl25-p3115</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/mpl3115_normal_interrupt_frdmkl25-p3115.ewp</path>
  </project>
</workspace>
