# IAR project led_demo_freedom_a000.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: MKL82Z128xxx7 NXP MKL82Z128xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CPU_MKL82Z128VLK7; CPU_IS_ARM_CORTEX_M0P=1; FREEDOM; FRDM_KL82Z
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050,Pe1105,Pe1305,Pa182
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../devices/MKL82Z7; ../../../../../../middleware/mcu-boot/targets/MKL82Z7/src; ../../../../../../middleware/mcu-boot/src/startup; ../../../../../../middleware/mcu-boot/src/include; ../../../../../../middleware/mcu-boot/apps/led_demo/src; ..; ../../../../../../devices/MKL82Z7
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BL_HAS_BOOTLOADER_CONFIG
  ILINK.IlinkOutputFile: led_demo_freedom_a000.out
  ILINK.IlinkIcfFile: MKL82Z128xxx7_application_0xA000.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group MKL82Z7
    ../: main.c
    ../../../../../../middleware/mcu-boot/apps/led_demo/src/: milliseconds_delay.h milliseconds_delay.c
  group device
    ../../../../../../devices/MKL82Z7/: fsl_device_registers.h MKL82Z7.h MKL82Z7_features.h system_MKL82Z7.c system_MKL82Z7.h
  group startup
    ../../../../../../middleware/mcu-boot/src/startup/: crt0.s startup.c
    ../../../../../../middleware/mcu-boot/targets/MKL82Z7/src/startup/iar/: startup_MKL82Z7.s
  group source/include
    ../../../../../../middleware/mcu-boot/src/include/: bootloader_core.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm0plus.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
