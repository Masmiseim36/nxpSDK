# Keil uVision project led_demo_freedom_a000.uvprojx, settings and files
target led_demo_freedom_a000 release (ARM-ADS)
  device: MKL82Z128VLK7 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.8.0
  cpu: CPUTYPE("Cortex-M0plus")
  output: led_demo_freedom_a000.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKL82Z128VLK7, CPU_IS_ARM_CORTEX_M0P=1, FREEDOM, FRDM_KL82Z
  c misc: --library_interface=armcc 
--diag_suppress=66,1296,186,170,2748,1461,1295,177,550 
--library_type=standardlib
  c include: ../../../../../../CMSIS/Include;../../../../../../devices/MKL82Z7;../../../../../../middleware/mcu-boot/targets/MKL82Z7/src;../../../../../../middleware/mcu-boot/src/startup;../../../../../../middleware/mcu-boot/src/include;../../../../../../middleware/mcu-boot/apps/led_demo/src;..;../../../../../../devices/MKL82Z7
  asm define: BL_HAS_BOOTLOADER_CONFIG=1
  asm misc: --cpreproc 
--diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MKL82Z128xxx7_application_0xa000.scf
  link misc: --remove 
--datacompressor 
off 
--feedback_type=unused,noiw 
--predefine="-D__ram_vector_table__=1"
  group MKL82Z7
    ../: main.c
    ../../../../../../middleware/mcu-boot/apps/led_demo/src/: milliseconds_delay.h milliseconds_delay.c
  group device
    ../../../../../../devices/MKL82Z7/: fsl_device_registers.h MKL82Z7.h MKL82Z7_features.h system_MKL82Z7.c system_MKL82Z7.h
  group startup
    ../../../../../../middleware/mcu-boot/targets/MKL82Z7/src/startup/arm/: startup_MKL82Z7.s
    ../../../../../../middleware/mcu-boot/src/startup/: startup.c
  group source-include
    ../../../../../../middleware/mcu-boot/src/include/: bootloader_core.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm0plus.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
