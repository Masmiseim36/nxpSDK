# IAR project led_demo_qspi_a000.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: MKL82Z128xxx7 NXP MKL82Z128xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CPU_MKL82Z128VLK7; CPU_IS_ARM_CORTEX_M0P=1; BL_TARGET_FLASH; BOOTLOADER_CONFIG; FRDM_KL82Z
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050,Pe1105,Pe1305,Pa182
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../middleware/mcu-boot/apps/demo_qspi/led_demo/src; ../../../../../../middleware/mcu-boot/src/include; ../../../../../../devices/MKL82Z7
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: led_demo_qspi_a000.out
  ILINK.IlinkIcfFile: MKL82Z128xxx7_qspi_a000.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group source/application
    ../../../../../../middleware/mcu-boot/apps/demo_qspi/led_demo/src/: led_demo_qspi.c led_bsp.h misc.c misc.h milliseconds_delay.h milliseconds_delay.c
  group source/startup
    ../../../../../../middleware/mcu-boot/apps/demo_qspi/led_demo/devices/MKL82Z7/startup/iar/: startup_MKL82Z7_qspi.s
    ../../../../../../middleware/mcu-boot/apps/demo_qspi/led_demo/devices/MKL82Z7/startup/: system_MKL82Z7_qspi.c system_MKL82Z7.h
  group source/include
    ../../../../../../middleware/mcu-boot/src/include/: bootloader_core.h
  group device
    ../../../../../../devices/MKL82Z7/: fsl_device_registers.h MKL82Z7.h MKL82Z7_features.h
  group startup
    ../../../../../../middleware/mcu-boot/src/startup/: startup.c
