# Keil uVision project led_demo_qspi_a000.uvprojx, settings and files
target led_demo_qspi_a000 release (ARM-ADS)
  device: MKL82Z128VLK7 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.8.0
  cpu: CPUTYPE("Cortex-M0plus")
  output: led_demo_qspi_a000.out
  AfterMake: fromelf.exe --bincombined  --output  "$L@L.bin"  "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKL82Z128VLK7, CPU_IS_ARM_CORTEX_M0P=1, BL_TARGET_FLASH, BOOTLOADER_CONFIG, FRDM_KL82Z
  c misc: --library_interface=armcc 
--diag_suppress=66,1296,186,170,2748,1461,1295,177,550 
--library_type=standardlib
  c include: ../../../../../../CMSIS/Include;../../../../../../middleware/mcu-boot/apps/demo_qspi/led_demo/src;../../../../../../middleware/mcu-boot/src/include;../../../../../../devices/MKL82Z7
  asm misc: --cpreproc 
--diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MKL82Z128xxx7_qspi_a000.scf
  link misc: --remove 
--datacompressor 
off 
--feedback_type=unused,noiw 
--predefine="-D__ram_vector_table__=1"
  group source-application
    ../../../../../../middleware/mcu-boot/apps/demo_qspi/led_demo/src/: led_demo_qspi.c led_bsp.h misc.c misc.h milliseconds_delay.h milliseconds_delay.c
  group source-startup
    ../../../../../../middleware/mcu-boot/apps/demo_qspi/led_demo/devices/MKL82Z7/startup/arm/: startup_MKL82Z7_qspi.s
    ../../../../../../middleware/mcu-boot/apps/demo_qspi/led_demo/devices/MKL82Z7/startup/: system_MKL82Z7_qspi.c system_MKL82Z7.h
  group device
    ../../../../../../devices/MKL82Z7/: fsl_device_registers.h MKL82Z7.h MKL82Z7_features.h
  group startup
    ../../../../../../middleware/mcu-boot/src/startup/: startup.c
  group source-include
    ../../../../../../middleware/mcu-boot/src/include/: bootloader_core.h
