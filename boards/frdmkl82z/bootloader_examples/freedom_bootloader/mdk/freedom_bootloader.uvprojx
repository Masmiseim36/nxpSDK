# Keil uVision project freedom_bootloader.uvprojx, settings and files
target freedom_bootloader debug (ARM-ADS)
  device: MKL82Z128VLK7 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.8.0
  cpu: CPUTYPE("Cortex-M0plus")
  output: freedom_bootloader.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKL82Z128VLK7, CPU_IS_ARM_CORTEX_M0P=1, FREEDOM, BL_TARGET_FLASH, FRDM_KL82Z, USB_STACK_BM
  c misc: --library_interface=armcc 
--diag_suppress=66,1296,186,170,2748,1461,1295,177,550 
--library_type=standardlib
  c include: ../../../../../CMSIS/Include;../../../../../middleware/mcu-boot/src;../../../../../middleware/mcu-boot/src/bootloader;../../../../../middleware/mcu-boot/src/include;../../../../../middleware/mcu-boot/src/startup;../../../../../middleware/mcu-boot/src/utilities;../../../../../middleware/mcu-boot/src/drivers;../../../../../middleware/mcu-boot/src/drivers/crc;../../../../../middleware/mcu-boot/src/drivers/microseconds;../../../../../middleware/mcu-boot/src/drivers/smc;../../../../../middleware/mcu-boot/targets/MKL82Z7/src;../../../../../middleware/mcu-boot/src/autobaud;../../../../../middleware/mcu-boot/src/bm_usb;../../../../../middleware/mcu-boot/src/security;../../../../../middleware/mcu-boot/src/drivers/ltc;../../../../../middleware/mcu-boot/src/drivers/mmcau;../../../../../middleware/mcu-boot/src/drivers/qspi;../../../../../devices/MKL82Z7;../../../../../devices/MKL82Z7/drivers;..;../../../../../devices/MKL82Z7/drivers;../../../../../devices/MKL82Z7/drivers;../../../../../devices/MKL82Z7;../../../../../devices/MKL82Z7/drivers;../../../../../devices/MKL82Z7/drivers;../../../../../devices/MKL82Z7/drivers;../../../../../devices/MKL82Z7/drivers;../../../../../devices/MKL82Z7/drivers;../../../../../devices/MKL82Z7/drivers;../../../../../devices/MKL82Z7/drivers;../../../../../middleware/usb/device;../../../../../middleware/usb/include;../../../../../middleware/usb/osa;../../../../../devices/MKL82Z7/drivers
  asm define: DEBUG, BL_HAS_BOOTLOADER_CONFIG=0
  asm misc: --cpreproc 
--diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1fffa000 size 0x18000
  scatter file: MKL82Z128xxx7_application_0x0000.scf
  link misc: --remove 
--datacompressor 
off 
--feedback_type=unused,noiw 
--predefine="-D__ram_vector_table__=1"
  group drivers
    ../../../../../devices/MKL82Z7/drivers/: fsl_clock.h fsl_clock.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_i2c.h fsl_i2c.c fsl_port.h fsl_dspi.h fsl_dspi.c fsl_crc.c fsl_crc.h fsl_intmux.h fsl_intmux.c fsl_common.h fsl_common.c
  group device
    ../../../../../devices/MKL82Z7/: fsl_device_registers.h MKL82Z7.h MKL82Z7_features.h system_MKL82Z7.c system_MKL82Z7.h
  group usb-device-source-khci
    ../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
  group usb-include
    ../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group osa
    ../../../../../middleware/usb/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group usb-device-class-hid
    ../: usb_device_hid.c usb_device_hid.h
  group usb-device-class-msc
    ../: usb_device_msc.c usb_device_msc.h usb_device_msc_ufi.c usb_device_msc_ufi.h
  group usb-device-source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
  group usb-device-class
    ../: usb_device_class.c usb_device_class.h
  group usb-device-include
    ../../../../../middleware/usb/device/: usb_device.h
  group startup
    ../../../../../middleware/mcu-boot/targets/MKL82Z7/src/startup/arm/: startup_MKL82Z7.s
    ../../../../../middleware/mcu-boot/src/startup/: ar_asm_macros.h startup.c
  group source-autobaud
    ../../../../../middleware/mcu-boot/src/autobaud/: autobaud.h
    ../../../../../middleware/mcu-boot/src/autobaud/src/: autobaud_irq.c
  group source-bootloader
    ../../../../../middleware/mcu-boot/src/bootloader/: bl_peripheral_interface.h bl_user_entry.h bl_version.h bootloader.h bl_command.h bl_context.h bl_peripheral.h bl_shutdown_cleanup.h bl_irq_common.h bl_app_crc_check.h bl_reliable_update.h
  group source-bootloader-src
    ../../../../../middleware/mcu-boot/src/bootloader/src/: bl_user_entry.c bl_main.c bl_context.c bl_exception_handler.c bl_tree_root.c bl_command.c bl_shutdown_cleanup.c bl_app_crc_check.c bl_misc.c bl_reliable_update.c lpuart_peripheral_interface.c dspi_peripheral_interface.c i2c_peripheral_interface.c usb_hid_msc_peripheral_interface.c
  group source-crc
    ../../../../../middleware/mcu-boot/src/crc/: crc16.h crc32.h
    ../../../../../middleware/mcu-boot/src/crc/src/: crc16.c crc32.c
  group source-include
    ../../../../../middleware/mcu-boot/src/include/: bootloader_common.h bootloader_core.h
  group source-memory
    ../../../../../middleware/mcu-boot/src/memory/: memory.h
  group source-memory-src
    ../../../../../middleware/mcu-boot/src/memory/src/: sram_init.h memory.c device_memory.h device_memory.c normal_memory.h normal_memory.c pattern_fill.s pattern_fill.h flash_memory.h flash_memory.c sram_init_cm0plus.c qspi_memory.c qspi_memory.h
  group source-packet
    ../../../../../middleware/mcu-boot/src/packet/: command_packet.h serial_packet.h
  group source-packet-src
    ../../../../../middleware/mcu-boot/src/packet/src/: serial_packet.c
  group source-property
    ../../../../../middleware/mcu-boot/src/property/: property.h
  group source-sbloader
    ../../../../../middleware/mcu-boot/src/sbloader/: sbloader.h sb_file_format.h
  group source-sbloader-src
    ../../../../../middleware/mcu-boot/src/sbloader/src/: sbloader.c
  group source-utilities
    ../../../../../middleware/mcu-boot/src/utilities/: fsl_rtos_abstraction.h fsl_assert.h vector_table_info.h kinetis_family.h
  group source-utilities-src
    ../../../../../middleware/mcu-boot/src/utilities/src/: fsl_assert.c fsl_rtos_abstraction.c
  group source-drivers-smc
    ../../../../../middleware/mcu-boot/src/drivers/smc/: smc.c smc.h
  group source-property-src
    ../../../../../middleware/mcu-boot/src/property/src/: property_kinetis.c
  group MKL82Z7
    ../../../../../middleware/mcu-boot/targets/MKL82Z7/src/: bootloader_config.h clock_config_MKL82Z7.c hardware_init_MKL82Z7.c memory_map_MKL82Z7.c peripherals_MKL82Z7.c peripherals_pinmux.h target_config.h bl_dspi_irq_config_MKL82Z7.c bl_i2c_irq_config_MKL82Z7.c bl_lpuart_irq_config_MKL82Z7.c external_memory_property_map_MKL82Z7.c
    ../../../../../middleware/mcu-boot/targets/common/src/: pinmux_utility_common.c bl_intmux_irq.c
  group source-usb-bm_composite
    ../../../../../middleware/mcu-boot/targets/MKL82Z7/src/: usb_device_config.h
    ../../../../../middleware/mcu-boot/src/bm_usb/: bootloader_hid_report_ids.h fat_directory_entry.h composite.h composite.c hid_bootloader.h hid_bootloader.c msc_disk.h msc_disk.c usb_descriptor.h usb_descriptor.c
  group source-drivers-mmcau
    ../../../../../middleware/mcu-boot/src/drivers/mmcau/: mmcau.h
  group source-security
    ../../../../../middleware/mcu-boot/src/security/: aes_security.h aes128_key_wrap_unwrap.h cbc_mac.h
  group source-security-src
    ../../../../../middleware/mcu-boot/src/security/src/: aes_security.c aes128_key_wrap_unwrap.c cbc_mac.c
  group source-drivers-ltc
    ../../../../../middleware/mcu-boot/src/drivers/ltc/: ltc.h
    ../../../../../middleware/mcu-boot/src/drivers/ltc/src/: ltc_aes_functions.c
  group source-drivers-qspi
    ../../../../../middleware/mcu-boot/src/drivers/qspi/: qspi.h
    ../../../../../middleware/mcu-boot/src/drivers/qspi/src/: qspi.c
  group source-drivers-microseconds
    ../../../../../middleware/mcu-boot/src/drivers/microseconds/: microseconds.h
    ../../../../../middleware/mcu-boot/src/drivers/microseconds/src/: microseconds_pit.c
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm0plus.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
target freedom_bootloader release (ARM-ADS)
  device: MKL82Z128VLK7 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.8.0
  cpu: CPUTYPE("Cortex-M0plus")
  output: freedom_bootloader.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKL82Z128VLK7, CPU_IS_ARM_CORTEX_M0P=1, FREEDOM, BL_TARGET_FLASH, FRDM_KL82Z, USB_STACK_BM
  c misc: as above
  c include: as above
  asm define: BL_HAS_BOOTLOADER_CONFIG=0
  asm misc: --cpreproc 
--diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MKL82Z128xxx7_application_0x0000.scf
  link misc: as above
