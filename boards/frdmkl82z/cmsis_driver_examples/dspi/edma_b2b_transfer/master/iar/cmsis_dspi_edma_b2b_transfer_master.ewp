# IAR project cmsis_dspi_edma_b2b_transfer_master.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL82Z128xxx7 NXP MKL82Z128xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKL82Z128VLK7; FRDM_KL82Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../../CMSIS/Driver/Include; ../../../../..; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../devices/MKL82Z7/drivers; ../../../../../../../devices/MKL82Z7/drivers; ../../../../../../../devices/MKL82Z7/drivers; ../../../../../../../devices/MKL82Z7/drivers; ../../../../../../../devices/MKL82Z7/drivers; ../../../../../../../devices/MKL82Z7/drivers; ../../../../../../../devices/MKL82Z7/drivers; ../../../../../../../devices/MKL82Z7/drivers; ../../../../../../../devices/MKL82Z7/cmsis_drivers; ../../../../../../../devices/MKL82Z7/drivers; ../../../../../../../devices/MKL82Z7; ../../../../../../../devices/MKL82Z7/utilities/str; ../../../../../../../devices/MKL82Z7/utilities/debug_console; ../../../../../../../components/uart; ../../../../../../../components/serial_manager; ../../../../../../../components/serial_manager; ../../../../../../../components/lists; ../../../../../../../devices/MKL82Z7/drivers; ../../../../../../../CMSIS/Driver/Include; ../../../../../../../CMSIS/Driver/Include; ../../../../../../../devices/MKL82Z7/template
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: cmsis_dspi_edma_b2b_transfer_master.out
  ILINK.IlinkIcfFile: MKL82Z128xxx7_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL82Z128VLK7; FRDM_KL82Z; FREEDOM
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: cmsis_dspi_edma_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
    ../../../../../../../devices/MKL82Z7/template/: RTE_Device.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MKL82Z7/drivers/: fsl_port.h fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_dspi.h fsl_dspi.c fsl_dspi_edma.h fsl_dspi_edma.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c
    ../../../../../../../devices/MKL82Z7/cmsis_drivers/: fsl_dspi_cmsis.h fsl_dspi_cmsis.c
  group device
    ../../../../../../../devices/MKL82Z7/: fsl_device_registers.h MKL82Z7.h MKL82Z7_features.h system_MKL82Z7.c system_MKL82Z7.h
  group utilities
    ../../../../../../../devices/MKL82Z7/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MKL82Z7/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/MKL82Z7/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../../components/uart/: uart.h lpuart_adapter.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../../../components/lists/: generic_list.h generic_list.c
  group startup
    ../../../../../../../devices/MKL82Z7/iar/: startup_MKL82Z7.s
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm0plus.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_SPI.h Driver_Common.h
