# Keil uVision project mbedtls_benchmark.uvprojx, settings and files
target mbedtls_benchmark debug (ARM-ADS)
  device: MKL82Z128VLK7 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.7.0-RC1
  cpu: CPUTYPE("Cortex-M0+")
  output: mbedtls_benchmark.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKL82Z128VLK7, PRINTF_ADVANCED_ENABLE=1, PRINTF_FLOAT_ENABLE=1, FREESCALE_KSDK_BM, MBEDTLS_CONFIG_FILE='\"ksdk_mbedtls_config.h\"', FRDM_KL82Z, FREEDOM
  c misc: --library_interface=armcc 
--diag_suppress=1296,186 
--diag_suppress=177
  c include: ..;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../middleware/mbedtls/include;../../../../../middleware/mbedtls/port/ksdk;../../../../../devices/MKL82Z7/drivers;../../../../../devices/MKL82Z7/drivers;../../../../../devices/MKL82Z7/drivers;../../../../../devices/MKL82Z7/drivers;../../../../../devices/MKL82Z7/drivers;../../../../../devices/MKL82Z7;../../../../../devices/MKL82Z7/utilities/str;../../../../../devices/MKL82Z7/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/serial_manager;../../../../../devices/MKL82Z7/drivers;../../../../../components/lists;../../../../../devices/MKL82Z7/drivers;../../../../../devices/MKL82Z7/drivers
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKL82Z128xxx7_flash.scf
  link misc: --remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x8000"
  group source
    ../: benchmark.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKL82Z7/drivers/: fsl_ltc.h fsl_ltc.c fsl_trng.c fsl_trng.h fsl_port.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c
  group mbedtls-mbedtls_include
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls-mbedtls_source
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c chacha20.c chachapoly.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c pkcs11.c
  group mbedtls-mbedtls_port
    ../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c
  group device
    ../../../../../devices/MKL82Z7/: fsl_device_registers.h MKL82Z7.h MKL82Z7_features.h system_MKL82Z7.c system_MKL82Z7.h
  group utilities
    ../../../../../devices/MKL82Z7/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MKL82Z7/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MKL82Z7/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: uart.h lpuart_adapter.c
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: generic_list.h generic_list.c
  group startup
    ../../../../../devices/MKL82Z7/arm/: startup_MKL82Z7.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm0plus.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
target mbedtls_benchmark release (ARM-ADS)
  device: MKL82Z128VLK7 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.7.0-RC1
  cpu: CPUTYPE("Cortex-M0+")
  output: mbedtls_benchmark.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKL82Z128VLK7, PRINTF_ADVANCED_ENABLE=1, PRINTF_FLOAT_ENABLE=1, FREESCALE_KSDK_BM, MBEDTLS_CONFIG_FILE='\"ksdk_mbedtls_config.h\"', FRDM_KL82Z, FREEDOM
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKL82Z128xxx7_flash.scf
  link misc: as above
