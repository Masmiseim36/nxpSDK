# Keil uVision project freertos_dspi.uvprojx, settings and files
target freertos_dspi debug (ARM-ADS)
  device: MKL82Z128VLK7 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.7.0-RC1
  cpu: CPUTYPE("Cortex-M0+")
  output: freertos_dspi.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKL82Z128VLK7, FRDM_KL82Z, FREEDOM, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc 
--diag_suppress=1296,186
  c include: ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM0;..;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../rtos/amazon-freertos/lib/include;../../../../../rtos/amazon-freertos/lib/include/private;../../../../../devices/MKL82Z7/drivers;../../../../../devices/MKL82Z7/drivers;../../../../../devices/MKL82Z7/drivers;../../../../../devices/MKL82Z7/drivers;../../../../../devices/MKL82Z7/drivers;../../../../../devices/MKL82Z7/drivers;../../../../../devices/MKL82Z7/drivers;../../../../../devices/MKL82Z7;../../../../../devices/MKL82Z7/utilities/str;../../../../../devices/MKL82Z7/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/serial_manager;../../../../../devices/MKL82Z7/drivers;../../../../../components/lists;../../../../../devices/MKL82Z7/drivers
  asm define: DEBUG
  asm include: ..;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKL82Z128xxx7_flash.scf
  link misc: --remove
  group source
    ../: freertos_dspi.c FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKL82Z7/drivers/: fsl_intmux.h fsl_intmux.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_dspi.h fsl_dspi.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_smc.h fsl_smc.c
  group drivers-freertos
    ../../../../../devices/MKL82Z7/drivers/: fsl_dspi_freertos.h fsl_dspi_freertos.c
  group amazon-freertos-license
    ../../../../../rtos/amazon-freertos/: LICENSE
  group amazon-freertos-include
    ../../../../../rtos/amazon-freertos/lib/include/: event_groups.h FreeRTOS.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
    ../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_wrappers.h portable.h projdefs.h stack_macros.h
  group amazon-freertos-FreeRTOS
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos-FreeRTOS-portable
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM0/: fsl_tickless_generic.h fsl_tickless_systick.c port.c portmacro.h
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
  group device
    ../../../../../devices/MKL82Z7/: fsl_device_registers.h MKL82Z7.h MKL82Z7_features.h system_MKL82Z7.c system_MKL82Z7.h
  group utilities
    ../../../../../devices/MKL82Z7/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MKL82Z7/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MKL82Z7/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: uart.h lpuart_adapter.c
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: generic_list.h generic_list.c
  group startup
    ../../../../../devices/MKL82Z7/arm/: startup_MKL82Z7.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm0plus.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
target freertos_dspi release (ARM-ADS)
  device: MKL82Z128VLK7 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.7.0-RC1
  cpu: CPUTYPE("Cortex-M0+")
  output: freertos_dspi.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKL82Z128VLK7, FRDM_KL82Z, FREEDOM, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc 
--diag_suppress=1296,186
  c include: as above
  asm define: NDEBUG
  asm include: ..;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKL82Z128xxx7_flash.scf
  link misc: --remove
