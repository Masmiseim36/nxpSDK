# IAR project dev_video_flexio_ov7670_bm.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL82Z128xxx7 NXP MKL82Z128xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: _DEBUG=1; DEBUG; CPU_MKL82Z128VLK7; USB_STACK_BM; SDK_I2C_BASED_COMPONENT_USED=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../ov7670; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../platform/drivers; ../../../../../../middleware/usb; ../../../../../../middleware/usb/osa; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/device; ../../../../../../components/video; ../../../../../../components/video/camera; ../../../../../../components/video/camera/device; ../../../../../../components/video/camera/receiver; ../../../../../../components/video/camera/device/ov7670; ../../../../../../components/video/camera/device/sccb; ../../../../../../middleware/usb/device; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/osa; ../../../../../../devices/MKL82Z7/drivers; ../../../../../../devices/MKL82Z7/drivers; ../../../../../../devices/MKL82Z7/drivers; ../../../../../../devices/MKL82Z7/drivers; ../../../../../../devices/MKL82Z7/drivers; ../../../../../../devices/MKL82Z7/drivers; ../../../../../../components/video/camera/receiver; ../../../../../../components/video/camera/device/ov7670; ../../../../../../components/video/camera/device/sccb; ../../../../../../components/video/camera/device; ../../../../../../components/video/camera; ../../../../../../devices/MKL82Z7/drivers; ../../../../../../devices/MKL82Z7/drivers; ../../../../../../devices/MKL82Z7/drivers; ../../../../../../devices/MKL82Z7; ../../../../../../devices/MKL82Z7/drivers; ../../../../../../devices/MKL82Z7/drivers; ../../../../../../devices/MKL82Z7/drivers; ../../../../../../devices/MKL82Z7/utilities/str; ../../../../../../devices/MKL82Z7/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/serial_manager; ../../../../../../components/lists
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: dev_video_flexio_ov7670_bm.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000
  ILINK.IlinkIcfFile: MKL82Z128xxx7_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; NDEBUG; CPU_MKL82Z128VLK7; USB_STACK_BM; SDK_I2C_BASED_COMPONENT_USED=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: usb_device_descriptor.c usb_device_descriptor.h video_camera.c video_camera.h usb_device_config.h
  group source/ov7670
    ../: fsl_flexio_camera_adapter.c fsl_flexio_camera_adapter.h fsl_video_common.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group usb/device/source
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
    ../: usb_device_ch9.c usb_device_ch9.h
  group usb/device/source/khci
    ../../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
  group usb/device/include
    ../../../../../../middleware/usb/device/: usb_device.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/video
    ../: usb_device_video.c usb_device_video.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group osa
    ../../../../../../middleware/usb/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group drivers
    ../../../../../../devices/MKL82Z7/drivers/: fsl_i2c.h fsl_i2c.c fsl_port.h fsl_flexio.c fsl_flexio.h fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_flexio_camera.c fsl_flexio_camera.h fsl_smc.h fsl_smc.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_sysmpu.h fsl_sysmpu.c
  group video
    ../../../../../../components/video/camera/receiver/: fsl_camera_receiver.h
    ../../../../../../components/video/camera/device/ov7670/: fsl_ov7670.h fsl_ov7670.c
    ../../../../../../components/video/camera/device/sccb/: fsl_sccb.h fsl_sccb.c
    ../../../../../../components/video/camera/device/: fsl_camera_device.h
    ../../../../../../components/video/camera/: fsl_camera.h
  group device
    ../../../../../../devices/MKL82Z7/: fsl_device_registers.h MKL82Z7.h MKL82Z7_features.h system_MKL82Z7.c system_MKL82Z7.h
  group startup
    ../../../../../../devices/MKL82Z7/iar/: startup_MKL82Z7.s
  group utilities
    ../../../../../../devices/MKL82Z7/utilities/: fsl_assert.c
    ../../../../../../devices/MKL82Z7/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MKL82Z7/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group component/uart
    ../../../../../../components/uart/: uart.h lpuart_adapter.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: generic_list.h generic_list.c
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm0plus.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
