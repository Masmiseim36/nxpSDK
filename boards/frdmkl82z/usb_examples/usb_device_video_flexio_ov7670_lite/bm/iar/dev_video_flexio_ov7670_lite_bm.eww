<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>dev_video_flexio_ov7670_lite_bm</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>dev_video_flexio_ov7670_lite_bm</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>dev_video_flexio_ov7670_lite_bm</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>dev_video_flexio_ov7670_lite_bm</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/dev_video_flexio_ov7670_lite_bm.ewp</path>
  </project>
</workspace>
