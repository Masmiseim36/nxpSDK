# IAR project cmsis_dspi_edma_b2b_transfer_master.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV10Z32xxx7 NXP MKV10Z32xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKV10Z32VLF7; FRDM_KV10Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../../CMSIS/Include; ../../../../../../../devices; ..; ../../../../../../../CMSIS/Driver/Include; ../../../../..; ../../../../../../../devices/MKV10Z7/drivers; ../../../../../../../devices/MKV10Z7/cmsis_drivers; ../../../../../../../devices/MKV10Z7/utilities; ../../../../../../../devices/MKV10Z7
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: cmsis_dspi_edma_b2b_transfer_master.out
  ILINK.IlinkIcfFile: MKV10Z32xxx7_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV10Z32VLF7; FRDM_KV10Z; FREEDOM
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../../devices/MKV10Z7/iar/: startup_MKV10Z7.s
    ../../../../../../../devices/MKV10Z7/: system_MKV10Z7.c system_MKV10Z7.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MKV10Z7/drivers/: fsl_uart.h fsl_uart.c fsl_port.h fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_dspi.h fsl_dspi.c fsl_dspi_edma.h fsl_dspi_edma.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
    ../../../../../../../devices/MKV10Z7/cmsis_drivers/: fsl_dspi_cmsis.h fsl_dspi_cmsis.c
  group source
    ../: cmsis_dspi_edma_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../../devices/MKV10Z7/utilities/: fsl_debug_console.c fsl_debug_console.h
