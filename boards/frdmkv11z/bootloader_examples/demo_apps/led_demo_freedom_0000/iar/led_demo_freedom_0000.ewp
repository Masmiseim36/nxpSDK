# IAR project led_demo_freedom_0000.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: MKV11Z128xxx7 NXP MKV11Z128xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CPU_MKV11Z128VLH7; CPU_IS_ARM_CORTEX_M0P=1; FREEDOM; FRDM_KV11Z75M
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050,Pe1105,Pe1305,Pa182
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../devices/MKV11Z7; ../../../../../../middleware/mcu-boot/targets/MKV11Z7/src; ../../../../../../middleware/mcu-boot/src/startup; ../../../../../../middleware/mcu-boot/src/include; ../../../../../../middleware/mcu-boot/apps/led_demo/src; ..; ../../../../../../devices/MKV11Z7/drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG; BL_HAS_BOOTLOADER_CONFIG
  ILINK.IlinkOutputFile: led_demo_freedom_0000.out
  ILINK.IlinkIcfFile: MKV11Z128xxx7_application_0x0000.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group board
    ../: pin_mux.c pin_mux.h
  group MKV11Z7
    ../: main.c
    ../../../../../../middleware/mcu-boot/apps/led_demo/src/: milliseconds_delay.h milliseconds_delay.c
  group drivers
    ../../../../../../devices/MKV11Z7/drivers/: fsl_port.h fsl_gpio.c fsl_gpio.h fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h
  group device
    ../../../../../../devices/MKV11Z7/: MKV11Z7.h MKV11Z7_features.h fsl_device_registers.h system_MKV11Z7.c system_MKV11Z7.h
  group startup
    ../../../../../../middleware/mcu-boot/src/startup/: crt0.s startup.c
    ../../../../../../middleware/mcu-boot/targets/MKV11Z7/src/startup/iar/: startup_MKV11Z7.s
  group source/include
    ../../../../../../middleware/mcu-boot/src/include/: bootloader_core.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm0plus.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
