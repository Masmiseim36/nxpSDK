# Keil uVision project freedom_bootloader.uvprojx, settings and files
target freedom_bootloader debug (ARM-ADS)
  device: MKV11Z128VLH7 NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: freedom_bootloader.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_MKV11Z128VLH7, CPU_IS_ARM_CORTEX_M0P=1, FREEDOM, BL_TARGET_FLASH, FRDM_KV11Z7, FSL_OSA_BM_TIMER_CONFIG=FSL_OSA_BM_TIMER_NONE
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -Wno-null-dereference  -Wno-unknown-attributes  -Wno-expansion-to-defined  -Wno-invalid-noreturn
  c include: ../../../../../CMSIS/Include;../../../../../middleware/mcu-boot/src;../../../../../middleware/mcu-boot/src/bootloader;../../../../../middleware/mcu-boot/src/include;../../../../../middleware/mcu-boot/src/startup;../../../../../middleware/mcu-boot/src/utilities;../../../../../middleware/mcu-boot/src/drivers;../../../../../middleware/mcu-boot/src/drivers/crc;../../../../../middleware/mcu-boot/src/drivers/microseconds;../../../../../middleware/mcu-boot/src/drivers/smc;../../../../../middleware/mcu-boot/targets/MKV11Z7/src;../../../../../middleware/mcu-boot/src/autobaud;../../../../../devices/MKV11Z7;../../../../../devices/MKV11Z7/drivers;..;../../../../../devices/MKV11Z7/drivers;../../../../../devices/MKV11Z7/drivers;../../../../../devices/MKV11Z7;../../../../../devices/MKV11Z7/drivers;../../../../../devices/MKV11Z7/drivers;../../../../../devices/MKV11Z7/drivers;../../../../../devices/MKV11Z7/drivers;../../../../../devices/MKV11Z7/drivers;../../../../../devices/MKV11Z7/drivers;../../../../../devices/MKV11Z7/drivers;../../../../../components/osa;../../../../../devices/MKV11Z7/drivers;../../../../../components/lists
  asm define: DEBUG, BL_HAS_BOOTLOADER_CONFIG=0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKV11Z128xxx7_application_0x0000.scf
  link misc: --remove --keep=*(.FlashConfig) --datacompressor off --predefine="-D__ram_vector_table__=1"
  group drivers
    ../../../../../devices/MKV11Z7/drivers/: fsl_clock.c fsl_clock.h fsl_flash.h fsl_ftfx_adapter.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_features.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_ftfx_utilities.h fsl_uart.c fsl_uart.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_port.h fsl_dspi.c fsl_dspi.h fsl_crc.c fsl_crc.h fsl_flexcan.c fsl_flexcan.h fsl_common.c fsl_common.h
  group device
    ../../../../../devices/MKV11Z7/: MKV11Z7.h MKV11Z7_features.h fsl_device_registers.h system_MKV11Z7.c system_MKV11Z7.h
  group startup
    ../../../../../middleware/mcu-boot/targets/MKV11Z7/src/startup/arm/: startup_MKV11Z7.s
    ../../../../../middleware/mcu-boot/src/startup/: ar_asm_macros.h startup.c
  group source-autobaud
    ../../../../../middleware/mcu-boot/src/autobaud/: autobaud.h
    ../../../../../middleware/mcu-boot/src/autobaud/src/: autobaud_irq.c
  group source-bootloader
    ../../../../../middleware/mcu-boot/src/bootloader/: bl_app_crc_check.h bl_command.h bl_context.h bl_irq_common.h bl_peripheral.h bl_peripheral_interface.h bl_shutdown_cleanup.h bl_user_entry.h bl_version.h bootloader.h bl_reliable_update.h
  group source-bootloader-src
    ../../../../../middleware/mcu-boot/src/bootloader/src/: bl_app_crc_check.c bl_command.c bl_context.c bl_exception_handler.c bl_main.c bl_misc.c bl_shutdown_cleanup.c bl_tree_root.c bl_user_entry.c bl_reliable_update.c dspi_peripheral_interface.c flexcan_peripheral_interface.c i2c_peripheral_interface.c uart_peripheral_interface.c
  group source-crc
    ../../../../../middleware/mcu-boot/src/crc/: crc16.h crc32.h
    ../../../../../middleware/mcu-boot/src/crc/src/: crc16.c crc32.c
  group source-include
    ../../../../../middleware/mcu-boot/src/include/: bootloader_common.h bootloader_core.h
  group source-memory
    ../../../../../middleware/mcu-boot/src/memory/: memory.h
  group source-memory-src
    ../../../../../middleware/mcu-boot/src/memory/src/: device_memory.c device_memory.h memory.c normal_memory.c normal_memory.h pattern_fill.h pattern_fill_gcc.S sram_init.h flash_memory.c flash_memory.h sram_init_cm0plus.c
  group source-packet
    ../../../../../middleware/mcu-boot/src/packet/: command_packet.h serial_packet.h
  group source-packet-src
    ../../../../../middleware/mcu-boot/src/packet/src/: serial_packet.c
  group source-property
    ../../../../../middleware/mcu-boot/src/property/: property.h
  group source-sbloader
    ../../../../../middleware/mcu-boot/src/sbloader/: sb_file_format.h sbloader.h
  group source-sbloader-src
    ../../../../../middleware/mcu-boot/src/sbloader/src/: sbloader.c
  group source-utilities
    ../../../../../middleware/mcu-boot/src/utilities/: fsl_assert.h fsl_rtos_abstraction.h vector_table_info.h kinetis_family.h
  group source-utilities-src
    ../../../../../middleware/mcu-boot/src/utilities/src/: debug_util.c fsl_assert.c fsl_rtos_abstraction.c
  group source-drivers-smc
    ../../../../../middleware/mcu-boot/src/drivers/smc/: smc.c smc.h
  group source-property-src
    ../../../../../middleware/mcu-boot/src/property/src/: property_kinetis.c
  group MKV11Z7
    ../../../../../middleware/mcu-boot/targets/MKV11Z7/src/: bootloader_config.h clock_config_MKV11Z7.c hardware_init_MKV11Z7.c memory_map_MKV11Z7.c peripherals_MKV11Z7.c peripherals_pinmux.h target_config.h
    ../../../../../middleware/mcu-boot/targets/common/src/: bl_dspi_irq_config_common.c bl_i2c_irq_config_common.c bl_uart_irq_config_common.c pinmux_utility_common.c
  group source-drivers-microseconds
    ../../../../../middleware/mcu-boot/src/drivers/microseconds/: microseconds.h
    ../../../../../middleware/mcu-boot/src/drivers/microseconds/src/: microseconds_sysclk.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm0plus.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
target freedom_bootloader release (ARM-ADS)
  device: MKV11Z128VLH7 NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: freedom_bootloader.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_MKV11Z128VLH7, CPU_IS_ARM_CORTEX_M0P=1, FREEDOM, BL_TARGET_FLASH, FRDM_KV11Z7, FSL_OSA_BM_TIMER_CONFIG=FSL_OSA_BM_TIMER_NONE
  c misc: as above
  c include: as above
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKV11Z128xxx7_application_0x0000.scf
  link misc: as above
