# IAR project cmsis_i2c_read_accel_value_transfer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV11Z128xxx7 NXP MKV11Z128xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKV11Z128VLH7; FRDM_KV11Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..; ../../../../../../CMSIS/Driver/Include; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MKV11Z7/drivers; ../../../../../../devices/MKV11Z7/cmsis_drivers; ../../../../../../devices/MKV11Z7; ../../../../../../devices/MKV11Z7/utilities/io; ../../../../../../devices/MKV11Z7/utilities/str; ../../../../../../devices/MKV11Z7/utilities/log; ../../../../../../devices/MKV11Z7/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: cmsis_i2c_read_accel_value_transfer.out
  ILINK.IlinkIcfFile: MKV11Z128xxx7_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV11Z128VLH7; FRDM_KV11Z; FREEDOM
  ICCARM.CCOptLevel: 3
  group source
    ../: cmsis_i2c_read_accel_value_transfer.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MKV11Z7/drivers/: fsl_port.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_i2c.h fsl_i2c.c fsl_i2c_edma.c fsl_i2c_edma.h fsl_flash.c fsl_flash.h fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c
    ../../../../../../devices/MKV11Z7/cmsis_drivers/: fsl_i2c_cmsis.h fsl_i2c_cmsis.c
  group startup
    ../../../../../../devices/MKV11Z7/: system_MKV11Z7.c system_MKV11Z7.h
    ../../../../../../devices/MKV11Z7/iar/: startup_MKV11Z7.s
  group utilities
    ../../../../../../devices/MKV11Z7/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../devices/MKV11Z7/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../devices/MKV11Z7/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MKV11Z7/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
