# IAR project log_bm.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV11Z128xxx7 NXP MKV11Z128xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKV11Z128VLH7; FRDM_KV11Z; FREEDOM; DEBUG_CONSOLE_RX_ENABLE=0; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MKV11Z7/drivers; ../../../../../../devices/MKV11Z7/utilities; ../../../../../../components/lists; ../../../../../../components/panic; ../../../../../../components/serial_manager; ../../../../../../components/osa; ../../../../../../components/log; ../../../../../../devices/MKV11Z7; ../../../../../../devices/MKV11Z7/utilities/str; ../../../../../../devices/MKV11Z7/utilities/debug_console; ../../../../../../components/uart; ../../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: log_bm.out
  ILINK.IlinkIcfFile: MKV11Z128xxx7_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV11Z128VLH7; FRDM_KV11Z; FREEDOM; DEBUG_CONSOLE_RX_ENABLE=0; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: log_main.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MKV11Z7/drivers/: fsl_gpio.h fsl_gpio.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_uart.h fsl_uart.c fsl_port.h fsl_smc.h fsl_smc.c
  group utilities
    ../../../../../../devices/MKV11Z7/utilities/: fsl_shell.c fsl_shell.h fsl_assert.c
    ../../../../../../devices/MKV11Z7/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MKV11Z7/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/panic
    ../../../../../../components/panic/: fsl_component_panic.h fsl_component_panic.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.c
  group component/log
    ../../../../../../components/log/: fsl_component_log.h fsl_component_log_config.h fsl_component_log.c fsl_component_log_backend_debugconsole.c fsl_component_log_backend_debugconsole.h fsl_component_log_backend_ringbuffer.c fsl_component_log_backend_ringbuffer.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group device
    ../../../../../../devices/MKV11Z7/: fsl_device_registers.h MKV11Z7.h MKV11Z7_features.h system_MKV11Z7.c system_MKV11Z7.h
  group startup
    ../../../../../../devices/MKV11Z7/iar/: startup_MKV11Z7.s
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm0plus.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
