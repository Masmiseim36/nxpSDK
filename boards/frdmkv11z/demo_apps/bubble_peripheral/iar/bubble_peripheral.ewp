# IAR project bubble_peripheral.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV11Z128xxx7 NXP MKV11Z128xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKV11Z128VLH7; PRINTF_ADVANCED_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; FRDM_KV11Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../devices/MKV11Z7/drivers; ../../../../../components/fxos8700cq; ../../../../../devices/MKV11Z7/utilities/debug_console_lite; ../../../../../devices/MKV11Z7; ../../../../../components/uart; ../../../../../components/lists; ../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: bubble_peripheral.out
  ILINK.IlinkIcfFile: MKV11Z128xxx7_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV11Z128VLH7; PRINTF_ADVANCED_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; FRDM_KV11Z; FREEDOM
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: bubble.c
  group board
    ../: pin_mux.c pin_mux.h peripherals.c peripherals.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKV11Z7/drivers/: fsl_ftm.c fsl_ftm.h fsl_i2c.h fsl_i2c.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_smc.h fsl_smc.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_uart.h fsl_uart.c
  group accel
    ../../../../../components/fxos8700cq/: fsl_fxos.h fsl_fxos.c
  group utilities
    ../../../../../devices/MKV11Z7/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group device
    ../../../../../devices/MKV11Z7/: fsl_device_registers.h MKV11Z7.h MKV11Z7_features.h system_MKV11Z7.c system_MKV11Z7.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MKV11Z7/iar/: startup_MKV11Z7.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm0plus.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
