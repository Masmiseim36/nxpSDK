# Keil uVision project mc_pmsm.uvprojx, settings and files
target mc_pmsm debug (ARM-ADS)
  device: MKV11Z128VLH7 NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: mc_pmsm.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKV11Z128VLH7, ARM_MATH_CM0PLUS, FRDM_KV11Z, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;..;../../../../../middleware/motor_control/boards/frdmkv11z;../../../../../devices/MKV11Z7/drivers;../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/AMCLIB;../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/AMCLIB/Include;../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/GDFLIB;../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/GDFLIB/Include;../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/GFLIB;../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/GFLIB/Include;../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/GMCLIB;../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/GMCLIB/Include;../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/MLIB;../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/MLIB/Include;../../../../../devices/MKV11Z7;../../../../../devices/MKV11Z7/utilities/io;../../../../../devices/MKV11Z7/utilities/str;../../../../../devices/MKV11Z7/utilities/log;../../../../../devices/MKV11Z7/utilities;../../../../../middleware/motor_control/pmsm;../../../../../middleware/motor_control/pmsm/mc_algorithms;../../../../../middleware/motor_control/pmsm/mc_state_machine;../../../../../middleware/motor_control/pmsm/state_machine;../../../../../middleware/motor_control/freemaster/freemaster_drv
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKV11Z128xxx7_flash.scf
  link misc: ../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/AMCLIB/AMCLIB.lib 
../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/GFLIB/GFLIB.lib 
../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/GDFLIB/GDFLIB.lib 
../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/GMCLIB/GMCLIB.lib 
../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/MLIB/MLIB.lib 
--remove
  group mc_drivers
    ../: mcdrv_adc_adc16.h mcdrv_adc_adc16.c mcdrv_pwm3ph_ftm.c mcdrv_pwm3ph_ftm.h
  group source
    ../: main.c m1_pmsm_appconfig.h
    ../../../../../middleware/motor_control/pmsm/: freemaster_cfg.h fm_tsa_pmsm.h fm_tsa_pmsm.c
  group board
    ../: mcdrv_frdmkv11z.c mcdrv_frdmkv11z.h mcdrv.h pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKV11Z7/drivers/: fsl_sim.h fsl_sim.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_port.h fsl_dmamux.h fsl_dmamux.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c
  group rtcesl/amclib
    ../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/AMCLIB/Include/: amclib.h AMCLIB_AngleTrackObsrv_F32.h AMCLIB_CtrlFluxWkng_A32.h AMCLIB_PMSMBemfObsrvDQ_A32.h AMCLIB_PMSMBemfObsrvDQHw_A32.h AMCLIB_PMSMBemfObsrvAB_A32.h AMCLIB_PMSMBemfObsrvABHw_A32.h AMCLIB_TrackObsrv_F32.h amclib_types.h
  group rtcesl/gdflib
    ../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/GDFLIB/Include/: gdflib.h GDFLIB_FilterExp_F32.h GDFLIB_FilterIIR1_F32.h GDFLIB_FilterIIR2_F32.h GDFLIB_FilterMA_A32.h GDFLIB_FilterMA_A32_Asmi.h gdflib_types.h
  group rtcesl/gflib
    ../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/GFLIB/Include/: gflib.h GFLIB_Atan_F32.h GFLIB_AtanYX_F32.h GFLIB_AtanYXHw_F32.h GFLIB_CtrlBetaIPp_A32.h GFLIB_CtrlPIp_A32.h GFLIB_DFlexRamp_A32.h GFLIB_DFlexRampHw_A32.h GFLIB_DRamp_F16.h GFLIB_DRamp_F32.h GFLIB_FlexRamp_A32.h GFLIB_FlexRampHw_A32.h GFLIB_Hyst_F16_Asmi.h GFLIB_Integrator_A32.h GFLIB_Limit_F16.h GFLIB_Limit_F32.h GFLIB_LowerLimit_F16.h GFLIB_LowerLimit_F32.h GFLIB_Lut_F16_Asmi.h GFLIB_Lut_F32.h GFLIB_LutPer_F16_Asmi.h GFLIB_LutPer_F32.h GFLIB_Ramp_F16.h GFLIB_Ramp_F16_Asmi.h GFLIB_Ramp_F32.h GFLIB_Ramp_F32_Asmi.h GFLIB_SinCos_A32.h GFLIB_Sqrt_F16.h GFLIB_Sqrt_F32.h GFLIB_SqrtHw_F16.h GFLIB_SqrtHw_F16_Asmi.h GFLIB_SqrtHw_F32.h GFLIB_SqrtHw_F32_Asmi.h gflib_types.h GFLIB_UpperLimit_F16.h GFLIB_UpperLimit_F32.h GFLIB_VectorLimit1_F16.h GFLIB_VectorLimit1Hw_F16.h
  group rtcesl/gmclib
    ../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/GMCLIB/Include/: gmclib.h GMCLIB_Clark_F16_Asmi.h GMCLIB_Decoupling_A32.h GMCLIB_ElimDcBusRip_A32.h GMCLIB_ElimDcBusRip_F16.h GMCLIB_ElimDcBusRipHw_A32.h GMCLIB_ElimDcBusRipHw_F16.h GMCLIB_Park_F16_Asmi.h GMCLIB_Svm_F16.h gmclib_types.h
  group rtcesl/mlib
    ../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/MLIB/Include/: asm_mac.h mlib.h MLIB_Abs_F16.h MLIB_Abs_F16_Asmi.h MLIB_Abs_F32.h MLIB_Abs_F32_Asmi.h MLIB_Add_A32.h MLIB_Add_A32_Asmi.h MLIB_Add_F16.h MLIB_Add_F16_Asmi.h MLIB_Add_F32.h MLIB_Add_F32_Asmi.h MLIB_Add4_F16.h MLIB_Add4_F16_Asmi.h MLIB_Add4_F32.h MLIB_Add4_F32_Asmi.h MLIB_BiShift_F16.h MLIB_BiShift_F16_Asmi.h MLIB_BiShift_F32.h MLIB_BiShift_F32_Asmi.h MLIB_Clb_F16_Asmi.h MLIB_Clb_F32.h MLIB_Clb_F32_Asmi.h MLIB_Conv_F32.h MLIB_Div_A32_Asm.h MLIB_Div_F16_Asm.h MLIB_Div_F32_Asm.h MLIB_Div1Q_A32_Asm.h MLIB_Div1Q_F16_Asm.h MLIB_Div1Q_F32_Asm.h MLIB_DivHw_A32_Asm.h MLIB_DivHw_F16_Asm.h MLIB_DivHw_F32.h MLIB_DivHw_F32_Asm.h MLIB_DivHw1Q_A32_Asm.h MLIB_DivHw1Q_F16_Asm.h MLIB_DivHw1Q_F32_Asm.h MLIB_Log2_U16_Asmi.h MLIB_Mac_A32.h MLIB_Mac_F16.h MLIB_Mac_F16_Asmi.h MLIB_Mac_F32.h MLIB_Mac_F32_Asmi.h MLIB_Mac4_F32.h MLIB_Mac4Rnd_F16.h MLIB_Mac4Rnd_F16_Asmi.h MLIB_Mac4Rnd_F32_Asm.h MLIB_MacRnd_A32.h MLIB_MacRnd_A32_Asmi.h MLIB_MacRnd_F16.h MLIB_MacRnd_F16_Asmi.h MLIB_MacRnd_F32.h MLIB_MacRnd_F32_Asmi.h MLIB_MMDVSQ.h MLIB_Mnac_A32.h MLIB_Mnac_F16.h MLIB_Mnac_F16_Asmi.h MLIB_Mnac_F32.h MLIB_Mnac_F32_Asmi.h MLIB_MnacRnd_A32.h MLIB_MnacRnd_A32_Asmi.h MLIB_MnacRnd_F16.h MLIB_MnacRnd_F16_Asmi.h MLIB_MnacRnd_F32.h MLIB_MnacRnd_F32_Asmi.h MLIB_Msu_A32.h MLIB_Msu_F16.h MLIB_Msu_F16_Asmi.h MLIB_Msu_F32.h MLIB_Msu_F32_Asmi.h MLIB_Msu4_F32.h MLIB_Msu4Rnd_F16.h MLIB_Msu4Rnd_F16_Asmi.h MLIB_Msu4Rnd_F32_Asm.h MLIB_MsuRnd_A32.h MLIB_MsuRnd_A32_Asmi.h MLIB_MsuRnd_F16.h MLIB_MsuRnd_F16_Asmi.h MLIB_MsuRnd_F32.h MLIB_MsuRnd_F32_Asmi.h MLIB_Mul_A32.h MLIB_Mul_A32_Asmi.h MLIB_Mul_F16.h MLIB_Mul_F16_Asmi.h MLIB_Mul_F32.h MLIB_Mul_F32_Asmi.h MLIB_MulRnd_A32.h MLIB_MulRnd_A32_Asmi.h MLIB_MulRnd_F16.h MLIB_MulRnd_F16_Asmi.h MLIB_MulRnd_F32.h MLIB_MulRnd_F32_Asmi.h MLIB_Neg_F16.h MLIB_Neg_F16_Asmi.h MLIB_Neg_F32.h MLIB_Neg_F32_Asmi.h MLIB_Rcp_A32_Asm.h MLIB_Rcp1Q_A32_Asm.h MLIB_RcpHw_A32_Asm.h MLIB_RcpHw1Q_A32_Asmi.h MLIB_Rnd_F32.h MLIB_Rnd_F32_Asmi.h MLIB_Sat_A32.h MLIB_Sat_A32_Asmi.h MLIB_Shift_F16.h MLIB_Shift_F16_Asmi.h MLIB_Shift_F32.h MLIB_Shift_F32_Asmi.h MLIB_Sign_F16_Asmi.h MLIB_Sign_F32_Asmi.h MLIB_Sub_A32.h MLIB_Sub_A32_Asmi.h MLIB_Sub_F16.h MLIB_Sub_F16_Asmi.h MLIB_Sub_F32.h MLIB_Sub_F32_Asmi.h MLIB_Sub4_F16.h MLIB_Sub4_F16_Asmi.h MLIB_Sub4_F32.h MLIB_Sub4_F32_Asmi.h mlib_types.h RTCESL_cfg.h
  group startup
    ../../../../../devices/MKV11Z7/: system_MKV11Z7.c system_MKV11Z7.h
    ../../../../../devices/MKV11Z7/arm/: startup_MKV11Z7.s
  group utilities
    ../../../../../devices/MKV11Z7/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MKV11Z7/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MKV11Z7/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MKV11Z7/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group mc_algorithms
    ../../../../../middleware/motor_control/pmsm/mc_algorithms/: pmsm_control.c pmsm_control.h
  group mc_state_machine
    ../../../../../middleware/motor_control/pmsm/mc_state_machine/: m1_sm_demo.c m1_sm_demo.h
  group state_machine
    ../../../../../middleware/motor_control/pmsm/state_machine/: state_machine.c state_machine.h
  group freemaster
    ../../../../../middleware/motor_control/freemaster/freemaster_drv/: freemaster_tsa.h freemaster_tsa.c freemaster_sfio.c freemaster_serial.c freemaster_scope.c freemaster_rec.h freemaster_rec.c freemaster_protocol.h freemaster_protocol.c freemaster_private.h freemaster_pipes.c freemaster_lin.c freemaster_defcfg.h freemaster_can.c freemaster_bdm.c freemaster_appcmd.c freemaster_Kxx.h freemaster_Kxx.c freemaster.h
target mc_pmsm release (ARM-ADS)
  device: MKV11Z128VLH7 NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: mc_pmsm.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKV11Z128VLH7, ARM_MATH_CM0PLUS, FRDM_KV11Z, FREEDOM
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKV11Z128xxx7_flash.scf
  link misc: as above
