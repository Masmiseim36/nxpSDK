# Keil uVision project power_manager.uvprojx, settings and files
target power_manager debug (ARM-ADS)
  device: MKV11Z128VLH7 NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: power_manager.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_MKV11Z128VLH7, FRDM_KV11Z, FREEDOM
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../devices/MKV11Z7/utilities/debug_console_lite;../../../../../devices/MKV11Z7/drivers;../../../../../devices/MKV11Z7/utilities;../../../../../devices/MKV11Z7;../../../../../components/uart;../../../../../components/lists;../../../../../CMSIS/Include
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKV11Z128xxx7_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
  group board
    ../: peripherals.c peripherals.h pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source
    ../: power_manager.h power_manager.c
  group doc
    ../: readme.txt
  group utilities
    ../../../../../devices/MKV11Z7/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../devices/MKV11Z7/drivers/: fsl_port.h fsl_llwu.h fsl_llwu.c fsl_pmc.h fsl_pmc.c fsl_smc.h fsl_smc.c fsl_rcm.c fsl_rcm.h fsl_lptmr.c fsl_lptmr.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_uart.h fsl_uart.c
  group utilities/utilities
    ../../../../../devices/MKV11Z7/utilities/: fsl_notifier.c fsl_notifier.h
  group device
    ../../../../../devices/MKV11Z7/: fsl_device_registers.h MKV11Z7.h MKV11Z7_features.h system_MKV11Z7.c system_MKV11Z7.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MKV11Z7/arm/: startup_MKV11Z7.S
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm0plus.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
target power_manager release (ARM-ADS)
  device: MKV11Z128VLH7 NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: power_manager.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_MKV11Z128VLH7, FRDM_KV11Z, FREEDOM
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKV11Z128xxx7_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
