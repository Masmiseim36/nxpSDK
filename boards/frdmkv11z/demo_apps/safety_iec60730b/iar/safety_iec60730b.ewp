# IAR project safety_iec60730b.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV11Z128xxx7 NXP MKV11Z128xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKV11Z128VLH7; FRDM_KV11Z; FREEDOM; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../middleware/safety_iec60730b/boards/frdmkv11z; ../../..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MKV11Z7; ..; ../../../../../middleware/safety_iec60730b/dev/frdmkv11z; ../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm0/register; ../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm0/ram; ../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm0/flash; ../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm0/stack; ../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm0/programCounter; ../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm0; ../../../../../middleware/safety_iec60730b/safety/v4_0; ../../../../../middleware/safety_iec60730b/safety/v4_0/compiler; ../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/wdog; ../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/dio; ../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/clock; ../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/aio; ../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/tsi; ../../../../../middleware/safety_iec60730b/boards/common/cm0/startup/cm0; ../../../../../devices/MKV11Z7/iar; ../../../../../devices/MKV11Z7/drivers; ../../../../../devices/MKV11Z7/utilities/str; ../../../../../devices/MKV11Z7/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../middleware/freemaster/src/common; ../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial; ../../../../../middleware/freemaster/src/drivers/mcuxsdk/can; ../../../../../middleware/freemaster/src/platforms/gen32le; ../../../../../devices/MKV11Z7/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm0; ../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm0/register; ../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm0/ram; ../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm0/flash; ../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm0/stack; ../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm0/programCounter; ../../../../../middleware/safety_iec60730b/safety/v4_0; ../../../../../middleware/safety_iec60730b/safety/v4_0/compiler; ../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/wdog; ../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/dio; ../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/clock; ../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/aio; ../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/tsi
  postbuild: ielftool --fill 0xFF;c_checksumStart-c_checksumEnd+3 --checksum __checksum:2,crc16,0x0;c_checksumStart-c_checksumEnd+3  --verbose "$TARGET_PATH$" "$TARGET_PATH$"
  ILINK.IlinkOutputFile: safety_iec60730b.out
  ILINK.IlinkIcfFile: linker/frdmkv11z_safety.icf
  ILINK.IlinkExtraOptions: --place_holder __checksum,4,.checksum,4; --keep=__checksum
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/safety_iec60730b/safety/v4_0/IEC60730_CM0_Class_B_IAR_v4_0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group source
    ../: main.c freemaster_cfg.h safety_test_items.h safety_test_items.c isr.h safety_config.h project_setup_frdmkv11z.h project_setup_frdmkv11z.c safety_cm0_kinetis.c safety_cm0_kinetis.h
  group doc
    ../: readme.txt
  group board
    ../: pin_mux.c pin_mux.h clock_config.c clock_config.h board.c board.h
  group tools/srec
    ../: srecord-1.64.zip
  group linker
    linker/: frdmkv11z_safety.icf
  group GUI
    ../GUI/: safety.pmp
  group device
    ../../../../../devices/MKV11Z7/: system_MKV11Z7.c system_MKV11Z7.h MKV11Z7.h MKV11Z7_features.h fsl_device_registers.h
  group cpu
    ../../../../../middleware/safety_iec60730b/boards/common/cm0/startup/cm0/: start.c startup_iar.c vectors_iar.c vectors_iar.h
  group IEC60730_Class_B
    ../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm0/: iec60730b_core.h
    ../../../../../middleware/safety_iec60730b/safety/v4_0/: iec60730b.h
  group IEC60730_Class_B/aio
    ../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/aio/: iec60730b_aio.h
  group IEC60730_Class_B/clock
    ../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/clock/: iec60730b_clock.h
  group IEC60730_Class_B/dio
    ../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/dio/: iec60730b_dio.h iec60730b_dio_ext.h
  group IEC60730_Class_B/tsi
    ../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/tsi/: iec60730b_tsi.h
  group IEC60730_Class_B/watchdog
    ../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/wdog/: iec60730b_wdog.c iec60730b_wdog.h
  group IEC60730_Class_B/compiler
    ../../../../../middleware/safety_iec60730b/safety/v4_0/compiler/: asm_mac_common.h
  group IEC60730_Class_B/flash
    ../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm0/flash/: iec60730b_cm0_flash.h
  group IEC60730_Class_B/programCounter
    ../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm0/programCounter/: iec60730b_cm0_pc.h iec60730b_cm0_pc_object.S
  group IEC60730_Class_B/ram
    ../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm0/ram/: iec60730b_cm0_ram.h
  group IEC60730_Class_B/register
    ../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm0/register/: iec60730b_cm0_reg.h
  group IEC60730_Class_B/stack
    ../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm0/stack/: iec60730b_cm0_stack.h
  group drivers
    ../../../../../devices/MKV11Z7/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_uart.c fsl_uart.h fsl_port.h fsl_smc.c fsl_smc.h fsl_gpio.c fsl_gpio.h
  group utilities
    ../../../../../devices/MKV11Z7/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MKV11Z7/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MKV11Z7/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: uart.h uart_adapter.c
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group freemaster
    ../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_can.c freemaster_can.h freemaster_defcfg.h freemaster_pdbdm.c freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_serial.c freemaster_serial.h freemaster_sha.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h
  group freemaster/drivers/mcuxsdk/can
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mcan.c freemaster_mcan.h freemaster_mscan.c freemaster_mscan.h
  group freemaster/drivers/mcuxsdk/serial
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_usb.c freemaster_serial_usb.h
  group freemaster/platforms
    ../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm0plus.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
