# IAR project dspi_half_duplex_int_master.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV11Z128xxx7 NXP MKV11Z128xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKV11Z128VLH7; FRDM_KV11Z; FREEDOM; PRINTF_ADVANCED_ENABLE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../../../CMSIS/Include; ../../../../../../../../devices; ..; ../../../../../..; ../../../../../../../../devices/MKV11Z7/drivers; ../../../../../../../../devices/MKV11Z7; ../../../../../../../../devices/MKV11Z7/utilities/io; ../../../../../../../../devices/MKV11Z7/utilities/str; ../../../../../../../../devices/MKV11Z7/utilities/log; ../../../../../../../../devices/MKV11Z7/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: dspi_half_duplex_int_master.out
  ILINK.IlinkIcfFile: MKV11Z128xxx7_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV11Z128VLH7; FRDM_KV11Z; FREEDOM; PRINTF_ADVANCED_ENABLE=1
  ICCARM.CCOptLevel: 3
  group source
    ../: dspi_half_duplex_int_master.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../../devices/MKV11Z7/drivers/: fsl_clock.h fsl_clock.c fsl_flash.c fsl_flash.h fsl_common.h fsl_common.c fsl_uart.h fsl_uart.c fsl_port.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c fsl_dspi.h fsl_dspi.c
  group startup
    ../../../../../../../../devices/MKV11Z7/: system_MKV11Z7.c system_MKV11Z7.h
    ../../../../../../../../devices/MKV11Z7/iar/: startup_MKV11Z7.s
  group utilities
    ../../../../../../../../devices/MKV11Z7/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../../../devices/MKV11Z7/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../../../devices/MKV11Z7/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../../devices/MKV11Z7/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
