# Keil uVision project dspi_half_duplex_polling_master.uvprojx, settings and files
target dspi_half_duplex_polling_master Debug (ARM-ADS)
  device: MKV11Z128VLH7 NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: dspi_half_duplex_polling_master.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKV11Z128VLH7, FRDM_KV11Z, FREEDOM, PRINTF_ADVANCED_ENABLE=1
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../../../CMSIS/Include;../../../../../../../../devices;..;../../../../../..;../../../../../../../../devices/MKV11Z7/drivers;../../../../../../../../devices/MKV11Z7;../../../../../../../../devices/MKV11Z7/utilities/io;../../../../../../../../devices/MKV11Z7/utilities/str;../../../../../../../../devices/MKV11Z7/utilities/log;../../../../../../../../devices/MKV11Z7/utilities
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKV11Z128xxx7_flash.scf
  link misc: --remove
  group source
    ../: dspi_half_duplex_polling_master.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../../devices/MKV11Z7/drivers/: fsl_clock.h fsl_clock.c fsl_flash.c fsl_flash.h fsl_common.h fsl_common.c fsl_uart.h fsl_uart.c fsl_port.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c fsl_dspi.h fsl_dspi.c
  group startup
    ../../../../../../../../devices/MKV11Z7/: system_MKV11Z7.c system_MKV11Z7.h
    ../../../../../../../../devices/MKV11Z7/arm/: startup_MKV11Z7.s
  group utilities
    ../../../../../../../../devices/MKV11Z7/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../../../devices/MKV11Z7/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../../../devices/MKV11Z7/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../../devices/MKV11Z7/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
target dspi_half_duplex_polling_master Release (ARM-ADS)
  device: MKV11Z128VLH7 NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: dspi_half_duplex_polling_master.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKV11Z128VLH7, FRDM_KV11Z, FREEDOM, PRINTF_ADVANCED_ENABLE=1
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKV11Z128xxx7_flash.scf
  link misc: --remove
