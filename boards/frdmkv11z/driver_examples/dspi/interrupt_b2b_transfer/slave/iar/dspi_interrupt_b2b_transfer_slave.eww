<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>dspi_interrupt_b2b_transfer_slave</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>dspi_interrupt_b2b_transfer_slave</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>dspi_interrupt_b2b_transfer_slave</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>dspi_interrupt_b2b_transfer_slave</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/dspi_interrupt_b2b_transfer_slave.ewp</path>
  </project>
</workspace>
