# IAR project flashloader_loader.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV31F512xxx12 NXP MKV31F512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKV31F512VLL12; BL_TARGET_FLASH; FRDM_KV31F
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050,Pe1105,Pe1305,Pa182
  ICCARM.CCIncludePath2: ../../flashloader/iar; ../../../../../middleware/mcu-boot/targets/MKV31F51212/src; ../../../../../devices/MKV31F51212/drivers; ../../../../../devices/MKV31F51212; ../../../../../middleware/mcu-boot/src/bootloader; ../../../../../middleware/mcu-boot/src/include; ../../../../../middleware/mcu-boot/src/utilities; ../../../../../middleware/mcu-boot/src/startup; ../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; LITE_FOOTPRINT
  AARM.AUserIncludes: ../../../../../middleware/mcu-boot/src/include
  OBJCOPY.OOCOutputFile: generic.srec
  ILINK.IlinkOutputFile: flashloader_loader.out
  ILINK.IlinkIcfFile: ../../../../../middleware/mcu-boot/targets/common/linker/iar/MKV31F51212/MKV31F512xxx12_flashloader_loader.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV31F512VLL12; BL_TARGET_FLASH; FRDM_KV31F
  AARM.ADefines: NDEBUG; LITE_FOOTPRINT
  group doc
    ../: readme.txt
  group MKV31F51212
    ../../../../../middleware/mcu-boot/targets/MKV31F51212/src/: bootloader_config.h target_config.h
  group drivers
    ../../../../../devices/MKV31F51212/drivers/: fsl_clock.h fsl_clock.c fsl_uart.h fsl_uart.c fsl_common.h fsl_common.c
  group device
    ../../../../../devices/MKV31F51212/: fsl_device_registers.h MKV31F51212.h MKV31F51212_features.h system_MKV31F51212.h system_MKV31F51212.c
  group startup
    ../../../../../middleware/mcu-boot/src/startup/: crt0.s startup.c
    ../../../../../middleware/mcu-boot/targets/MKV31F51212/src/startup/iar/: startup_MKV31F51212.s
  group source/bootloader
    ../../../../../middleware/mcu-boot/src/bootloader/: flashloader_image.h
    ../../../../../middleware/mcu-boot/src/bootloader/src/: bl_flashloader.c bl_exception_handler.c
  group source/include
    ../../../../../middleware/mcu-boot/src/include/: bootloader_common.h bootloader_core.h
  group source/utilities
    ../../../../../middleware/mcu-boot/src/utilities/: fsl_assert.h vector_table_info.h
  group source/utilities/src
    ../../../../../middleware/mcu-boot/src/utilities/src/: fsl_assert.c
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
