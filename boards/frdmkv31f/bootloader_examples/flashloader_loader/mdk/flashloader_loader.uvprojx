# Keil uVision project flashloader_loader.uvprojx, settings and files
target flashloader_loader debug (ARM-ADS)
  device: MKV31F512VLL12 NXP
  pack: NXP.MKV31F51212_DFP.12.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: flashloader_loader.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: DEBUG, CPU_MKV31F512VLL12, BL_TARGET_FLASH, FRDM_KV31F
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -Wno-null-dereference  -Wno-unknown-attributes  -Wno-expansion-to-defined  -Wno-invalid-noreturn
  c include: ../../flashloader/mdk;../../../../../middleware/mcu-boot/targets/MKV31F51212/src;../../../../../devices/MKV31F51212/drivers;../../../../../devices/MKV31F51212;../../../../../middleware/mcu-boot/src/bootloader;../../../../../middleware/mcu-boot/src/include;../../../../../middleware/mcu-boot/src/utilities;../../../../../middleware/mcu-boot/src/startup;../../../../../CMSIS/Include
  asm define: DEBUG, BL_HAS_BOOTLOADER_CONFIG=0, LITE_FOOTPRINT
  asm include: ../../../../../middleware/mcu-boot/src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ../../../../../middleware/mcu-boot/targets/common/linker/arm/MKV31F51212/MKV31F512xxx12_flashloader_loader.scf
  link misc: --remove --keep=*(.FlashConfig) --datacompressor off
  group doc
    ../: readme.txt
  group MKV31F51212
    ../../../../../middleware/mcu-boot/targets/MKV31F51212/src/: bootloader_config.h target_config.h
  group drivers
    ../../../../../devices/MKV31F51212/drivers/: fsl_clock.h fsl_clock.c fsl_uart.h fsl_uart.c fsl_common.h fsl_common.c
  group device
    ../../../../../devices/MKV31F51212/: fsl_device_registers.h MKV31F51212.h MKV31F51212_features.h system_MKV31F51212.h system_MKV31F51212.c
  group startup
    ../../../../../middleware/mcu-boot/targets/MKV31F51212/src/startup/arm/: startup_MKV31F51212.S
    ../../../../../middleware/mcu-boot/src/startup/: startup.c
  group source/bootloader
    ../../../../../middleware/mcu-boot/src/bootloader/: flashloader_image.h
    ../../../../../middleware/mcu-boot/src/bootloader/src/: bl_flashloader.c bl_exception_handler.c
  group source/include
    ../../../../../middleware/mcu-boot/src/include/: bootloader_common.h bootloader_core.h
  group source/utilities
    ../../../../../middleware/mcu-boot/src/utilities/: fsl_assert.h vector_table_info.h
  group source/utilities/src
    ../../../../../middleware/mcu-boot/src/utilities/src/: fsl_assert.c
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
target flashloader_loader release (ARM-ADS)
  device: MKV31F512VLL12 NXP
  pack: NXP.MKV31F51212_DFP.12.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: flashloader_loader.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: NDEBUG, CPU_MKV31F512VLL12, BL_TARGET_FLASH, FRDM_KV31F
  c misc: as above
  c include: as above
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=0, LITE_FOOTPRINT
  asm include: ../../../../../middleware/mcu-boot/src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: as above
  link misc: --remove --keep=*(.FlashConfig) --datacompressor off
