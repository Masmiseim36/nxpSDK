# IAR project cmsis_dspi_edma_b2b_transfer_master.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV31F512xxx12 NXP MKV31F512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MKV31F512VLL12; FRDM_KV31F; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../../devices/MKV31F51212/utilities/debug_console_lite; ../../../../../../../devices/MKV31F51212/drivers; ../../../../../../../devices/MKV31F51212/cmsis_drivers; ../../../../../../../devices/MKV31F51212; ../../../../../../../components/uart; ../../../../../../../components/lists; ../../../../../../../CMSIS/Include; ../../../../../../../CMSIS/Driver/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: cmsis_dspi_edma_b2b_transfer_master.out
  ILINK.IlinkIcfFile: MKV31F512xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV31F512VLL12; FRDM_KV31F; FREEDOM
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: cmsis_dspi_edma_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../../../devices/MKV31F51212/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../../devices/MKV31F51212/drivers/: fsl_port.h fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_dspi.h fsl_dspi.c fsl_dspi_edma.h fsl_dspi_edma.c fsl_common.h fsl_common.c fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c
    ../../../../../../../devices/MKV31F51212/cmsis_drivers/: fsl_dspi_cmsis.h fsl_dspi_cmsis.c
  group device
    ../../../../../../../devices/MKV31F51212/: fsl_device_registers.h MKV31F51212.h MKV31F51212_features.h system_MKV31F51212.c system_MKV31F51212.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../../devices/MKV31F51212/iar/: startup_MKV31F51212.s
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_SPI.h Driver_Common.h
