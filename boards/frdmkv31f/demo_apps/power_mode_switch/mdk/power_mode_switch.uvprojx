# Keil uVision project power_mode_switch.uvprojx, settings and files
target power_mode_switch debug (ARM-ADS)
  device: MKV31F512VLL12 NXP
  pack: NXP.MKV31F51212_DFP.12.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: power_mode_switch.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: DEBUG, CPU_MKV31F512VLL12, FRDM_KV31F, FREEDOM, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../devices/MKV31F51212/drivers;../../../../../devices/MKV31F51212;../../../../../devices/MKV31F51212/utilities/str;../../../../../devices/MKV31F51212/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../CMSIS/Include
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: MKV31F512xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
  group board
    ../: peripherals.c peripherals.h pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source
    ../: power_mode_switch.c power_mode_switch.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKV31F51212/drivers/: fsl_port.h fsl_llwu.h fsl_llwu.c fsl_pmc.h fsl_pmc.c fsl_smc.h fsl_smc.c fsl_rcm.c fsl_rcm.h fsl_lptmr.c fsl_lptmr.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c
  group device
    ../../../../../devices/MKV31F51212/: fsl_device_registers.h MKV31F51212.h MKV31F51212_features.h system_MKV31F51212.c system_MKV31F51212.h
  group utilities
    ../../../../../devices/MKV31F51212/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MKV31F51212/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MKV31F51212/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MKV31F51212/arm/: startup_MKV31F51212.S
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
target power_mode_switch release (ARM-ADS)
  device: MKV31F512VLL12 NXP
  pack: NXP.MKV31F51212_DFP.12.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: power_mode_switch.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: NDEBUG, CPU_MKV31F512VLL12, FRDM_KV31F, FREEDOM, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: MKV31F512xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
