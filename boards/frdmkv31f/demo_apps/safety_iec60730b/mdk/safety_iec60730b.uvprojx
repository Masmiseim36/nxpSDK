# Keil uVision project safety_iec60730b.uvprojx, settings and files
target safety_iec60730b debug (ARM-ADS)
  device: MKV31F512VLL12 NXP
  pack: NXP.MKV31F51212_DFP.12.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: safety_iec60730b.out +hex
  AfterMake: ..\..\..\..\..\middleware\safety_iec60730b\tools\crc\crc_hex.bat -..\..\..\..\boards\frdmkv31f\demo_apps\safety_iec60730b\mdk\debug\safety_iec60730b.hex -..\..\..\..\boards\frdmkv31f\demo_apps\safety_iec60730b\mdk\debug\safety_iec60730b_crc.hex -..\..\..\..\tools\srecord\srec_cat
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: DEBUG, CPU_MKV31F512VLL12, FRDM_KV31F, FREEDOM, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../middleware/safety_iec60730b/boards/common/cm4_cm7/startup/cm4;..;linker;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/register;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/ram;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/flash;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/stack;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/programCounter;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7;../../../../../middleware/safety_iec60730b/safety/v4_1;../../../../../middleware/safety_iec60730b/safety/v4_1/compiler;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/wdog;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/tsi;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/dio;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/clock;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/aio;../../../../../devices/MKV31F51212;../../../../../devices/MKV31F51212/drivers;../../../../../devices/MKV31F51212/utilities/str;../../../../../devices/MKV31F51212/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../middleware/freemaster/src/common;../../../../../middleware/freemaster/src/platforms/gen32le;../../../../../middleware/freemaster/src/drivers/mcuxsdk/can;../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial;../../../../../CMSIS/Include
  asm define: DEBUG
  asm include: ../../../../../middleware/safety_iec60730b/boards/common/cm4_cm7/startup/cm4;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/register;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/ram;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/flash;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/stack;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/programCounter;../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7;../../../../../middleware/safety_iec60730b/safety/v4_1;../../../../../middleware/safety_iec60730b/safety/v4_1/compiler;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/wdog;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/tsi;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/dio;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/clock;../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/aio;../../../../../devices/MKV31F51212
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: linker/frdmkv31f_safety.sct
  link misc: --remove --datacompressor=off
  group source
    ../: freemaster_cfg.h safety_test_items.h safety_test_items.c isr.h safety_config.h project_setup_frdmkv31f.h project_setup_frdmkv31f.c safety_cm4_cm7_kinetis.c safety_cm4_cm7_kinetis.h main.c
  group doc
    ../: readme.txt
  group board
    ../: pin_mux.c pin_mux.h clock_config.c clock_config.h board.c board.h
  group linker
    ../../../../../middleware/safety_iec60730b/tools/crc/: crc_hex.bat
    linker/: frdmkv31f_safety.sct linker_config.h
  group tools/srecord
    ../../../../../tools/srecord/: srecord-1.64.zip
  group startup
    ../../../../../middleware/safety_iec60730b/boards/common/cm4_cm7/startup/cm4/: start.c startup_mdk.c vectors_mdk.c vectors_mdk.h
  group GUI
    ../GUI/: safety.pmp
  group safety/v4_1/register
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/register/: iec60730b_cm4_cm7_reg.h
  group safety/v4_1/ram
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/ram/: iec60730b_cm4_cm7_ram.h
  group safety/v4_1/flash
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/flash/: iec60730b_cm4_cm7_flash.h
  group safety/v4_1/stack
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/stack/: iec60730b_cm4_cm7_stack.h
  group safety/v4_1/programCounter
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/programCounter/: iec60730b_cm4_cm7_pc.h iec60730b_cm4_cm7_pc_object.S
  group safety/v4_1
    ../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm4_cm7/: iec60730b_core.h
    ../../../../../middleware/safety_iec60730b/safety/v4_1/: iec60730b.h iec60730b_types.h IEC60730B_M4_M7_KEIL_v4_1.lib IEC60730B_M4_M7_COM_KEIL_v4_1.lib
  group safety/v4_1/compiler
    ../../../../../middleware/safety_iec60730b/safety/v4_1/compiler/: asm_mac_common.h
  group safety/v4_1/wdog
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/wdog/: iec60730b_wdog.c iec60730b_wdog.h
  group safety/v4_1/tsi
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/tsi/: iec60730b_tsi.h
  group safety/v4_1/dio
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/dio/: iec60730b_dio_ext.h iec60730b_dio.h
  group safety/v4_1/clock
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/clock/: iec60730b_clock.h
  group safety/v4_1/aio
    ../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/aio/: iec60730b_aio.h
  group MKV31F51212
    ../../../../../devices/MKV31F51212/: system_MKV31F51212.c system_MKV31F51212.h
  group drivers
    ../../../../../devices/MKV31F51212/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_uart.h fsl_uart.c fsl_port.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c
  group device
    ../../../../../devices/MKV31F51212/: fsl_device_registers.h MKV31F51212.h MKV31F51212_features.h
  group utilities
    ../../../../../devices/MKV31F51212/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MKV31F51212/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MKV31F51212/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group freemaster
    ../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_defcfg.h freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h freemaster_can.c freemaster_can.h freemaster_sha.c freemaster_pdbdm.c freemaster_serial.c freemaster_serial.h
  group freemaster/platforms
    ../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group freemaster/drivers
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mscan.c freemaster_mscan.h freemaster_mcan.c freemaster_mcan.h
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_usb.c freemaster_serial_usb.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
