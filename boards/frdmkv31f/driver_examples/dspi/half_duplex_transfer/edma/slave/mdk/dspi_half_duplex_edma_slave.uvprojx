# Keil uVision project dspi_half_duplex_edma_slave.uvprojx, settings and files
target dspi_half_duplex_edma_slave Debug (ARM-ADS)
  device: MKV31F512VLL12 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: dspi_half_duplex_edma_slave.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKV31F512VLL12, FRDM_KV31F, FREEDOM, PRINTF_ADVANCED_ENABLE=1
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../../../CMSIS/Include;../../../../../../../../devices;..;../../../../../..;../../../../../../../../devices/MKV31F51212/drivers;../../../../../../../../devices/MKV31F51212;../../../../../../../../devices/MKV31F51212/utilities/io;../../../../../../../../devices/MKV31F51212/utilities/str;../../../../../../../../devices/MKV31F51212/utilities/log;../../../../../../../../devices/MKV31F51212/utilities
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: MKV31F512xxx12_flash.scf
  link misc: --remove
  group source
    ../: dspi_half_duplex_edma_slave.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../../devices/MKV31F51212/drivers/: fsl_clock.h fsl_clock.c fsl_flash.c fsl_flash.h fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c fsl_port.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c fsl_dspi.h fsl_dspi.c fsl_dspi_edma.h fsl_dspi_edma.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c
  group startup
    ../../../../../../../../devices/MKV31F51212/: system_MKV31F51212.c system_MKV31F51212.h
    ../../../../../../../../devices/MKV31F51212/arm/: startup_MKV31F51212.s
  group utilities
    ../../../../../../../../devices/MKV31F51212/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../../../devices/MKV31F51212/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../../../devices/MKV31F51212/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../../devices/MKV31F51212/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
target dspi_half_duplex_edma_slave Release (ARM-ADS)
  device: MKV31F512VLL12 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: dspi_half_duplex_edma_slave.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKV31F512VLL12, FRDM_KV31F, FREEDOM, PRINTF_ADVANCED_ENABLE=1
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: MKV31F512xxx12_flash.scf
  link misc: --remove
