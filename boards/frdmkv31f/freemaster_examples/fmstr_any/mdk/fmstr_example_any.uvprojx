# Keil uVision project fmstr_example_any.uvprojx, settings and files
target fmstr_example_any debug (ARM-ADS)
  device: MKV31F512VLL12 NXP
  pack: NXP.MKV31F51212_DFP.12.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: fmstr_example_any.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: DEBUG, CPU_MKV31F512VLL12, SDK_DEBUGCONSOLE=1, FRDM_KV31F, FREEDOM
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../common/fmstr_example;../../../../../devices/MKV31F51212/drivers;../../../../../devices/MKV31F51212/utilities/debug_console_lite;../../../../../middleware/freemaster/src/common;../../../../../devices/MKV31F51212;../../../../../components/uart;../../../../../components/lists;../../../../../middleware/freemaster/src/platforms/gen32le;../../../../../middleware/freemaster/src/drivers/mcuxsdk/can;../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial;../../../../../CMSIS/Include
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: MKV31F512xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
  group source
    ../: main.c freemaster_cfg.h freemaster_democfg.h
    ../../common/fmstr_example/: freemaster_example_per.c freemaster_example.h
  group board
    ../: clock_config.c clock_config.h pin_mux.c pin_mux.h peripherals.c peripherals.h board.c board.h
  group source/example_data
    ../../common/fmstr_example/: data_example_pmp.h data_img_logo.h data_img_file.h data_img_fmstrlogo.h data_html_index.h example_data.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKV31F51212/drivers/: fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c
  group utilities
    ../../../../../devices/MKV31F51212/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group freemaster
    ../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_defcfg.h freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h freemaster_can.c freemaster_can.h freemaster_sha.c freemaster_pdbdm.c freemaster_serial.c freemaster_serial.h
  group device
    ../../../../../devices/MKV31F51212/: fsl_device_registers.h MKV31F51212.h MKV31F51212_features.h system_MKV31F51212.c system_MKV31F51212.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MKV31F51212/arm/: startup_MKV31F51212.S
  group freemaster/platforms
    ../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group freemaster/drivers
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mscan.c freemaster_mscan.h freemaster_mcan.c freemaster_mcan.h
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_usb.c freemaster_serial_usb.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
target fmstr_example_any release (ARM-ADS)
  device: MKV31F512VLL12 NXP
  pack: NXP.MKV31F51212_DFP.12.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: fmstr_example_any.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: NDEBUG, CPU_MKV31F512VLL12, SDK_DEBUGCONSOLE=1, FRDM_KV31F, FREEDOM
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: MKV31F512xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
