# IAR project $[project_name].ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV31F512xxx12 NXP MKV31F512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../platform/drivers; ../../../../../devices/MKV31F51212/drivers; ../../../../../devices/MKV31F51212/utilities; ../../../../../devices/MKV31F51212
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: cppproject_templates.out
  ILINK.IlinkIcfFile: MKV31F512xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../devices/MKV31F51212/iar/: startup_MKV31F51212.s
    ../../../../../devices/MKV31F51212/: system_MKV31F51212.c system_MKV31F51212.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKV31F51212/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group utilities
    ../../../../../devices/MKV31F51212/utilities/: fsl_debug_console.c fsl_debug_console.h
