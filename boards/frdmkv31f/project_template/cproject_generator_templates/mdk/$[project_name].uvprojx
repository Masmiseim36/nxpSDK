# Keil uVision project $[project_name].uvprojx, settings and files
target $[project_name] Debug (ARM-ADS)
  device: MKV31F512VLL12 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: cproject_templates.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;../../../../../platform/drivers;../../../../../devices/MKV31F51212/drivers;../../../../../devices/MKV31F51212/utilities;../../../../../devices/MKV31F51212
  asm define: DEBUG
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: MKV31F512xxx12_flash.scf
  link misc: --remove
  group startup
    ../../../../../devices/MKV31F51212/arm/: startup_MKV31F51212.s
    ../../../../../devices/MKV31F51212/: system_MKV31F51212.c system_MKV31F51212.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKV31F51212/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group utilities
    ../../../../../devices/MKV31F51212/utilities/: fsl_debug_console.c fsl_debug_console.h
target $[project_name] Release (ARM-ADS)
  device: MKV31F512VLL12 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: cproject_templates.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG
  c misc: as above
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: MKV31F512xxx12_flash.scf
  link misc: --remove
