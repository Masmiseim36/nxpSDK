# Keil uVision project cmsis_dspi_edma_b2b_transfer_master.uvprojx, settings and files
target cmsis_dspi_edma_b2b_transfer_master Debug (ARM-ADS)
  device: MKW36Z512xxx4 Freescale
  pack: Keil.Kinetis_KWxx_DFP.1.6.0-dev4
  cpu: CPUTYPE("Cortex-M0+")
  output: cmsis_dspi_edma_b2b_transfer_master.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKW36Z512VHT4, FRDM_KW36, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../devices/MKW36Z4/drivers;..;../../../../../../../CMSIS/Driver/Include;../../../../..;../../../../../../../devices/MKW36Z4/cmsis_drivers;../../../../../../../devices/MKW36Z4/utilities;../../../../../../../devices/MKW36Z4
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: MKW36Z512xxx4_flash.scf
  link misc: --remove
  group startup
    ../../../../../../../devices/MKW36Z4/arm/: startup_MKW36Z4.s
    ../../../../../../../devices/MKW36Z4/: system_MKW36Z4.c system_MKW36Z4.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MKW36Z4/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_lptmr.c fsl_lptmr.h fsl_port.h fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_dspi.h fsl_dspi.c fsl_dspi_edma.h fsl_dspi_edma.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
    ../../../../../../../devices/MKW36Z4/cmsis_drivers/: fsl_dspi_cmsis.h fsl_dspi_cmsis.c
  group source
    ../: cmsis_dspi_edma_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../../devices/MKW36Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
target cmsis_dspi_edma_b2b_transfer_master Release (ARM-ADS)
  device: MKW36Z512xxx4 Freescale
  pack: Keil.Kinetis_KWxx_DFP.1.6.0-dev4
  cpu: CPUTYPE("Cortex-M0+")
  output: cmsis_dspi_edma_b2b_transfer_master.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKW36Z512VHT4, FRDM_KW36, FREEDOM
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKW36Z512xxx4_flash.scf
  link misc: --remove
