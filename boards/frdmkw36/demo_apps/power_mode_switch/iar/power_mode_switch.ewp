# IAR project power_mode_switch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW36Z512xxx4 NXP MKW36Z512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKW36Z512VHT4; USE_WARMBOOT_SP=1; SUPPORT_WARMBOOT; FRDM_KW36; FREEDOM
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MKW36Z4/drivers; ..; ../../..; ../../../../../devices/MKW36Z4/utilities; ../../../../../devices/MKW36Z4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; SUPPORT_WARMBOOT
  ILINK.IlinkOutputFile: power_mode_switch.out
  ILINK.IlinkConfigDefines: __warmboot_stack_addr__=0x1FFFC000; __warmboot_stack_size__=0x400
  ILINK.IlinkIcfFile: MKW36Z512xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW36Z512VHT4; USE_WARMBOOT_SP=1; SUPPORT_WARMBOOT; FRDM_KW36; FREEDOM
  ICCARM.CCOptLevel: 3
  AARM.ADefines: SUPPORT_WARMBOOT
  group startup
    ../../../../../devices/MKW36Z4/iar/: startup_MKW36Z4.s
    ../../../../../devices/MKW36Z4/: system_MKW36Z4.c system_MKW36Z4.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKW36Z4/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_lptmr.c fsl_lptmr.h fsl_port.h fsl_llwu.h fsl_llwu.c fsl_pmc.h fsl_pmc.c fsl_smc.h fsl_smc.c fsl_rcm.c fsl_rcm.h fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group source
    ../: power_mode_switch.c power_mode_switch.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MKW36Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
