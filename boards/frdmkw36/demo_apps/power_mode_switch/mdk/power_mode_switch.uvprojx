# Keil uVision project power_mode_switch.uvprojx, settings and files
target power_mode_switch Debug (ARM-ADS)
  device: MKW36Z512xxx4 Freescale
  pack: Keil.Kinetis_KWxx_DFP.1.6.0-dev4
  cpu: CPUTYPE("Cortex-M0+")
  output: power_mode_switch.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKW36Z512VHT4, USE_WARMBOOT_SP=1, SUPPORT_WARMBOOT, FRDM_KW36, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;../../../../../devices/MKW36Z4/drivers;..;../../..;../../../../../devices/MKW36Z4/utilities;../../../../../devices/MKW36Z4
  asm define: DEBUG, SUPPORT_WARMBOOT
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: MKW36Z512xxx4_flash.scf
  link misc: --remove 
--predefine="-D__warmboot_stack_addr__=0x1FFFC000" 
--predefine="-D__warmboot_stack_size__=0x400"
  group startup
    ../../../../../devices/MKW36Z4/arm/: startup_MKW36Z4.s
    ../../../../../devices/MKW36Z4/: system_MKW36Z4.c system_MKW36Z4.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKW36Z4/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_lptmr.c fsl_lptmr.h fsl_port.h fsl_llwu.h fsl_llwu.c fsl_pmc.h fsl_pmc.c fsl_smc.h fsl_smc.c fsl_rcm.c fsl_rcm.h fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group source
    ../: power_mode_switch.c power_mode_switch.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MKW36Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
target power_mode_switch Release (ARM-ADS)
  device: MKW36Z512xxx4 Freescale
  pack: Keil.Kinetis_KWxx_DFP.1.6.0-dev4
  cpu: CPUTYPE("Cortex-M0+")
  output: power_mode_switch.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKW36Z512VHT4, USE_WARMBOOT_SP=1, SUPPORT_WARMBOOT, FRDM_KW36, FREEDOM
  c misc: as above
  c include: as above
  asm define: SUPPORT_WARMBOOT
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKW36Z512xxx4_flash.scf
  link misc: as above
