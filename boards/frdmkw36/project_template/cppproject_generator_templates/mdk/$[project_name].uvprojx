# Keil uVision project $[project_name].uvprojx, settings and files
target $[project_name] Debug (ARM-ADS)
  device: MKW36Z512xxx4 NXP
  pack: Keil.Kinetis_KWxx_DFP.1.6.0-dev4
  cpu: IRAM(0x1FFFC000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x10000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: cppproject_templates.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;../../../../../platform/drivers;../../../../../devices/MKW36Z4/drivers;../../../../../devices/MKW36Z4/utilities;../../../../../devices/MKW36Z4
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: MKW36Z512xxx4_flash.scf
  link misc: --remove
  group startup
    ../../../../../devices/MKW36Z4/arm/: startup_MKW36Z4.s
    ../../../../../devices/MKW36Z4/: system_MKW36Z4.c system_MKW36Z4.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKW36Z4/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_lptmr.c fsl_lptmr.h fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group utilities
    ../../../../../devices/MKW36Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
target $[project_name] Release (ARM-ADS)
  device: MKW36Z512xxx4 NXP
  pack: Keil.Kinetis_KWxx_DFP.1.6.0-dev4
  cpu: as above
  output: cppproject_templates.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  scatter file: MKW36Z512xxx4_flash.scf
  link misc: --remove
