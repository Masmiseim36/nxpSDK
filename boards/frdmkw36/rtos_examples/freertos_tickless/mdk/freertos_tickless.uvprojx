# Keil uVision project freertos_tickless.uvprojx, settings and files
target freertos_tickless Debug (ARM-ADS)
  device: MKW36Z512xxx4 Freescale
  pack: Keil.Kinetis_KWxx_DFP.1.6.0-dev4
  cpu: CPUTYPE("Cortex-M0+")
  output: freertos_tickless.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKW36Z512VHT4, FSL_RTOS_FREE_RTOS, FRDM_KW36, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../rtos/freertos_9.0.0/Source/portable/RVDS/ARM_CM0;../../../../../rtos/freertos_9.0.0/Source/include;../../../../../CMSIS/Include;../../../../../devices;../../../../../devices/MKW36Z4/drivers;..;../../..;../../../../../rtos/freertos_9.0.0/Source;../../../../../devices/MKW36Z4/utilities;../../../../../devices/MKW36Z4
  asm define: DEBUG
  asm include: ..;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: MKW36Z512xxx4_flash.scf
  link misc: --remove
  group startup
    ../../../../../devices/MKW36Z4/arm/: startup_MKW36Z4.s
    ../../../../../devices/MKW36Z4/: system_MKW36Z4.c system_MKW36Z4.h
  group freertos:portable
    ../../../../../rtos/freertos_9.0.0/Source/portable/RVDS/ARM_CM0/: port.c fsl_tickless_systick.c fsl_tickless_generic.h portmacro.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKW36Z4/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_lptmr.c fsl_lptmr.h fsl_port.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group freertos
    ../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
    ../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
    ../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group source
    ../: freertos_tickless.c FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MKW36Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
  group freertos-portable
    ../../../../../rtos/freertos_9.0.0/Source/portable/low_power_tickless/: fsl_tickless_lptmr.c
target freertos_tickless Release (ARM-ADS)
  device: MKW36Z512xxx4 Freescale
  pack: Keil.Kinetis_KWxx_DFP.1.6.0-dev4
  cpu: CPUTYPE("Cortex-M0+")
  output: freertos_tickless.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKW36Z512VHT4, FSL_RTOS_FREE_RTOS, FRDM_KW36, FREEDOM
  c misc: as above
  c include: as above
  asm include: ..;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKW36Z512xxx4_flash.scf
  link misc: --remove
