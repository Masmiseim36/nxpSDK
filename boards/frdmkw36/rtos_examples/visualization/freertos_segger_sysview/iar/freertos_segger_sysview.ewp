# IAR project freertos_segger_sysview.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW36Z512xxx4 NXP MKW36Z512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKW36Z512VHT4; FSL_RTOS_FREE_RTOS; FRDM_KW36; FREEDOM
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM0; ../../../../../../rtos/freertos_9.0.0/Source/include; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MKW36Z4/drivers; ..; ../SEGGER; ../Config; ../Sample/OS; ../../../..; ../../../../../../rtos/freertos_9.0.0/Source; ../../../../../../devices/MKW36Z4/utilities; ../../../../../../devices/MKW36Z4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..; ../SEGGER; ../Config; ../Sample/OS; ../../../..
  ILINK.IlinkOutputFile: freertos_segger_sysview.out
  ILINK.IlinkIcfFile: MKW36Z512xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW36Z512VHT4; FSL_RTOS_FREE_RTOS; FRDM_KW36; FREEDOM
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/MKW36Z4/iar/: startup_MKW36Z4.s
    ../../../../../../devices/MKW36Z4/: system_MKW36Z4.c system_MKW36Z4.h
  group freertos
    ../../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
    ../../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
    ../../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group freertos/portable
    ../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM0/: port.c fsl_tickless_systick.c fsl_tickless_generic.h portasm.s portmacro.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MKW36Z4/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_lptmr.c fsl_lptmr.h fsl_port.h fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group source
    ../: main.c FreeRTOSConfig.h
  group segger_sysview
    ../SEGGER/: SEGGER.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Int.h
    ../Config/: Global.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW_Conf.h
    ../Sample/OS/: SEGGER_SYSVIEW_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../devices/MKW36Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
