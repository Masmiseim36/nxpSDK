# IAR project bootloader_otap_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW36Z512xxx4 NXP MKW36Z512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKW36Z512VHT4; gEepromType_d=gEepromDevice_AT45DB041E_c; gUseOTAPBootloader_d=1; FRDM_KW36; FREEDOM
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.PreInclude: ../../../../../../../boards/frdmkw36/wireless_examples/framework/bootloader_otap/bm/app_preinclude.h
  ICCARM.CCIncludePath2: ../../../../../../../CMSIS/Include; ../../../../../../../devices; ..; ../../../../../../../middleware/wireless/framework_5.4.8/FunctionLib; ../../src/bootloader; ../../src/eeprom; ../../src/spi; ../../src/timer; ../../src/uart; ../../../../../../../devices/MKW36Z4/drivers; ../../../../../../../devices/MKW36Z4; ../../../../../../../middleware/wireless/framework_5.4.8/Common; ../../../../../../../devices/MKW36Z4/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: bootloader_otap_frdmkw36.bin
  ILINK.IlinkOutputFile: bootloader_otap_bm.out
  ILINK.IlinkConfigDefines: gRomSize_c=524288; gSectorSize_c=2048
  ILINK.IlinkIcfFile: MKW36Z512xxx4_PD_bootloader.icf
  ILINK.IlinkProgramEntryLabel: main
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW36Z512VHT4; gEepromType_d=gEepromDevice_AT45DB041E_c; gUseOTAPBootloader_d=1; FRDM_KW36; FREEDOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group source
    ../: pin_mux.c pin_mux.h clock_config.c clock_config.h app_preinclude.h
    ../../src/bootloader/: main.c main.h OtapBootloader.c OtapBootloader.h
  group source/drivers/eeprom
    ../../src/eeprom/: Eeprom_Boot.h Eeprom_Boot_AT45DB041E.c
  group source/drivers/spi
    ../../src/spi/: SPI.c SPI.h
  group source/drivers/timer
    ../../src/timer/: timer.c timer.h
  group source/drivers/uart
    ../../src/uart/: UART.c UART.h
  group framework/FunctionLib
    ../../../../../../../middleware/wireless/framework_5.4.8/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/Common
    ../../../../../../../middleware/wireless/framework_5.4.8/Common/: EmbeddedTypes.h
  group doc
    ../../: readme.txt
  group drivers
    ../../../../../../../devices/MKW36Z4/drivers/: fsl_common.h fsl_common.c fsl_flash.c fsl_flash.h fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_rtc.c fsl_rtc.h fsl_smc.h fsl_smc.c fsl_clock.h fsl_clock.c
  group utilities
    ../../../../../../../devices/MKW36Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
