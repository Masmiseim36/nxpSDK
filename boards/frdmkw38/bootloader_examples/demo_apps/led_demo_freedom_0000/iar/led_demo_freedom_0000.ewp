# IAR project led_demo_freedom_0000.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: MKW38A512xxx4 NXP MKW38A512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CPU_MKW38A512VFT4; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050,Pe1105,Pe1305,Pa182
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../devices/MKW38A4; ../../../../../../middleware/mcu-boot/targets/MKW38A4/src; ../../../../../../middleware/mcu-boot/src/startup; ../../../../../../middleware/mcu-boot/src/include; ../../../../../../middleware/mcu-boot/apps/led_demo/src; ..; ../../../../../../devices/MKW38A4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BL_HAS_BOOTLOADER_CONFIG
  ILINK.IlinkOutputFile: led_demo_freedom_0000.out
  ILINK.IlinkIcfFile: MKW38A512xxx4_application_0x0000.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group MKW38A4
    ../: main.c
    ../../../../../../middleware/mcu-boot/apps/led_demo/src/: milliseconds_delay.h milliseconds_delay.c
  group device
    ../../../../../../devices/MKW38A4/: MKW38A4.h MKW38A4_features.h fsl_device_registers.h system_MKW38A4.c system_MKW38A4.h
  group startup
    ../../../../../../middleware/mcu-boot/src/startup/: crt0.s startup.c
    ../../../../../../middleware/mcu-boot/targets/MKW38A4/src/startup/iar/: startup_MKW38A4.s
  group source/include
    ../../../../../../middleware/mcu-boot/src/include/: bootloader_core.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm0plus.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h
