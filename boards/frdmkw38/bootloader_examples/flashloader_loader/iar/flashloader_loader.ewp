# IAR project flashloader_loader.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW38A512xxx4 NXP MKW38A512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKW38A512VFT4; BL_TARGET_FLASH; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050,Pe1105,Pe1305,Pa182
  ICCARM.CCIncludePath2: ../../flashloader/iar; ../../../../../CMSIS/Include; ../../../../../middleware/mcu-boot/src; ../../../../../middleware/mcu-boot/src/bootloader; ../../../../../middleware/mcu-boot/src/include; ../../../../../middleware/mcu-boot/src/startup; ../../../../../middleware/mcu-boot/src/utilities; ../../../../../middleware/mcu-boot/src/drivers; ../../../../../middleware/mcu-boot/src/drivers/crc; ../../../../../middleware/mcu-boot/src/drivers/microseconds; ../../../../../middleware/mcu-boot/targets/MKW38A4/src; ../../../../../devices/MKW38A4; ../../../../../devices/MKW38A4/drivers; ../../../../../devices/MKW38A4/drivers; ../../../../../devices/MKW38A4; ../../../../../devices/MKW38A4/drivers; ../../../../../devices/MKW38A4/drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; LITE_FOOTPRINT
  AARM.AUserIncludes: ../../../../../middleware/mcu-boot/src/include
  OBJCOPY.OOCOutputFile: generic.srec
  ILINK.IlinkOutputFile: flashloader_loader.out
  ILINK.IlinkIcfFile: MKW38A512xxx4_flashloader_loader.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW38A512VFT4; BL_TARGET_FLASH; FREEDOM
  AARM.ADefines: LITE_FOOTPRINT
  group MKW38A4
    ../../../../../middleware/mcu-boot/targets/MKW38A4/src/: bootloader_config.h target_config.h
  group drivers
    ../../../../../devices/MKW38A4/drivers/: fsl_clock.c fsl_clock.h fsl_lpuart.c fsl_lpuart.h fsl_common.c fsl_common.h
  group device
    ../../../../../devices/MKW38A4/: MKW38A4.h MKW38A4_features.h fsl_device_registers.h system_MKW38A4.c system_MKW38A4.h
  group startup
    ../../../../../middleware/mcu-boot/src/startup/: crt0.s startup.c
    ../../../../../middleware/mcu-boot/targets/MKW38A4/src/startup/iar/: startup_MKW38A4.s
  group source/bootloader
    ../../../../../middleware/mcu-boot/src/bootloader/: flashloader_image.h
    ../../../../../middleware/mcu-boot/src/bootloader/src/: bl_exception_handler.c bl_flashloader.c
  group source/include
    ../../../../../middleware/mcu-boot/src/include/: bootloader_common.h bootloader_core.h
  group source/utilities
    ../../../../../middleware/mcu-boot/src/utilities/: vector_table_info.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm0plus.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h
