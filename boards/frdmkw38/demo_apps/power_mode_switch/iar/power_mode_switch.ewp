# IAR project power_mode_switch.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW38A512xxx4 NXP MKW38A512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKW38A512VFT4; USE_WARMBOOT_SP=1; SUPPORT_WARMBOOT; frdmKW38
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../platform/drivers; ../../../../../devices/MKW38A4/drivers; ../../../../../devices/MKW38A4/drivers; ../../../../../devices/MKW38A4/drivers; ../../../../../devices/MKW38A4/drivers; ../../../../../devices/MKW38A4/drivers; ../../../../../devices/MKW38A4/drivers; ../../../../../devices/MKW38A4/drivers; ../../../../../devices/MKW38A4/drivers; ../../../../../devices/MKW38A4/drivers; ../../../../../devices/MKW38A4/drivers; ../../../../../devices/MKW38A4/drivers; ../../../../../devices/MKW38A4; ../../../../../devices/MKW38A4/utilities/str; ../../../../../devices/MKW38A4/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/serial_manager; ../../../../../devices/MKW38A4/drivers; ../../../../../components/lists
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; SUPPORT_WARMBOOT
  ILINK.IlinkOutputFile: power_mode_switch.out
  ILINK.IlinkConfigDefines: __warmboot_stack_addr__=0x1FFFC000; __warmboot_stack_size__=0x400; gFirmwareTopAddr_c=0x20007FFF
  ILINK.IlinkIcfFile: MKW38A512xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW38A512VFT4; USE_WARMBOOT_SP=1; SUPPORT_WARMBOOT; frdmKW38
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; SUPPORT_WARMBOOT
  group source
    ../: power_mode_switch.c power_mode_switch.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKW38A4/drivers/: fsl_power.c fsl_power.h fsl_dcdc.c fsl_dcdc.h fsl_port.h fsl_llwu.c fsl_llwu.h fsl_pmc.c fsl_pmc.h fsl_smc.c fsl_smc.h fsl_rcm.c fsl_rcm.h fsl_lptmr.c fsl_lptmr.h fsl_gpio.c fsl_gpio.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h
  group device
    ../../../../../devices/MKW38A4/: MKW38A4.h MKW38A4_features.h fsl_device_registers.h system_MKW38A4.c system_MKW38A4.h
  group utilities
    ../../../../../devices/MKW38A4/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MKW38A4/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MKW38A4/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MKW38A4/iar/: startup_MKW38A4.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm0plus.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h
