# IAR project lp_master_freertos.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW38A512xxx4 NXP MKW38A512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKW38A512VFT4; SUPPORT_WARMBOOT; CR_INTEGER_PRINTF; FRDM_KW38; CFG_BLE_PRJ=1; ENABLE_RAM_VECTOR_TABLE=1; FSL_RTOS_FREE_RTOS
  ICCARM.PreInclude: ../../../../../../../boards/frdmkw38/reference_design/bluetooth/lp_master/freertos/app_preinclude.h
  ICCARM.CCIncludePath2: ../../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM0; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../rtos/amazon-freertos/lib/include; ../../../../../../../rtos/amazon-freertos/lib/include/private; ../../../../../../../middleware/wireless/refdes/boards/frdmkw38/lp_master; ../..; ..; ../../../../../../../middleware/wireless/framework/boards/frdmkw38; ../../../../../../../middleware/wireless/framework/OSAbstraction/Interface; ../../../../../../../middleware/wireless/framework/Flash/Internal; ../../../../../../../middleware/wireless/framework/GPIO; ../../../../../../../middleware/wireless/framework/Keyboard/Interface; ../../../../../../../middleware/wireless/framework/LED/Interface; ../../../../../../../middleware/wireless/framework/Reset; ../../../../../../../middleware/wireless/framework/Common; ../../../../../../../middleware/wireless/framework/MemManager/Interface; ../../../../../../../middleware/wireless/framework/Messaging/Interface; ../../../../../../../middleware/wireless/framework/OSAbstraction/Interface; ../../../../../../../middleware/wireless/framework/Panic/Interface; ../../../../../../../middleware/wireless/framework/RNG/Interface; ../../../../../../../middleware/wireless/framework/NVM/Interface; ../../../../../../../middleware/wireless/framework/NVM/Source; ../../../../../../../middleware/wireless/framework/MWSCoexistence/Interface; ../../../../../../../middleware/wireless/framework/SerialManager/Interface; ../../../../../../../middleware/wireless/framework/SerialManager/Source; ../../../../../../../middleware/wireless/framework/TimersManager/Interface; ../../../../../../../middleware/wireless/framework/TimersManager/Source; ../../../../../../../middleware/wireless/framework/ModuleInfo; ../../../../../../../middleware/wireless/framework/FunctionLib; ../../../../../../../middleware/wireless/framework/Lists; ../../../../../../../middleware/wireless/framework/SecLib; ../../../../../../../middleware/wireless/framework/Shell/Interface; ../../../../../../../middleware/wireless/bluetooth/host/interface; ../../../../../../../middleware/wireless/bluetooth/host/config; ../../../../../../../middleware/wireless/bluetooth/application/common; ../../../../../../../middleware/wireless/bluetooth/application/common; ../../../../../../../middleware/wireless/ble_controller/interface; ../../../../../../../middleware/wireless/ble_controller/config; ../../../../../../../middleware/wireless/bluetooth/host/config; ../../../../../../../middleware/wireless/bluetooth/application/common; ../../../../../../../middleware/wireless/bluetooth/application/common; ../../../../../../../middleware/wireless/bluetooth/application/common/gatt_db; ../../../../../../../middleware/wireless/bluetooth/application/common/gatt_db/macros; ../../../../../../../middleware/wireless/bluetooth/application/common; ../../../../../../../middleware/wireless/framework/LowPower/Interface/MKW38Z4; ../../../../../../../middleware/wireless/bluetooth/profiles/battery; ../../../../../../../middleware/wireless/bluetooth/profiles/device_info; ../../../../../../../middleware/wireless/bluetooth/profiles/temperature; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../devices/MKW38A4; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../components/uart; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../devices/MKW38A4/utilities/str; ../../../../../../../devices/MKW38A4/utilities/debug_console; ../../../../../../../components/serial_manager; ../../../../../../../components/serial_manager; ../../../../../../../middleware/wireless/framework/DCDC/Interface/MKW38Z4; ../../../../../../../components/lists; ../../../../../../../middleware/wireless/framework/XCVR/MKW38Z4/drv; ../../../../../../../middleware/wireless/framework/XCVR/MKW38Z4/drv/nb2p4ghz; ../../../../../../../middleware/wireless/framework/XCVR/MKW38Z4/drv/nb2p4ghz/configs/gen35
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; SUPPORT_WARMBOOT
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: lp_master_frdmkw38.bin
  ILINK.IlinkOutputFile: lp_master_freertos.out
  ILINK.IlinkConfigDefines: gUseWarmBootLink_d=1; gUseNVMLink_d=1; gEraseNVMLink_d=1; __ram_vector_table__=1
  ILINK.IlinkIcfFile: MKW38A512xxx4_PD_connectivity_lp.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../middleware/wireless/framework/SecLib/lib_crypto_m0.a; ../../../../../../../middleware/wireless/bluetooth/host/lib/lib_ble_5-0_host_central_cm0p_iar.a; ../../../../../../../middleware/wireless/ble_controller/lib/lib_ble_kw38a4_controller.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW38A512VFT4; SUPPORT_WARMBOOT; CR_INTEGER_PRINTF; FRDM_KW38; CFG_BLE_PRJ=1; ENABLE_RAM_VECTOR_TABLE=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; SUPPORT_WARMBOOT
  group board
    ../: app.h clock_config.c clock_config.h pin_mux.c pin_mux.h gpio_pins.h gpio_pins.c hardware_init.c board.c board.h
  group source
    ../../: app_config.c gatt_db.h gatt_uuid128.h lowpower_master.c lowpower_master.h
    ../: FreeRTOSConfig.h app_preinclude.h app_preinclude_common.h
  group source/common
    ../../../../../../../middleware/wireless/bluetooth/application/common/: ble_conn_manager.c ble_conn_manager.h ble_host_task_config.h ble_host_tasks.c ApplMain.c ApplMain.h ble_init.c ble_init.h ieee11073.h ble_service_discovery.c ble_service_discovery.h
  group source/common/gatt_db
    ../../../../../../../middleware/wireless/bluetooth/application/common/gatt_db/: gatt_database.c gatt_db_handles.h
  group source/common/gatt_db/macros
    ../../../../../../../middleware/wireless/bluetooth/application/common/gatt_db/macros/: gatt_alloc_x.h gatt_db_macros.h gatt_db_x_macros.h gatt_decl_x.h gatt_enum_x.h gatt_init_x.h gatt_size_x.h gatt_uuid_decl_x.h gatt_uuid_def_x.h
  group doc
    ../../: readme.txt
  group amazon-freertos/freertos
    ../../../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos/freertos/portable
    ../../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
    ../../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
  group amazon-freertos/include
    ../../../../../../../rtos/amazon-freertos/lib/include/: FreeRTOS.h event_groups.h freertos_tasks_c_additions.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
    ../../../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h stack_macros.h threading_alt.h
  group framework/OSAbstraction/interface
    ../../../../../../../middleware/wireless/framework/OSAbstraction/Interface/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction.h fsl_os_abstraction_config.h
  group framework/OSAbstraction/source
    ../../../../../../../middleware/wireless/framework/OSAbstraction/Source/: fsl_os_abstraction_free_rtos.c
  group framework/Flash
    ../../../../../../../middleware/wireless/framework/Flash/Internal/: Flash_Adapter.c Flash_Adapter.h
  group framework/GPIO/source
    ../../../../../../../middleware/wireless/framework/GPIO/: GPIO_Adapter.c
  group framework/GPIO/interface
    ../../../../../../../middleware/wireless/framework/GPIO/: GPIO_Adapter.h
  group framework/Keyboard/interface
    ../../../../../../../middleware/wireless/framework/Keyboard/Interface/: Keyboard.h
  group framework/Keyboard/source
    ../../../../../../../middleware/wireless/framework/Keyboard/Source/: Keyboard.c
  group framework/LED/interface
    ../../../../../../../middleware/wireless/framework/LED/Interface/: LED.h
  group framework/LED/source
    ../../../../../../../middleware/wireless/framework/LED/Source/: LED.c
  group framework/Reset/source
    ../../../../../../../middleware/wireless/framework/Reset/: Reset.c
  group framework/Reset/interface
    ../../../../../../../middleware/wireless/framework/Reset/: Reset.h
  group framework/Common
    ../../../../../../../middleware/wireless/framework/Common/: EmbeddedTypes.h
  group framework/MemManager/interface
    ../../../../../../../middleware/wireless/framework/MemManager/Interface/: MemManager.h
  group framework/MemManager/source
    ../../../../../../../middleware/wireless/framework/MemManager/Source/: MemManager.c MemManagerLight.c
  group framework/Messaging/interface
    ../../../../../../../middleware/wireless/framework/Messaging/Interface/: Messaging.h
  group framework/Messaging/source
    ../../../../../../../middleware/wireless/framework/Messaging/Source/: Messaging.c
  group framework/Panic/interface
    ../../../../../../../middleware/wireless/framework/Panic/Interface/: Panic.h
  group framework/Panic/source
    ../../../../../../../middleware/wireless/framework/Panic/Source/: Panic.c
  group framework/RNG/interface
    ../../../../../../../middleware/wireless/framework/RNG/Interface/: RNG_Interface.h
  group framework/RNG/source
    ../../../../../../../middleware/wireless/framework/RNG/Source/: RNG.c
  group framework/NVM/interface
    ../../../../../../../middleware/wireless/framework/NVM/Interface/: NVM_Interface.h
  group framework/NVM/source
    ../../../../../../../middleware/wireless/framework/NVM/Source/: NV_Flash.c NV_Flash.h NV_FsciCommands.c NV_FsciCommands.h
  group framework/MWSCoexistence/interface
    ../../../../../../../middleware/wireless/framework/MWSCoexistence/Interface/: MWS.h
  group framework/MWSCoexistence/source
    ../../../../../../../middleware/wireless/framework/MWSCoexistence/Source/: MWS.c
  group framework/SerialManager/interface
    ../../../../../../../middleware/wireless/framework/SerialManager/Interface/: SerialManager.h
  group framework/SerialManager/source
    ../../../../../../../middleware/wireless/framework/SerialManager/Source/: SerialManager.c UART_Serial_Adapter.c UART_Serial_Adapter.h
  group framework/TimersManager/interface
    ../../../../../../../middleware/wireless/framework/TimersManager/Interface/: TimersManager.h
  group framework/TimersManager/source
    ../../../../../../../middleware/wireless/framework/TimersManager/Source/: TMR_Adapter.c TMR_Adapter.h TimersManager.c TimersManagerInternal.h
  group framework/ModuleInfo/source
    ../../../../../../../middleware/wireless/framework/ModuleInfo/: ModuleInfo.c
  group framework/ModuleInfo/interface
    ../../../../../../../middleware/wireless/framework/ModuleInfo/: ModuleInfo.h
  group framework/FunctionLib/source
    ../../../../../../../middleware/wireless/framework/FunctionLib/: FunctionLib.c
  group framework/FunctionLib/interface
    ../../../../../../../middleware/wireless/framework/FunctionLib/: FunctionLib.h
  group framework/Lists/source
    ../../../../../../../middleware/wireless/framework/Lists/: GenericList.c
  group framework/Lists/interface
    ../../../../../../../middleware/wireless/framework/Lists/: GenericList.h
  group framework/SecLib/interface
    ../../../../../../../middleware/wireless/framework/SecLib/: CryptoLibSW.h SecLib.h
  group framework/SecLib/source
    ../../../../../../../middleware/wireless/framework/SecLib/: SecLib.c
  group framework/Shell/interface
    ../../../../../../../middleware/wireless/framework/Shell/Interface/: shell.h shell_config.h
  group framework/Shell/source
    ../../../../../../../middleware/wireless/framework/Shell/Source/: shell.c shell_autocomplete.c shell_autocomplete.h shell_cmdhelp.c shell_cmdhist.c
  group framework/LowPower/interface
    ../../../../../../../middleware/wireless/framework/LowPower/Interface/MKW38Z4/: PWR_Configuration.h PWR_Interface.h
  group framework/LowPower/source
    ../../../../../../../middleware/wireless/framework/LowPower/Source/MKW38Z4/: PWR.c PWRLib.c PWRLib.h
  group framework/DCDC/interface
    ../../../../../../../middleware/wireless/framework/DCDC/Interface/MKW38Z4/: DCDC.h
  group framework/DCDC/source
    ../../../../../../../middleware/wireless/framework/DCDC/Source/MKW38Z4/: DCDC.c
  group framework/XCVR/MKW38Z4
    ../../../../../../../middleware/wireless/framework/XCVR/MKW38Z4/drv/: dbg_ram_capture.c dbg_ram_capture.h dma_capture.c dma_capture.h mathfp.c mathfp.h nxp_xcvr_ext_ctrl.c nxp_xcvr_ext_ctrl.h rsim_ctrl.c rsim_ctrl.h
  group framework/XCVR/MKW38Z4/nb2p4ghz
    ../../../../../../../middleware/wireless/framework/XCVR/MKW38Z4/drv/nb2p4ghz/: nxp2p4_xcvr.c nxp2p4_xcvr.h nxp_xcvr_trim.c nxp_xcvr_trim.h
  group framework/XCVR/MKW38Z4/nb2p4ghz/configs
    ../../../../../../../middleware/wireless/framework/XCVR/MKW38Z4/drv/nb2p4ghz/configs/gen35/: nxp_xcvr_coding_config.c nxp_xcvr_coding_config.h nxp_xcvr_common_config.c nxp_xcvr_common_config.h nxp_xcvr_gfsk_bt_0p5_h_0p32_config.c nxp_xcvr_gfsk_bt_0p5_h_0p32_config.h nxp_xcvr_gfsk_bt_0p5_h_0p5_config.c nxp_xcvr_gfsk_bt_0p5_h_0p5_config.h nxp_xcvr_gfsk_bt_0p5_h_0p7_config.c nxp_xcvr_gfsk_bt_0p5_h_0p7_config.h nxp_xcvr_gfsk_bt_0p5_h_1p0_config.c nxp_xcvr_gfsk_bt_0p5_h_1p0_config.h nxp_xcvr_mode_config.c nxp_xcvr_mode_config.h nxp_xcvr_msk_config.c nxp_xcvr_msk_config.h
  group bluetooth/host/config
    ../../../../../../../middleware/wireless/bluetooth/host/config/: ble_config.h ble_globals.c
  group bluetooth/host/interface
    ../../../../../../../middleware/wireless/bluetooth/host/interface/: att_callbacks.h att_errors.h att_interface.h att_params.h att_types.h ble_constants.h ble_general.h ble_host_tasks.h ble_sig_defines.h ble_utils.h gap_interface.h gap_types.h gatt_client_interface.h gatt_database.h gatt_db_app_interface.h gatt_db_att_interface.h gatt_db_dynamic.h gatt_interface.h gatt_server_interface.h gatt_types.h l2ca_cb_interface.h l2ca_interface.h l2ca_types.h vendor_debug_commands.h
  group bluetooth/controller/config
    ../../../../../../../middleware/wireless/ble_controller/config/: ble_controller_task_config.h ble_ll_config.h ble_ll_globals.c
  group bluetooth/controller/interface
    ../../../../../../../middleware/wireless/ble_controller/interface/: controller_interface.h
    ../../../../../../../middleware/wireless/ble_controller/src/MKW38/: controller_init.c
  group bluetooth/controller/task
    ../../../../../../../middleware/wireless/ble_controller/src/: ble_controller_task.c
  group bluetooth/profiles/battery
    ../../../../../../../middleware/wireless/bluetooth/profiles/battery/: battery_interface.h battery_service.c
  group bluetooth/profiles/device_info
    ../../../../../../../middleware/wireless/bluetooth/profiles/device_info/: device_info_interface.h device_info_service.c
  group bluetooth/profiles/temperature
    ../../../../../../../middleware/wireless/bluetooth/profiles/temperature/: temperature_interface.h temperature_service.c
  group drivers
    ../../../../../../../devices/MKW38A4/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_lptmr.c fsl_lptmr.h fsl_port.h fsl_smc.c fsl_smc.h fsl_gpio.c fsl_gpio.h fsl_flash.h fsl_ftfx_adapter.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_features.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_ftfx_utilities.h fsl_edma.c fsl_edma.h fsl_dmamux.c fsl_dmamux.h fsl_pmc.c fsl_pmc.h fsl_adc16.c fsl_adc16.h fsl_flexcan.c fsl_flexcan.h fsl_ltc.c fsl_ltc.h fsl_trng.c fsl_trng.h fsl_tpm.c fsl_tpm.h fsl_rtc.c fsl_rtc.h fsl_power.c fsl_power.h fsl_dspi.c fsl_dspi.h
  group device
    ../../../../../../../devices/MKW38A4/: MKW38A4.h MKW38A4_features.h fsl_device_registers.h system_MKW38A4.c system_MKW38A4.h
  group startup
    ../../../../../../../devices/MKW38A4/iar/: startup_MKW38A4.s
  group component/uart
    ../../../../../../../components/uart/: lpuart_adapter.c uart.h
  group component/serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
  group utilities
    ../../../../../../../devices/MKW38A4/utilities/: fsl_assert.c
    ../../../../../../../devices/MKW38A4/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/MKW38A4/utilities/str/: fsl_str.c fsl_str.h
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm0plus.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h
