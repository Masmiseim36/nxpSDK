<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>blood_pressure_sensor_bm</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>blood_pressure_sensor_bm</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>blood_pressure_sensor_bm</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>blood_pressure_sensor_bm</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/blood_pressure_sensor_bm.ewp</path>
  </project>
</workspace>
