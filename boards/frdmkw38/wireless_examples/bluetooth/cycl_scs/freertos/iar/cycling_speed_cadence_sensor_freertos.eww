<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>cycling_speed_cadence_sensor_freertos</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>cycling_speed_cadence_sensor_freertos</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>cycling_speed_cadence_sensor_freertos</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>cycling_speed_cadence_sensor_freertos</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/cycling_speed_cadence_sensor_freertos.ewp</path>
  </project>
</workspace>
