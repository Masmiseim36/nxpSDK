# IAR project bootloader_otap.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW38A512xxx4 NXP MKW38A512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; GCOV_DO_COVERAGE=0; CPU_MKW38A512VFT4; gEepromType_d=gEepromDevice_AT45DB041E_c; gUseOTAPBootloader_d=1; CR_INTEGER_PRINTF; FRDM_KW38; CFG_BLE_PRJ=1; ENABLE_RAM_VECTOR_TABLE=1; UNITY_CUSTOM_OUTPUT_CHAR=1
  ICCARM.PreInclude: ../../../../../../../boards/frdmkw38/wireless_examples/framework/bootloader_otap/bm/app_preinclude.h
  ICCARM.CCIncludePath2: ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../devices/MKW38A4; ../../../../../../../devices/MKW38A4/drivers; ..; ../../src/bootloader; ../../src/eeprom; ../../src/spi; ../../src/timer; ../../src/uart; ../../../../../../../middleware/wireless/framework/Common; ../../../../../../../middleware/wireless/framework/FunctionLib; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../devices/MKW38A4/drivers; ../../../../../../../devices/MKW38A4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: bootloader_otap_frdmkw38.bin
  ILINK.IlinkOutputFile: bootloader_otap.out
  ILINK.IlinkConfigDefines: gRomSize_c=524288; gSectorSize_c=2048; __heap_size__=0; gUseNVMLink_d=1; gEraseNVMLink_d=1; __ram_vector_table__=1
  ILINK.IlinkIcfFile: MKW38A512xxx4_PD_bootloader.icf
  ILINK.IlinkProgramEntryLabel: main
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; GCOV_DO_COVERAGE=0; CPU_MKW38A512VFT4; gEepromType_d=gEepromDevice_AT45DB041E_c; gUseOTAPBootloader_d=1; CR_INTEGER_PRINTF; FRDM_KW38; CFG_BLE_PRJ=1; ENABLE_RAM_VECTOR_TABLE=1; UNITY_CUSTOM_OUTPUT_CHAR=1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: NDEBUG
  group board
    ../: pin_mux.c pin_mux.h clock_config.c clock_config.h
  group source
    ../../src/bootloader/: OtapBootloader.c OtapBootloader.h main.c main.h
    ../: app_preinclude.h
  group source/drivers/eeprom
    ../../src/eeprom/: Eeprom_Boot.h Eeprom_Boot_AT45DB041E.c Eeprom_Boot_InternalFlash.c
  group source/drivers/spi
    ../../src/spi/: SPI.c SPI.h
  group source/drivers/timer
    ../../src/timer/: timer.c timer.h
  group source/drivers/uart
    ../../src/uart/: UART.c UART.h
  group doc
    ../../: readme.txt
  group framework/Common
    ../../../../../../../middleware/wireless/framework/Common/: EmbeddedTypes.h
  group framework/FunctionLib/source
    ../../../../../../../middleware/wireless/framework/FunctionLib/: FunctionLib.c
  group framework/FunctionLib/interface
    ../../../../../../../middleware/wireless/framework/FunctionLib/: FunctionLib.h
  group drivers
    ../../../../../../../devices/MKW38A4/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flash.h fsl_ftfx_adapter.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_features.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_ftfx_utilities.h fsl_rtc.c fsl_rtc.h fsl_port.h fsl_gpio.c fsl_gpio.h
  group device
    ../../../../../../../devices/MKW38A4/: MKW38A4.h MKW38A4_features.h fsl_device_registers.h system_MKW38A4.c system_MKW38A4.h
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm0plus.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h
