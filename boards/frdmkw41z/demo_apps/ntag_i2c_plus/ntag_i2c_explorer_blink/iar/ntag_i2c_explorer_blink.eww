<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>ntag_i2c_explorer_blink</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>ntag_i2c_explorer_blink</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>ntag_i2c_explorer_blink</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>ntag_i2c_explorer_blink</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/ntag_i2c_explorer_blink.ewp</path>
  </project>
</workspace>
