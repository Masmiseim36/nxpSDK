# IAR project ntag_i2c_explorer_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW41Z512xxx4 NXP MKW41Z512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKW41Z512VHT4; PRINTF_ADVANCED_ENABLE=1; I2C_FSL; HAVE_STDBOOL_H; HAVE_STDINT_H; FRDM_KW41Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../devices; ..; ../../../../../../middleware/ntag_i2c_plus_1.0.0/inc; ../../../../../../middleware/ntag_i2c_plus_1.0.0/HAL_I2C/inc; ../../../../../../middleware/ntag_i2c_plus_1.0.0/HAL_ISR; ../../../../../../middleware/ntag_i2c_plus_1.0.0/HAL_ISR/inc; ../../../../../../middleware/ntag_i2c_plus_1.0.0/HAL_NTAG/inc; ../../../../../../middleware/ntag_i2c_plus_1.0.0/HAL_NTAG; ../../../../../../middleware/ntag_i2c_plus_1.0.0/HAL_TMR/inc; ../../../..; ../../../../../../devices/MKW41Z4/drivers; ../../../../../../devices/MKW41Z4/utilities; ../../../../../../devices/MKW41Z4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: ntag_i2c_explorer_demo.out
  ILINK.IlinkIcfFile: MKW41Z512xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW41Z512VHT4; PRINTF_ADVANCED_ENABLE=1; I2C_FSL; HAVE_STDBOOL_H; HAVE_STDINT_H; FRDM_KW41Z; FREEDOM
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/MKW41Z4/iar/: startup_MKW41Z4.s
    ../../../../../../devices/MKW41Z4/: system_MKW41Z4.c system_MKW41Z4.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MKW41Z4/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_lptmr.c fsl_lptmr.h fsl_gpio.h fsl_gpio.c fsl_port.h fsl_smc.h fsl_smc.c fsl_adc16.c fsl_adc16.h fsl_i2c.h fsl_i2c.c fsl_common.h fsl_common.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group source
    ../: ntag_i2c_explorer_demo.c crc32.c crc32.h ndef_message.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../devices/MKW41Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
  group ntag_i2c_plus/HAL_NTAG
    ../../../../../../middleware/ntag_i2c_plus_1.0.0/HAL_NTAG/inc/: ntag_bridge.h ntag_defines.h ntag_device_list.h ntag_driver.h
    ../../../../../../middleware/ntag_i2c_plus_1.0.0/HAL_NTAG/: ntag_driver_intern.h ntag_bridge.c ntag_driver.c
  group ntag_i2c_plus/HAL_I2C
    ../../../../../../middleware/ntag_i2c_plus_1.0.0/HAL_I2C/inc/: HAL_I2C_driver.h HAL_I2C_kinetis_fsl.h
    ../../../../../../middleware/ntag_i2c_plus_1.0.0/HAL_I2C/: i2c_kinetis_fsl.c
  group ntag_i2c_plus/HAL_ISR
    ../../../../../../middleware/ntag_i2c_plus_1.0.0/HAL_ISR/inc/: HAL_ISR_callback_list.h HAL_ISR_driver.h
    ../../../../../../middleware/ntag_i2c_plus_1.0.0/HAL_ISR/: isr_driver_intern.h isr_kinetis_intern.h isr_common.c isr_kinetis.c
  group ntag_i2c_plus/HAL_TMR
    ../../../../../../middleware/ntag_i2c_plus_1.0.0/HAL_TMR/inc/: HAL_timer_driver.h
    ../../../../../../middleware/ntag_i2c_plus_1.0.0/HAL_TMR/: timer_kinetis.c
  group ntag_i2c_plus/ntag_i2c_plus_include
    ../../../../../../middleware/ntag_i2c_plus_1.0.0/inc/: global_types.h nfc_device.h
