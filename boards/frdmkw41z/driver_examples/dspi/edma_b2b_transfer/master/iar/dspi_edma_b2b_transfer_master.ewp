# IAR project dspi_edma_b2b_transfer_master.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW41Z512xxx4 NXP MKW41Z512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKW41Z512VHT4; FRDM_KW41Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../../CMSIS/Include; ../../../../../../../devices; ..; ../../../../..; ../../../../../../../devices/MKW41Z4/drivers; ../../../../../../../devices/MKW41Z4/utilities; ../../../../../../../devices/MKW41Z4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: dspi_edma_b2b_transfer_master.out
  ILINK.IlinkIcfFile: MKW41Z512xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW41Z512VHT4; FRDM_KW41Z; FREEDOM
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../../devices/MKW41Z4/iar/: startup_MKW41Z4.s
    ../../../../../../../devices/MKW41Z4/: system_MKW41Z4.c system_MKW41Z4.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MKW41Z4/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_lptmr.c fsl_lptmr.h fsl_port.h fsl_dspi.h fsl_dspi.c fsl_dspi_edma.h fsl_dspi_edma.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group source
    ../: dspi_edma_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../../devices/MKW41Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
