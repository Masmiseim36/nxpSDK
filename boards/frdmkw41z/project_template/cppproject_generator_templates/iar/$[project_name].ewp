# IAR project $[project_name].ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW41Z512xxx4 NXP MKW41Z512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../platform/drivers; ../../../../../devices/MKW41Z4/drivers; ../../../../../devices/MKW41Z4/utilities; ../../../../../devices/MKW41Z4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: cppproject_templates.out
  ILINK.IlinkIcfFile: MKW41Z512xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../devices/MKW41Z4/iar/: startup_MKW41Z4.s
    ../../../../../devices/MKW41Z4/: system_MKW41Z4.c system_MKW41Z4.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKW41Z4/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_lptmr.c fsl_lptmr.h fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group utilities
    ../../../../../devices/MKW41Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
