<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>wireless_power_ptu_freertos</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>wireless_power_ptu_freertos</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>wireless_power_ptu_freertos</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>wireless_power_ptu_freertos</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/wireless_power_ptu_freertos.ewp</path>
  </project>
</workspace>
