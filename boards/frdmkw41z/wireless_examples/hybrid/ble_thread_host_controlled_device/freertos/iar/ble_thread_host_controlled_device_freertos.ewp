# IAR project ble_thread_host_controlled_device_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW41Z512xxx4 NXP MKW41Z512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKW41Z512VHT4; FSL_RTOS_FREE_RTOS; FRDM_KW41Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.PreInclude: ../../../../../../../middleware/wireless/nwk_ip_1.2.8/examples/ble_thread_host_controlled_device/config/config.h
  ICCARM.CCIncludePath2: ../../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM0; ../../../../../../../rtos/freertos_9.0.0/Source/include; ..; ../../../../../../../rtos/freertos_9.0.0/Source; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../middleware/wireless/framework_5.3.8/OSAbstraction/Interface; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/mac/source/App; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/mac/interface; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/phy/interface; ../../../../../../../middleware/wireless/framework_5.3.8/GPIO; ../../../../../../../middleware/wireless/framework_5.3.8/Keyboard/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/LED/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/SerialManager/Source/SPI_Adapter; ../../../../../../../middleware/wireless/framework_5.3.8/SerialManager/Source; ../../../../../../../middleware/wireless/framework_5.3.8/Flash/Internal; ../../../../../../../middleware/wireless/framework_5.3.8/Common; ../../../../../../../middleware/wireless/framework_5.3.8/FSCI/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/FSCI/Source; ../../../../../../../middleware/wireless/framework_5.3.8/MemManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/Messaging/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/LowPower/Interface/MKW41Z; ../../../../../../../middleware/wireless/framework_5.3.8/Shell/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/NVM/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/NVM/Source; ../../../../../../../middleware/wireless/framework_5.3.8/Panic/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/RNG/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/SerialManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/TimersManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/TimersManager/Source; ../../../../../../../middleware/wireless/framework_5.3.8/SecLib; ../../../../../../../middleware/wireless/framework_5.3.8/Lists; ../../../../../../../middleware/wireless/framework_5.3.8/FunctionLib; ../../../../../../../middleware/wireless/framework_5.3.8/ModuleInfo; ../../../../../../../middleware/wireless/bluetooth_1.2.9/application/common; ../../../../../../../middleware/wireless/bluetooth_1.2.9/controller/interface; ../../../../../../../middleware/wireless/bluetooth_1.2.9/hci_transport/interface; ../../../../../../../middleware/wireless/bluetooth_1.2.9/application/common/gatt_db; ../../../../../../../middleware/wireless/bluetooth_1.2.9/application/common/gatt_db/macros; ../../../../../../../middleware/wireless/bluetooth_1.2.9/profiles/battery; ../../../../../../../middleware/wireless/bluetooth_1.2.9/profiles/device_info; ../../../../../../../middleware/wireless/bluetooth_1.2.9/profiles/wireless_uart; ../../../../../../../middleware/wireless/bluetooth_1.2.9/host/interface; ../../../../../../../middleware/wireless/bluetooth_1.2.9/host/config; ../../../../../../../middleware/wireless/framework_5.3.8/MWSCoexistence/Interface; ../../../../../../../middleware/wireless/nwk_ip_1.2.8/core/interface/modules; ../../../../../../../middleware/wireless/nwk_ip_1.2.8/core/interface/thread; ../../../../../../../middleware/wireless/nwk_ip_1.2.8/core/interface/http; ../../../../../../../middleware/wireless/nwk_ip_1.2.8/core/interface; ../../../../../../../middleware/wireless/nwk_ip_1.2.8/base/interface; ../../../../../../../middleware/wireless/nwk_ip_1.2.8/examples/common; ../../../../../../../middleware/wireless/nwk_ip_1.2.8/examples/ble_thread_host_controlled_device/src; ../../../../../../../devices/MKW41Z4/drivers; ../../../../../../../middleware/wireless/framework_5.3.8/DCDC/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/XCVR/MKW41Z4; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/phy/source/MKW41Z; ../../../../../../../devices/MKW41Z4; ../../../../../../../devices/MKW41Z4/utilities
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: ble_thread_host_controlled_device_frdmkw41z.srec
  ILINK.IlinkOutputFile: ble_thread_host_controlled_device_freertos.out
  ILINK.IlinkConfigDefines: gUseBootloaderLink_d=0; gUseNVMLink_d=1; __ram_vector_table__=1; gUseInternalStorageLink_d=0; gNVMSectorCountLink_d=26; gEraseNVMLink_d=1
  ILINK.IlinkIcfFile: MKW41Z512xxx4_connectivity.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../middleware/wireless/bluetooth_1.2.9/host/lib/lib_ble_4-2_host_fsci_cm0p.a; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/mac/lib/lib802.15.4_mac_thr_cm0.a; ../../../../../../../middleware/wireless/bluetooth_1.2.9/controller/lib/lib_ble_kw41z_controller.a; ../../../../../../../middleware/wireless/framework_5.3.8/SecLib/lib_crypto_m0.a; ../../../../../../../middleware/wireless/nwk_ip_1.2.8/core/lib/thread/lib_thread_br_cm0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW41Z512VHT4; FSL_RTOS_FREE_RTOS; FRDM_KW41Z; FREEDOM
  ICCARM.CCOptStrategy: 1
  group freertos
    ../../../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
    ../../../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
    ../../../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group freertos/portable
    ../../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM0/: port.c fsl_tickless_systick.c fsl_tickless_generic.h portasm.s portmacro.h
  group startup
    ../../../../../../../devices/MKW41Z4/iar/: startup_MKW41Z4.s
    ../../../../../../../devices/MKW41Z4/: system_MKW41Z4.c system_MKW41Z4.h
  group framework/OSAbstraction
    ../../../../../../../middleware/wireless/framework_5.3.8/OSAbstraction/Interface/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h
    ../../../../../../../middleware/wireless/framework_5.3.8/OSAbstraction/Source/: fsl_os_abstraction_free_rtos.c
  group framework/OSAbstraction/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/OSAbstraction/Interface/: fsl_os_abstraction.h fsl_os_abstraction_config.h
  group framework/GPIO/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/GPIO/: GPIO_Adapter.h
  group framework/GPIO/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/GPIO/: GPIO_Adapter.c
  group framework/Keyboard/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/Keyboard/Interface/: Keyboard.h
  group framework/Keyboard/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/Keyboard/Source/: Keyboard.c
  group framework/LED/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/LED/Interface/: LED.h
  group framework/LED/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/LED/Source/: LED.c
  group framework/Reset/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/Reset/: Reset.c
  group framework/SerialManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/SerialManager/Source/: UART_Adapter.h UART_Adapter.c I2C_Adapter.h I2C_Adapter.c SerialManager.c
  group framework/SerialManager/Source/SPI_Adapter
    ../../../../../../../middleware/wireless/framework_5.3.8/SerialManager/Source/SPI_Adapter/: SPI_Adapter.h SPI_Adapter.c
  group framework/SerialManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/SerialManager/Interface/: SerialManager.h
  group framework/Flash/Internal
    ../../../../../../../middleware/wireless/framework_5.3.8/Flash/Internal/: Flash_Adapter.h Flash_Adapter.c
  group framework/Common
    ../../../../../../../middleware/wireless/framework_5.3.8/Common/: EmbeddedTypes.h
  group framework/FSCI/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/FSCI/Interface/: FsciInterface.h
  group framework/FSCI/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/FSCI/Source/: FsciCommands.c FsciCommands.h FsciCommunication.c FsciCommunication.h FsciLogging.c FsciMain.c
  group framework/MemManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/MemManager/Interface/: MemManager.h
  group framework/MemManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/MemManager/Source/: MemManager.c
  group framework/Messaging/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/Messaging/Source/: Messaging.c
  group framework/LowPower/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/LowPower/Interface/MKW41Z/: PWR_Configuration.h PWR_Interface.h
  group framework/LowPower/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/LowPower/Source/MKW41Z/: PWR.c PWRLib.c PWRLib.h PWR_BLE.c PWR_BLE.h
  group framework/Shell/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/Shell/Interface/: shell.h shell_config.h
  group framework/Shell/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/Shell/Source/: shell.c shell_autocomplete.c shell_cmdhelp.c shell_cmdhist.c
  group framework/NVM/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/NVM/Interface/: NVM_Interface.h
  group framework/NVM/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/NVM/Source/: NV_Flash.c NV_Flash.h NV_FsciCommands.c NV_FsciCommands.h
  group framework/Panic/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/Panic/Interface/: Panic.h
  group framework/Panic/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/Panic/Source/: Panic.c
  group framework/RNG/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/RNG/Source/: RNG.c
  group framework/TimersManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/TimersManager/Interface/: TimersManager.h
  group framework/TimersManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/TimersManager/Source/: TimersManager.c TimersManagerInternal.h TMR_Adapter.h TMR_Adapter.c
  group framework/SecLib
    ../../../../../../../middleware/wireless/framework_5.3.8/SecLib/: SecLib.h SecLib.c
  group framework/Lists
    ../../../../../../../middleware/wireless/framework_5.3.8/Lists/: GenericList.c GenericList.h
  group framework/FunctionLib
    ../../../../../../../middleware/wireless/framework_5.3.8/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/ModuleInfo
    ../../../../../../../middleware/wireless/framework_5.3.8/ModuleInfo/: ModuleInfo.h ModuleInfo.c
  group framework/MWSCoexistence/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/MWSCoexistence/Interface/: MWS.h
  group framework/MWSCoexistence/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/MWSCoexistence/Source/: MWS.c
  group framework/DCDC/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/DCDC/Interface/: DCDC.h
  group framework/DCDC/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/DCDC/Source/: DCDC.c
  group framework/XCVR/MKW41Z4
    ../../../../../../../middleware/wireless/framework_5.3.8/XCVR/MKW41Z4/: fsl_xcvr.c fsl_xcvr.h ifr_radio.c ifr_radio.h fsl_xcvr_trim.c fsl_xcvr_trim.h dbg_ram_capture.c dbg_ram_capture.h
    ../../../../../../../middleware/wireless/framework_5.3.8/XCVR/MKW41Z4/cfgs_kw4x_3x_2x/: fsl_xcvr_ble_config.c fsl_xcvr_ant_config.c fsl_xcvr_zgbe_config.c fsl_xcvr_msk_config.c fsl_xcvr_common_config.c fsl_xcvr_mode_datarate_config.c fsl_xcvr_gfsk_bt_0p3_h_0p5_config.c fsl_xcvr_gfsk_bt_0p5_h_0p5_config.c fsl_xcvr_gfsk_bt_0p5_h_0p7_config.c fsl_xcvr_gfsk_bt_0p5_h_0p32_config.c fsl_xcvr_gfsk_bt_0p5_h_1p0_config.c fsl_xcvr_gfsk_bt_0p7_h_0p5_config.c
  group board
    ../: board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h clock_config.c clock_config.h
  group source
    ../: FreeRTOSConfig.h
    ../../../../../../../middleware/wireless/nwk_ip_1.2.8/examples/ble_thread_host_controlled_device/config/: config.h
    ../../../../../../../middleware/wireless/nwk_ip_1.2.8/examples/ble_thread_host_controlled_device/src/: app.c app.h app_config.c gatt_db.h gatt_uuid128.h ApplMain.c ApplMain.h ble_init.h ble_init.c host_controlled_device_hybrid_app.c host_controlled_device_hybrid_app.h
  group source/common
    ../../../../../../../middleware/wireless/bluetooth_1.2.9/application/common/: ble_controller_task.c ble_controller_task_config.h ieee11073.h ble_service_discovery.c ble_service_discovery.h ble_host_tasks.c ble_host_task_config.h ble_conn_manager.c ble_conn_manager.h
  group source/common/gatt_db
    ../../../../../../../middleware/wireless/bluetooth_1.2.9/application/common/gatt_db/: gatt_database.c gatt_db_handles.h
  group source/common/gatt_db/macros
    ../../../../../../../middleware/wireless/bluetooth_1.2.9/application/common/gatt_db/macros/: gatt_alloc_x.h gatt_db_macros.h gatt_db_x_macros.h gatt_decl_x.h gatt_enum_x.h gatt_init_x.h gatt_size_x.h gatt_uuid_decl_x.h gatt_uuid_def_x.h
  group ieee_802.15.4/App
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/mac/source/App/: FsciAspCommands.h FsciAspCommands.c FsciMacCommands.h FsciMacCommands.c MacGlobals.c MacGlobals.h
  group ieee_802.15.4/mac/interface
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/mac/interface/: MacFunctionalityDefines.h MacInterface.h MacMessages.h MacTypes.h
  group ieee_802.15.4/phy/Interface
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/phy/interface/: AspInterface.h MpmInterface.h PhyDebug.h PhyInterface.h PhyMessages.h PhyTypes.h
  group ieee_802.15.4/phy/source
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/phy/source/MKW41Z/: Phy.h ASP.c MPM.c PhyISR.c PhyPacketProcessor.c PhyPlmeData.c PhyStateMachine.c PhyTime.c
  group bluetooth/controller/interface
    ../../../../../../../middleware/wireless/bluetooth_1.2.9/controller/interface/: controller_interface.h
  group bluetooth/hci_transport/interface
    ../../../../../../../middleware/wireless/bluetooth_1.2.9/hci_transport/interface/: hci_transport.h
  group bluetooth/hci_transport/source
    ../../../../../../../middleware/wireless/bluetooth_1.2.9/hci_transport/source/: hcit_serial_interface.c
  group bluetooth/profiles/battery
    ../../../../../../../middleware/wireless/bluetooth_1.2.9/profiles/battery/: battery_service.c battery_interface.h
  group bluetooth/profiles/device_info
    ../../../../../../../middleware/wireless/bluetooth_1.2.9/profiles/device_info/: device_info_service.c device_info_interface.h
  group bluetooth/profiles/wireless_uart
    ../../../../../../../middleware/wireless/bluetooth_1.2.9/profiles/wireless_uart/: wireless_uart_service.c wireless_uart_interface.h
  group bluetooth/host/interface
    ../../../../../../../middleware/wireless/bluetooth_1.2.9/host/interface/: att_callbacks.h att_errors.h att_interface.h att_params.h att_types.h ble_constants.h ble_general.h ble_host_tasks.h ble_sig_defines.h ble_utils.h gap_interface.h gap_types.h gatt_client_interface.h gatt_database.h gatt_db_app_interface.h gatt_db_dynamic.h gatt_interface.h gatt_server_interface.h gatt_types.h hci_interface.h hci_types.h l2ca_cb_interface.h l2ca_interface.h l2ca_types.h vendor_debug_commands.h att_errors.h att_types.h ble_constants.h ble_general.h ble_sig_defines.h ble_utils.h fsci_ble_interface.h gap_interface.h gap_types.h gatt_client_interface.h gatt_database.h gatt_db_app_interface.h gatt_interface.h gatt_server_interface.h gatt_types.h gatt_db_dynamic.h l2ca_cb_interface.h l2ca_interface.h l2ca_types.h vendor_debug_commands.h
  group bluetooth/host/config
    ../../../../../../../middleware/wireless/bluetooth_1.2.9/host/config/: ble_config.h ble_globals.c ble_config.h ble_globals.c
  group nwk_ip/core/interface
    ../../../../../../../middleware/wireless/nwk_ip_1.2.8/core/interface/: network_utils.h sockets.h stack_events.h
  group nwk_ip/core/interface/modules
    ../../../../../../../middleware/wireless/nwk_ip_1.2.8/core/interface/modules/: arp.h coap.h coap_cfg.h dhcp.h dhcp_cfg.h dhcp_client.h dhcp_server.h dhcp6.h dhcp6_cfg.h dhcp6_client.h dhcp6_lq_client.h dhcp6_lq_server.h dhcp6_relay_agent.h dhcp6_server.h dns_client.h dns_client_cfg.h dns_utils.h dtls.h dtls_cfg.h event_manager.h event_manager_cfg.h icmp.h icmp4.h icmp6.h igmp.h ip.h ip4.h ip6.h ip_cfg.h ip_if_management.h mdns.h mdns_cfg.h mld.h mle.h mle_basic.h mle_cfg.h mle_extended.h mle_security.h mle_utils.h mpl.h mpl_cfg.h nd.h nd_cfg.h nd_events.h nd_sixlowpan.h nd_tables.h pmtu_discovery.h rfc4944_6lowpan.h rfc6282_header_comp.h session.h sixlowpan.h sixlowpan_cfg.h sixlowpan_fwd_thread.h sixlowpan_ib.h sixlowpan_interface.h sixlowpan_tbl.h sockets_cfg.h stack_config.h stack_manager_if.h tcp.h tcp_cfg.h thread_stack_config.h trickle.h trickle_cfg.h udp.h udp_cfg.h version.h
  group nwk_ip/core/interface/thread
    ../../../../../../../middleware/wireless/nwk_ip_1.2.8/core/interface/thread/: thread_app_callbacks.h thread_attributes.h thread_cfg.h thread_dns.h thread_meshcop.h thread_meshcop_mgmt.h thread_network.h thread_types.h thread_utils.h
    ../../../../../../../middleware/wireless/nwk_ip_1.2.8/core/thread/interface/: thread_network_data.h thread_server_data.h
  group nwk_ip/core/interface/http
    ../../../../../../../middleware/wireless/nwk_ip_1.2.8/core/interface/http/: http.h http_cfg.h
  group nwk_ip/base/interface
    ../../../../../../../middleware/wireless/nwk_ip_1.2.8/base/interface/: debug_log.h ip_if_6LowPan.h ip_if_enet.h ip_if_usbenet.h mac_abs_802154.h mac_abs_types.h mac_filtering.h mac_filtering_cfg.h nv_data.h nvm_adapter.h shell_ip.h thci.h ip_if_serial_tun.h serial_tun_driver.h
  group nwk_ip/base/ip_media_if
    ../../../../../../../middleware/wireless/nwk_ip_1.2.8/base/ip_media_if/: ip_if_6lo.c ip_if_loopback.c ip_if_enet.c ip_if_usbenet.c ip_if_serial_tun.c serial_tun_driver.c
  group nwk_ip/base/shell
    ../../../../../../../middleware/wireless/nwk_ip_1.2.8/base/shell/: shell_ip.c
  group nwk_ip/base/stack_globals
    ../../../../../../../middleware/wireless/nwk_ip_1.2.8/base/stack_globals/: arp_globals.c coap_globals.c dhcp_globals.c dns_globals.c dtls_globals.c event_manager_globals.c icmp_globals.c ip_globals.c mdns_globals.c mle_globals.c mpl_globals.c nd_globals.c sixlowpan_globals.c sockets_globals.c tcp_globals.c thread_globals.c trickle_globals.c udp_globals.c
  group nwk_ip/base/thci
    ../../../../../../../middleware/wireless/nwk_ip_1.2.8/base/thci/: thci.c
  group nwk_ip/base/thread_config
    ../../../../../../../middleware/wireless/nwk_ip_1.2.8/base/thread_config/: thread_config.c
  group nwk_ip/base/utils
    ../../../../../../../middleware/wireless/nwk_ip_1.2.8/base/utils/: debug_log.c mac_abs_802154.c mac_filtering.c nv_data.c nvm_adapter.c
  group nwk_ip/app/config
    ../../../../../../../middleware/wireless/nwk_ip_1.2.8/examples/common/: app_config.h app_framework_config.h app_mac_config.h app_stack_config.h app_thread_config.h
  group nwk_ip/app/common
    ../../../../../../../middleware/wireless/nwk_ip_1.2.8/examples/common/: app_coap_observe.c app_coap_observe.h app_echo_udp.c app_echo_udp.h app_event_monitoring.c app_event_monitoring.h app_init.c app_init.h app_led.c app_led.h app_observe_demo.c app_observe_demo.h app_socket_utils.c app_socket_utils.h app_temp_sensor.c app_temp_sensor.h app_thread_callbacks.c app_thread_init.c app_border_router.c app_border_router.h app_ethernet.c app_ethernet.h app_ethernet_usb.c app_ethernet_usb.h app_serial_tun.c app_serial_tun.h
  group doc
    ../../: readme.txt
  group drivers
    ../../../../../../../devices/MKW41Z4/drivers/: fsl_common.h fsl_common.c fsl_trng.c fsl_trng.h fsl_flash.c fsl_flash.h fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_tpm.c fsl_tpm.h fsl_dspi.h fsl_dspi.c fsl_i2c.h fsl_i2c.c fsl_lptmr.c fsl_lptmr.h fsl_rtc.c fsl_rtc.h fsl_llwu.h fsl_llwu.c fsl_ltc.h fsl_ltc.c fsl_pmc.h fsl_pmc.c fsl_adc16.c fsl_adc16.h fsl_tsi_v4.h fsl_tsi_v4.c fsl_smc.h fsl_smc.c fsl_clock.h fsl_clock.c
  group utilities
    ../../../../../../../devices/MKW41Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
