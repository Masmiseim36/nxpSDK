# IAR project ble_zigbee_end_device_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW41Z512xxx4 NXP MKW41Z512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKW41Z512VHT4; FSL_RTOS_FREE_RTOS; I2C_FSL; FRDM_KW41Z; FREEDOM
  ICCARM.CCDiagSuppress: Pe188,Pa082,Pa050,Pe167
  ICCARM.PreInclude: ../../../../../../../boards/frdmkw41z/wireless_examples/hybrid/ble_zigbee_end_device/freertos/config.h
  ICCARM.CCIncludePath2: ../../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM0; ../../../../../../../rtos/freertos_9.0.0/Source/include; ..; ../../../../../../../rtos/freertos_9.0.0/Source; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../middleware/wireless/framework_5.3.8/OSAbstraction/Interface; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/mac/source/App; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/mac/interface; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/phy/interface; ../../../../../../../middleware/wireless/framework_5.3.8/GPIO; ../../../../../../../middleware/wireless/framework_5.3.8/Keyboard/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/LED/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/SerialManager/Source/SPI_Adapter; ../../../../../../../middleware/wireless/framework_5.3.8/SerialManager/Source; ../../../../../../../middleware/wireless/framework_5.3.8/Flash/Internal; ../../../../../../../middleware/wireless/framework_5.3.8/Flash/External/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/OtaSupport/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/Common; ../../../../../../../middleware/wireless/framework_5.3.8/MemManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/Messaging/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/LowPower/Interface/MKW41Z; ../../../../../../../middleware/wireless/framework_5.3.8/Panic/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/RNG/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/SerialManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/TimersManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/TimersManager/Source; ../../../../../../../middleware/wireless/framework_5.3.8/ModuleInfo; ../../../../../../../middleware/wireless/framework_5.3.8/FunctionLib; ../../../../../../../middleware/wireless/framework_5.3.8/Lists; ../../../../../../../middleware/wireless/framework_5.3.8/SecLib; ../../../../../../../middleware/wireless/bluetooth_1.2.9/host/interface; ../../../../../../../middleware/wireless/bluetooth_1.2.9/host/config; ../../../../../../../middleware/wireless/bluetooth_1.2.9/application/common; ../../../../../../../middleware/wireless/bluetooth_1.2.9/controller/interface; ../../../../../../../middleware/wireless/bluetooth_1.2.9/hci_transport/interface; ../../../../../../../middleware/wireless/bluetooth_1.2.9/application/common/gatt_db; ../../../../../../../middleware/wireless/bluetooth_1.2.9/application/common/gatt_db/macros; ../../../../../../../middleware/wireless/bluetooth_1.2.9/profiles/battery; ../../../../../../../middleware/wireless/bluetooth_1.2.9/profiles/device_info; ../../../../../../../middleware/wireless/bluetooth_1.2.9/profiles/wireless_uart; ../../../../../../../middleware/wireless/framework_5.3.8/MWSCoexistence/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/NVM/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/NVM/Source; ../../../../../../../middleware/wireless/framework_5.3.8/Shell/Interface; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZigbeeCommon/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZPSAPL/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZPSMAC/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZPSNWK/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZPSTSV/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/PDUM/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZigbeeCommon/Source; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/BDB/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/BDB/Source/Common; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/BDB/Source/FindAndBind; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/BDB/Source/NwkFormation; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/BDB/Source/NwkSteering; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/BDB/Source/OutOfBand; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/BDB/Source/TouchLink; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCIF/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCIF/Source; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/ApplianceManagement/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/ApplianceManagement/Source; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/Closures/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/Closures/Source; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/Commissioning/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/Commissioning/Source; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/General/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/General/Source; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/GreenPower/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/GreenPower/Source; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/HVAC/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/HVAC/Source; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/Lighting/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/Lighting/Source; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/MeasurementAndSensing/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/OTA/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/SecurityAndSafety/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/SecurityAndSafety/Source; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/SmartEnergy/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/SmartEnergy/Source; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Devices/ZGP/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Devices/ZHA/ApplianceManagement/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Devices/ZHA/Closures/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Devices/ZHA/Generic/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Devices/ZHA/HVAC/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Devices/ZHA/SecurityAndSafety/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Devices/ZHA/SmartEnergy/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Devices/ZLO/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/base/JennicCommon/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/base/PDM/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/base/PWRM/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/base/TimerServer/Include; ../../common; ../../common/ntag_i2c_plus/inc; ../../common/ntag_i2c_plus/HAL_I2C/inc; ../../common/ntag_i2c_plus/HAL_ISR; ../../common/ntag_i2c_plus/HAL_ISR/inc; ../../common/ntag_i2c_plus/HAL_NTAG/inc; ../../common/ntag_i2c_plus/HAL_NTAG; ../../common/ntag_i2c_plus/HAL_TMR/inc; ../../../../../../../devices/MKW41Z4/drivers; ../../../../../../../middleware/wireless/framework_5.3.8/DCDC/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/XCVR/MKW41Z4; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/phy/source/MKW41Z; ../../../../../../../devices/MKW41Z4; ../../../../../../../devices/MKW41Z4/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __IAR_SYSTEMS_ICC__
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: ble_zigbee_end_device_frdmkw41z.bin
  ILINK.IlinkOutputFile: ble_zigbee_end_device_freertos.out
  ILINK.IlinkConfigDefines: gUseBootloaderLink_d=0; gUseNVMLink_d=1; __ram_vector_table__=1; gUseInternalStorageLink_d=0; gNVMSectorCountLink_d=32; gEraseNVMLink_d=1
  ILINK.IlinkIcfFile: MKW41Z512xxx4_connectivity.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../middleware/wireless/bluetooth_1.2.9/host/lib/lib_ble_4-2_host_cm0p.a; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/mac/lib/lib802.15.4_mac_zp_cm0.a; ../../../../../../../middleware/wireless/bluetooth_1.2.9/controller/lib/lib_ble_kw41z_controller.a; ../../../../../../../middleware/wireless/framework_5.3.8/SecLib/lib_crypto_m0.a; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/lib/lib_zps_ed_cm0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW41Z512VHT4; FSL_RTOS_FREE_RTOS; I2C_FSL; FRDM_KW41Z; FREEDOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: __IAR_SYSTEMS_ICC__
  group freertos
    ../../../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
    ../../../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
    ../../../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group freertos/portable
    ../../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM0/: port.c fsl_tickless_systick.c fsl_tickless_generic.h portasm.s portmacro.h
  group startup
    ../../../../../../../devices/MKW41Z4/iar/: startup_MKW41Z4.s
    ../../../../../../../devices/MKW41Z4/: system_MKW41Z4.c system_MKW41Z4.h
  group framework/OSAbstraction
    ../../../../../../../middleware/wireless/framework_5.3.8/OSAbstraction/Interface/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h
    ../../../../../../../middleware/wireless/framework_5.3.8/OSAbstraction/Source/: fsl_os_abstraction_free_rtos.c
  group framework/OSAbstraction/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/OSAbstraction/Interface/: fsl_os_abstraction.h fsl_os_abstraction_config.h
  group framework/GPIO/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/GPIO/: GPIO_Adapter.h
  group framework/GPIO/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/GPIO/: GPIO_Adapter.c
  group framework/Keyboard/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/Keyboard/Interface/: Keyboard.h
  group framework/Keyboard/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/Keyboard/Source/: Keyboard.c
  group framework/LED/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/LED/Interface/: LED.h
  group framework/LED/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/LED/Source/: LED.c
  group framework/Reset/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/Reset/: Reset.c
  group framework/SerialManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/SerialManager/Source/: UART_Adapter.h UART_Adapter.c I2C_Adapter.h I2C_Adapter.c SerialManager.c
  group framework/SerialManager/Source/SPI_Adapter
    ../../../../../../../middleware/wireless/framework_5.3.8/SerialManager/Source/SPI_Adapter/: SPI_Adapter.h SPI_Adapter.c
  group framework/SerialManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/SerialManager/Interface/: SerialManager.h
  group framework/Flash/Internal
    ../../../../../../../middleware/wireless/framework_5.3.8/Flash/Internal/: Flash_Adapter.h Flash_Adapter.c
  group framework/Flash/External/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/Flash/External/Interface/: Eeprom.h
  group framework/Flash/External/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/Flash/External/Source/: Eeprom_AT26DF081A.c Eeprom_AT45DB021E.c Eeprom_AT45DB041E.c Eeprom_AT45DB161E.c Eeprom_InternalFlash.c
  group framework/OtaSupport/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/OtaSupport/Interface/: OtaSupport.h
  group framework/OtaSupport/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/OtaSupport/Source/: OtaSupport.c
  group framework/Common
    ../../../../../../../middleware/wireless/framework_5.3.8/Common/: EmbeddedTypes.h
  group framework/MemManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/MemManager/Interface/: MemManager.h
  group framework/MemManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/MemManager/Source/: MemManager.c
  group framework/Messaging/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/Messaging/Source/: Messaging.c
  group framework/LowPower/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/LowPower/Interface/MKW41Z/: PWR_Configuration.h PWR_Interface.h
  group framework/LowPower/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/LowPower/Source/MKW41Z/: PWR.c PWRLib.c PWRLib.h PWR_BLE.c PWR_BLE.h
  group framework/Panic/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/Panic/Interface/: Panic.h
  group framework/Panic/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/Panic/Source/: Panic.c
  group framework/RNG/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/RNG/Source/: RNG.c
  group framework/TimersManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/TimersManager/Interface/: TimersManager.h
  group framework/TimersManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/TimersManager/Source/: TimersManager.c TimersManagerInternal.h TMR_Adapter.h TMR_Adapter.c
  group framework/ModuleInfo
    ../../../../../../../middleware/wireless/framework_5.3.8/ModuleInfo/: ModuleInfo.h ModuleInfo.c
  group framework/FunctionLib
    ../../../../../../../middleware/wireless/framework_5.3.8/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/Lists
    ../../../../../../../middleware/wireless/framework_5.3.8/Lists/: GenericList.c GenericList.h
  group framework/SecLib
    ../../../../../../../middleware/wireless/framework_5.3.8/SecLib/: SecLib.h SecLib.c
  group framework/MWSCoexistence/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/MWSCoexistence/Interface/: MWS.h
  group framework/MWSCoexistence/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/MWSCoexistence/Source/: MWS.c
  group framework/NVM/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/NVM/Interface/: NVM_Interface.h
  group framework/NVM/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/NVM/Source/: NV_Flash.c NV_Flash.h NV_FsciCommands.c NV_FsciCommands.h
  group framework/Shell/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/Shell/Interface/: shell.h shell_config.h
  group framework/Shell/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/Shell/Source/: shell.c shell_autocomplete.c shell_cmdhelp.c shell_cmdhist.c
  group framework/DCDC/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/DCDC/Interface/: DCDC.h
  group framework/DCDC/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/DCDC/Source/: DCDC.c
  group framework/XCVR/MKW41Z4
    ../../../../../../../middleware/wireless/framework_5.3.8/XCVR/MKW41Z4/: fsl_xcvr.c fsl_xcvr.h ifr_radio.c ifr_radio.h fsl_xcvr_trim.c fsl_xcvr_trim.h dbg_ram_capture.c dbg_ram_capture.h
    ../../../../../../../middleware/wireless/framework_5.3.8/XCVR/MKW41Z4/cfgs_kw4x_3x_2x/: fsl_xcvr_ble_config.c fsl_xcvr_ant_config.c fsl_xcvr_zgbe_config.c fsl_xcvr_msk_config.c fsl_xcvr_common_config.c fsl_xcvr_mode_datarate_config.c fsl_xcvr_gfsk_bt_0p3_h_0p5_config.c fsl_xcvr_gfsk_bt_0p5_h_0p5_config.c fsl_xcvr_gfsk_bt_0p5_h_0p7_config.c fsl_xcvr_gfsk_bt_0p5_h_0p32_config.c fsl_xcvr_gfsk_bt_0p5_h_1p0_config.c fsl_xcvr_gfsk_bt_0p7_h_0p5_config.c
  group source
    ../: config.h FreeRTOSConfig.h app_cfg.h app_end_device_node.h app_end_device_node.c app_main.c app_main.h app_zb_shell.h app_zb_shell.c app_start.c app_zcl_task.h app_zcl_task.c app_pdum_cfg.h zcl_options.h app_zps_cfg.h app_zcl_cfg.h app_zcl_globals.c app_config.c ApplMain.c ApplMain.h ble_init.c ble_init.h gatt_db.h gatt_uuid128.h app_mac_config.h bdb_options.h app_framework_config.h app_zb_utils.h app_zb_utils.c
  group source/common
    ../../../../../../../middleware/wireless/bluetooth_1.2.9/application/common/: ble_host_tasks.c ble_host_task_config.h ble_conn_manager.c ble_conn_manager.h ble_controller_task.c ble_controller_task_config.h ieee11073.h ble_service_discovery.c ble_service_discovery.h
    ../../common/: app_buttons.h app_leds.h app_common.h app_events.h app_ntag_i2c_plus.c app_ntag_i2c_plus.h
  group source/common/gatt_db
    ../../../../../../../middleware/wireless/bluetooth_1.2.9/application/common/gatt_db/: gatt_database.c gatt_db_handles.h
  group source/common/gatt_db/macros
    ../../../../../../../middleware/wireless/bluetooth_1.2.9/application/common/gatt_db/macros/: gatt_alloc_x.h gatt_db_macros.h gatt_db_x_macros.h gatt_decl_x.h gatt_enum_x.h gatt_init_x.h gatt_size_x.h gatt_uuid_decl_x.h gatt_uuid_def_x.h
  group board
    ../: board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h clock_config.c clock_config.h
  group ieee_802.15.4/App
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/mac/source/App/: FsciAspCommands.h FsciAspCommands.c FsciMacCommands.h FsciMacCommands.c MacGlobals.c MacGlobals.h
  group ieee_802.15.4/mac/interface
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/mac/interface/: MacFunctionalityDefines.h MacInterface.h MacMessages.h MacTypes.h
  group ieee_802.15.4/phy/Interface
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/phy/interface/: AspInterface.h MpmInterface.h PhyDebug.h PhyInterface.h PhyMessages.h PhyTypes.h
  group ieee_802.15.4/phy/source
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/phy/source/MKW41Z/: Phy.h ASP.c MPM.c PhyISR.c PhyPacketProcessor.c PhyPlmeData.c PhyStateMachine.c PhyTime.c
  group bluetooth/host/interface
    ../../../../../../../middleware/wireless/bluetooth_1.2.9/host/interface/: att_callbacks.h att_errors.h att_interface.h att_params.h att_types.h ble_constants.h ble_general.h ble_host_tasks.h ble_sig_defines.h ble_utils.h gap_interface.h gap_types.h gatt_client_interface.h gatt_database.h gatt_db_app_interface.h gatt_db_dynamic.h gatt_interface.h gatt_server_interface.h gatt_types.h hci_interface.h hci_types.h l2ca_cb_interface.h l2ca_interface.h l2ca_types.h vendor_debug_commands.h
  group bluetooth/host/config
    ../../../../../../../middleware/wireless/bluetooth_1.2.9/host/config/: ble_config.h ble_globals.c
  group bluetooth/controller/interface
    ../../../../../../../middleware/wireless/bluetooth_1.2.9/controller/interface/: controller_interface.h
  group bluetooth/hci_transport/interface
    ../../../../../../../middleware/wireless/bluetooth_1.2.9/hci_transport/interface/: hci_transport.h
  group bluetooth/hci_transport/source
    ../../../../../../../middleware/wireless/bluetooth_1.2.9/hci_transport/source/: hcit_serial_interface.c
  group bluetooth/profiles/battery
    ../../../../../../../middleware/wireless/bluetooth_1.2.9/profiles/battery/: battery_service.c battery_interface.h
  group bluetooth/profiles/device_info
    ../../../../../../../middleware/wireless/bluetooth_1.2.9/profiles/device_info/: device_info_service.c device_info_interface.h
  group bluetooth/profiles/wireless_uart
    ../../../../../../../middleware/wireless/bluetooth_1.2.9/profiles/wireless_uart/: wireless_uart_service.c wireless_uart_interface.h
  group zigbee_3_0/core/zigbee_common/include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZigbeeCommon/Include/: appZdpExtraction.h appZpsBeaconHandler.h ZQueue.h ZTimer.h
  group zigbee_3_0/core/zigbee_common/source
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZigbeeCommon/Source/: app_zps_link_keys.c appZdpExtraction.c appZpsBeaconHandler.c appZpsExtendedDebug.c pwrm_shim.c timer_server_shim.c zps_mutex_shim.c ZQueue.c ZTimer.c zps_globals.c pdum_globals.c
  group zigbee_3_0/core/ZPSAPL/include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZPSAPL/Include/: zps_apl.h zps_apl_af.h zps_apl_aib.h zps_apl_aps.h zps_apl_zdo.h zps_apl_zdp.h
  group zigbee_3_0/core/ZPSMAC/include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZPSMAC/Include/: mac_sap.h mac_vs_sap.h zps_mac.h zps_mac_if_table.h
  group zigbee_3_0/core/ZPSNWK/include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZPSNWK/Include/: zps_nwk_config.h zps_nwk_mac_sap.h zps_nwk_nib.h zps_nwk_pub.h zps_nwk_sap.h zps_nwk_sec.h zps_nwk_slist.h
  group zigbee_3_0/core/ZPSTSV/include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZPSTSV/Include/: zps_tsv.h
  group zigbee_3_0/core/PDUM/include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/PDUM/Include/: pdum_apl.h pdum_common.h pdum_nwk.h
  group zigbee_3_0/core/bdb/common
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/BDB/Include/: bdb_api.h
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/BDB/Source/Common/: bdb_fr.h bdb_fr.c bdb_start.h bdb_start.c bdb_state_machine.c
  group zigbee_3_0/core/bdb/find_and_bind
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/BDB/Source/FindAndBind/: bdb_fb_api.h bdb_fb_common.c bdb_fb_initiator.c bdb_fb_target.c
  group zigbee_3_0/core/bdb/nwk_formation
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/BDB/Source/NwkFormation/: bdb_nf.c bdb_nf.h
  group zigbee_3_0/core/bdb/nwk_steering
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/BDB/Source/NwkSteering/: bdb_ns.c bdb_ns.h
  group zigbee_3_0/core/bdb/out_of_band
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/BDB/Source/OutOfBand/: bdb_DeviceCommissioning.c bdb_DeviceCommissioning.h
  group zigbee_3_0/core/bdb/touch_link
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/BDB/Source/TouchLink/: bdb_tl.h
  group zigbee_3_0/core/zcif/include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCIF/Include/: dlist.h version.h zcl.h zcl_customcommand.h zcl_heap.h zcl_internal_library_options.h
  group zigbee_3_0/core/zcif/source
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCIF/Source/: dlist.c zcl.c zcl_CustomCommandReceive.c zcl_CustomCommandSend.c zcl_PDUbufferReadWrite.c zcl_PDUbufferReadWriteString.c zcl_WriteAttributesRequestHandle.c zcl_WriteAttributesRequestSend.c zcl_WriteAttributesResponseHandle.c zcl_attribute.c zcl_buffer.c zcl_clusterCommand.c zcl_command.c zcl_common.c zcl_common.h zcl_configureReportingCommandHandle.c zcl_configureReportingCommandSend.c zcl_configureReportingResponseHandle.c zcl_defaultResponse.c zcl_discoverAttributesExtendedRequestHandle.c zcl_discoverAttributesExtendedRequestSend.c zcl_discoverAttributesExtendedResponseHandle.c zcl_discoverAttributesRequestHandle.c zcl_discoverAttributesRequestSend.c zcl_discoverAttributesResponseHandle.c zcl_discoverCommandsRequestHandle.c zcl_discoverCommandsRequestSend.c zcl_discoverCommandsResponseHandle.c zcl_event.c zcl_heap.c zcl_internal.h zcl_library_options.c zcl_readAttributesRequestHandle.c zcl_readAttributesRequestSend.c zcl_readAttributesResponseHandle.c zcl_readReportingConfigurationCommandHandle.c zcl_readReportingConfigurationCommandSend.c zcl_readReportingConfigurationResponseHandle.c zcl_reportManager.c zcl_reportMaths.c zcl_reportScheduler.c zcl_reportStringHandling.c zcl_reportStructure.c zcl_search.c zcl_timer.c zcl_transmit.c
  group zigbee_3_0/core/zcl/clusters/ApplianceManagement/Include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/ApplianceManagement/Include/: ApplianceControl.h ApplianceEventsAndAlerts.h ApplianceIdentification.h ApplianceStatistics.h
  group zigbee_3_0/core/zcl/clusters/ApplianceManagement/Source
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/ApplianceManagement/Source/: ApplianceControl.c ApplianceControlClientCommands.c ApplianceControlCommandHandler.c ApplianceControlServerCommands.c ApplianceControl_internal.h ApplianceEventsAndAlerts.c ApplianceEventsAndAlertsClientCommands.c ApplianceEventsAndAlertsCommandHandler.c ApplianceEventsAndAlertsServerCommands.c ApplianceEventsAndAlerts_internal.h ApplianceIdentification.c ApplianceStatistics.c ApplianceStatisticsClientCommands.c ApplianceStatisticsCommandHandler.c ApplianceStatisticsServerCommands.c ApplianceStatistics_internal.h
  group zigbee_3_0/core/zcl/clusters/Closures/Include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/Closures/Include/: DoorLock.h
  group zigbee_3_0/core/zcl/clusters/Closures/Source
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/Closures/Source/: DoorLock.c DoorLock_internal.h DoorLockCommandHandler.c DoorLockCommands.c
  group zigbee_3_0/core/zcl/clusters/Commissioning/Include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/Commissioning/Include/: Commissioning.h zll_commission.h zll_utility.h
  group zigbee_3_0/core/zcl/clusters/Commissioning/Source
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/Commissioning/Source/: Commissioning.c Commissioning_internal.h CommissioningClientCommands.c CommissioningCmdHandler.c CommissioningServerCommands.c zll_commission.c zll_CommissionCmdHandler.c zll_utility.c zll_UtilityCmdHandler.c
  group zigbee_3_0/core/zcl/clusters/General/Include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/General/Include/: Alarms.h AnalogInputBasic.h AnalogOutputBasic.h Basic.h BinaryInputBasic.h BinaryOutputBasic.h DeviceTemperatureConfiguration.h Diagnostics.h Groups.h Identify.h LevelControl.h MultistateInputBasic.h MultistateOutputBasic.h OOSC.h OnOff.h PollControl.h PowerConfiguration.h PowerProfile.h Scenes.h TC.h ZclTime.h
  group zigbee_3_0/core/zcl/clusters/General/Source
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/General/Source/: Alarms.c AlarmsClientCommands.c AlarmsCommandHandler.c AlarmsServerCommands.c AlarmsTableManager.c Alarms_internal.h AnalogInputBasic.c AnalogInputBasic_internal.h AnalogOutputBasic.c AnalogOutputBasic_internal.h Basic.c BasicClientCommands.c BasicCommandHandler.c Basic_internal.h BinaryInputBasic.c BinaryInputBasic_internal.h BinaryOutputBasic.c BinaryOutputBasic_internal.h DeviceTemperatureConfiguration.c Diagnostics.c Groups.c GroupsClientCommands.c GroupsCommandHandler.c GroupsServerCommands.c GroupsTableManager.c Groups_internal.h Identify.c IdentifyClientCommands.c IdentifyCommandHandler.c IdentifyServerCommands.c Identify_internal.h LevelControl.c LevelControlClientCommands.c LevelControlCommandHandler.c LevelControl_internal.h MultistateInputBasic.c MultistateInputBasic_internal.h MultistateOutputBasic.c MultistateOutputBasic_internal.h OOSC.c OnOff.c OnOffCommandHandler.c OnOffCommands.c OnOff_internal.h PollControl.c PollControlClientCommands.c PollControlCommandHandler.c PollControlServerCommands.c PollControl_internal.h PowerConfiguration.c PowerProfile.c PowerProfileClientCommands.c PowerProfileCommandHandler.c PowerProfileServerCommands.c PowerProfile_internal.h Scenes.c ScenesClientCommands.c ScenesClusterManagement.c ScenesCommandHandler.c ScenesServerCommands.c ScenesTableManager.c Scenes_internal.h TC.c Time.c
  group zigbee_3_0/core/zcl/clusters/GreenPower/Include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/GreenPower/Include/: GreenPower.h
  group zigbee_3_0/core/zcl/clusters/GreenPower/Source
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/GreenPower/Source/: GreenPower.c GreenPower_internal.h GreenPowerCommissioningNotification.c GreenPowerCommon.c GreenPowerCustomCommandHandler.c GreenPowerCustomCommandResponses.c GreenPowerDataIndication.c GreenPowerDirectCommandHandler.c GreenPowerNotification.c GreenPowerPairing.c GreenPowerPairingConfiguration.c GreenPowerPairingSearch.c GreenPowerProxyCommissioningMode.c GreenPowerProxyGPDHandler.c GreenPowerProxyTableRequest.c GreenPowerProxyTableResponse.c GreenPowerResponse.c GreenPowerScheduler.c GreenPowerSinkTableRequest.c GreenPowerSinkTableResponse.c GreenPowerTranslationTableRequest.c GreenPowerTranslationTableResponse.c GreenPowerTranslationTableUpdate.c
  group zigbee_3_0/core/zcl/clusters/HVAC/Include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/HVAC/Include/: Thermostat.h ThermostatUIConfig.h
  group zigbee_3_0/core/zcl/clusters/HVAC/Source
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/HVAC/Source/: Thermostat.c Thermostat_internal.h ThermostatCommandHandler.c ThermostatCommands.c ThermostatUIConfig.c
  group zigbee_3_0/core/zcl/clusters/Lighting/Include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/Lighting/Include/: BallastConfiguration.h ColourControl.h
  group zigbee_3_0/core/zcl/clusters/Lighting/Source
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/Lighting/Source/: BallastConfiguration.c ColourControl.c ColourControl_internal.h ColourControlClientCommands.c ColourControlCommandHandler.c ColourControlConversions.c
  group zigbee_3_0/core/zcl/clusters/MeasurementAndSensing/Include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/MeasurementAndSensing/Include/: ConcentrationMeasurement.h ElectricalMeasurement.h FlowMeasurement.h IlluminanceLevelSensing.h IlluminanceMeasurement.h OccupancySensing.h PressureMeasurement.h RelativeHumidityMeasurement.h TemperatureMeasurement.h
  group zigbee_3_0/core/zcl/clusters/MeasurementAndSensing/Source
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/MeasurementAndSensing/Source/: ConcentrationMeasurement.c ElectricalMeasurement.c FlowMeasurement.c IlluminanceLevelSensing.c IlluminanceMeasurement.c OccupancySensing.c PressureMeasurement.c RelativeHumidityMeasurement.c TemperatureMeasurement.c
  group zigbee_3_0/core/zcl/clusters/OTA/Include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/OTA/Include/: OTA.h
  group zigbee_3_0/core/zcl/clusters/OTA/Source
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/OTA/Source/: OTA.c OTA_client.c OTA_ClientUpgradeManager.c OTA_common.c OTA_CustomCommandHandler.c OTA_CustomReceiveCommands.c OTA_server.c OTA_ServerUpgradeManager.c
  group zigbee_3_0/core/zcl/clusters/SecurityAndSafety/Include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/SecurityAndSafety/Include/: IASACE.h IASWD.h IASZone.h
  group zigbee_3_0/core/zcl/clusters/SecurityAndSafety/Source
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/SecurityAndSafety/Source/: IASACE.c IASACE_internal.h IASACEClientCommands.c IASACECommandHandler.c IASACEServerCommands.c IASWD.c IASWD_internal.h IASWDCommandHandler.c IASWDCommands.c IASZone.c IASZone_internal.h IASZoneCommandHandler.c IASZoneCommands.c
  group zigbee_3_0/core/zcl/clusters/SmartEnergy/Include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/SmartEnergy/Include/: DRLC.h Price.h SimpleMetering.h SimpleMeteringAttributeCount.h
  group zigbee_3_0/core/zcl/clusters/SmartEnergy/Source
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Clusters/SmartEnergy/Source/: DRLC.c DRLCCommandCanceAlllLoadControlEvents.c DRLCCommandCancelLoadControlEvent.c DRLCCommandGetScheduledEvents.c DRLCCommandHandler.c DRLCCommandLoadControlEvent.c DRLCCommandReportEventStatus.c DRLCCustomCommandResponsesClient.c DRLCCustomCommandResponsesServer.c DRLCEffectiveTime.c DRLCScheduler.c DRLCTableManagerNoMutex.c DRLCTableManagerServer.c DRLCUserEventOptInOut.c DRLC_internal.h Price.c PriceBlockPeriodTableManager.c PriceCalorificValueTableManager.c PriceCommandGetBlockPeriod.c PriceCommandGetCalorificValue.c PriceCommandGetConversionFactor.c PriceCommandGetCurrentPrice.c PriceCommandGetScheduledPrices.c PriceCommandPriceAck.c PriceCommandPublishBlockPeriod.c PriceCommandPublishBlockPeriodReceive.c PriceCommandPublishCalorificValue.c PriceCommandPublishCalorificValueReceive.c PriceCommandPublishConversionFactor.c PriceCommandPublishConversionFactorReceive.c PriceCommandPublishPrice.c PriceCommandPublishPriceReceive.c PriceConversionFactorTableManager.c PriceCustomCommandHandler.c PriceCustomCommandResponses.c PriceScheduler.c PriceServerAttributeManager.c PriceTableManager.c Price_internal.h SimpleMetering.c SimpleMeteringCommandHandler.c SimpleMetering_SendRequest.c SimpleMetering_internal.h
  group zigbee_3_0/core/zcl/devices/ZGP/Include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Devices/ZGP/Include/: gp.h
  group zigbee_3_0/core/zcl/devices/ZGP/Source
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Devices/ZGP/Source/: gp.c
  group zigbee_3_0/core/zcl/devices/ZHA/ApplianceManagement/Include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Devices/ZHA/ApplianceManagement/Include/: home_gateway.h white_goods.h
  group zigbee_3_0/core/zcl/devices/ZHA/ApplianceManagement/Source
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Devices/ZHA/ApplianceManagement/Source/: home_gateway.c white_goods.c
  group zigbee_3_0/core/zcl/devices/ZHA/Closures/Include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Devices/ZHA/Closures/Include/: door_lock.h door_lock_controller.h
  group zigbee_3_0/core/zcl/devices/ZHA/Closures/Source
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Devices/ZHA/Closures/Source/: door_lock.c door_lock_controller.c
  group zigbee_3_0/core/zcl/devices/ZHA/Generic/Include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Devices/ZHA/Generic/Include/: base_device.h mains_power_outlet.h on_off_output.h remote_control.h simple_sensor.h
  group zigbee_3_0/core/zcl/devices/ZHA/Generic/Source
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Devices/ZHA/Generic/Source/: base_device.c mains_power_outlet.c on_off_output.c remote_control.c simple_sensor.c
  group zigbee_3_0/core/zcl/devices/ZHA/HVAC/Include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Devices/ZHA/HVAC/Include/: temperature_sensor.h thermostat_device.h
  group zigbee_3_0/core/zcl/devices/ZHA/HVAC/Source
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Devices/ZHA/HVAC/Source/: temperature_sensor.c thermostat_device.c
  group zigbee_3_0/core/zcl/devices/ZHA/SecurityAndSafety/Include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Devices/ZHA/SecurityAndSafety/Include/: ancillary_control_equipment.h control_and_indicating_equipment.h warning_device.h zone.h
  group zigbee_3_0/core/zcl/devices/ZHA/SecurityAndSafety/Source
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Devices/ZHA/SecurityAndSafety/Source/: ancillary_control_equipment.c control_and_indicating_equipment.c warning_device.c zone.c
  group zigbee_3_0/core/zcl/devices/ZHA/SmartEnergy/Include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Devices/ZHA/SmartEnergy/Include/: smart_plug.h
  group zigbee_3_0/core/zcl/devices/ZHA/SmartEnergy/Source
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Devices/ZHA/SmartEnergy/Source/: smart_plug.c
  group zigbee_3_0/core/zcl/devices/ZLO/Include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Devices/ZLO/Include/: colour_controller.h colour_dimmable_light.h colour_dimmer_switch.h colour_scene_controller.h colour_temperature_light.h commission_endpoint.h control_bridge.h dimmable_ballast.h dimmable_light.h dimmable_plug.h dimmer_switch.h extended_colour_light.h light_level_sensor.h light_sensor.h non_colour_controller.h non_colour_scene_controller.h occupancy_sensor.h on_off_ballast.h on_off_light.h on_off_light_switch.h on_off_plug.h on_off_sensor.h zlo_device_id.h
  group zigbee_3_0/core/zcl/devices/ZLO/Source
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/core/ZCL/Devices/ZLO/Source/: colour_controller.c colour_dimmable_light.c colour_dimmer_switch.c colour_scene_controller.c colour_temperature_light.c commission_endpoint.c control_bridge.c dimmable_ballast.c dimmable_light.c dimmable_plug.c dimmer_switch.c extended_colour_light.c light_level_sensor.c light_sensor.c non_colour_controller.c non_colour_scene_controller.c occupancy_sensor.c on_off_ballast.c on_off_light.c on_off_light_switch.c on_off_plug.c on_off_sensor.c
  group zigbee_3_0/base/include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/base/JennicCommon/Include/: jendefs.h
  group zigbee_3_0/base/pdm/include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/base/PDM/Include/: PDM.h PDM_IDs.h
  group zigbee_3_0/base/pdm/source
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/base/PDM/Source/: pdm.c
  group zigbee_3_0/base/PWRM/include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/base/PWRM/Include/: pwrm.h
  group zigbee_3_0/base/TSV/include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.9/base/TimerServer/Include/: tsv_pub.h
  group doc
    ../../: readme.txt
  group ntag_i2c_plus/HAL_NTAG
    ../../common/ntag_i2c_plus/HAL_NTAG/inc/: ntag_bridge.h ntag_defines.h ntag_device_list.h ntag_driver.h
    ../../common/ntag_i2c_plus/HAL_NTAG/: ntag_driver_intern.h ntag_bridge.c ntag_driver.c
  group ntag_i2c_plus/HAL_I2C
    ../../common/ntag_i2c_plus/HAL_I2C/inc/: HAL_I2C_driver.h HAL_I2C_kinetis_fsl.h
    ../../common/ntag_i2c_plus/HAL_I2C/: i2c_kinetis_fsl.c
  group ntag_i2c_plus/HAL_ISR
    ../../common/ntag_i2c_plus/HAL_ISR/: HAL_ISR_callback_list.h HAL_ISR_driver.h
  group ntag_i2c_plus/ntag_i2c_plus_include
    ../../common/ntag_i2c_plus/inc/: nfc_device.h ndef_message.h
  group drivers
    ../../../../../../../devices/MKW41Z4/drivers/: fsl_common.h fsl_common.c fsl_trng.c fsl_trng.h fsl_flash.c fsl_flash.h fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_tpm.c fsl_tpm.h fsl_dspi.h fsl_dspi.c fsl_i2c.h fsl_i2c.c fsl_lptmr.c fsl_lptmr.h fsl_rtc.c fsl_rtc.h fsl_llwu.h fsl_llwu.c fsl_ltc.h fsl_ltc.c fsl_pmc.h fsl_pmc.c fsl_adc16.c fsl_adc16.h fsl_tsi_v4.h fsl_tsi_v4.c fsl_cop.c fsl_cop.h fsl_rcm.c fsl_rcm.h fsl_smc.h fsl_smc.c fsl_clock.h fsl_clock.c
  group utilities
    ../../../../../../../devices/MKW41Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
