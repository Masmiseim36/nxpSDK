# IAR project otap_server_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW41Z512xxx4 NXP MKW41Z512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKW41Z512VHT4; FSL_RTOS_FREE_RTOS; FRDM_KW41Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.PreInclude: ../../../../../../../boards/frdmkw41z/wireless_examples/ieee_802_15_4/otap_server/freertos/app_preinclude.h
  ICCARM.CCIncludePath2: ../../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM0; ../../../../../../../rtos/freertos_9.0.0/Source/include; ..; ../../../../../../../rtos/freertos_9.0.0/Source; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../middleware/wireless/framework_5.3.8/OSAbstraction/Interface; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/mac/source/App; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/mac/interface; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/phy/interface; ../../../../../../../middleware/wireless/framework_5.3.8/GPIO; ../../../../../../../middleware/wireless/framework_5.3.8/Keyboard/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/LED/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/SerialManager/Source/SPI_Adapter; ../../../../../../../middleware/wireless/framework_5.3.8/SerialManager/Source; ../../../../../../../middleware/wireless/framework_5.3.8/Flash/External/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/Flash/Internal; ../../../../../../../middleware/wireless/framework_5.3.8/Common; ../../../../../../../middleware/wireless/framework_5.3.8/FSCI/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/FSCI/Source; ../../../../../../../middleware/wireless/framework_5.3.8/OtaSupport/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/MemManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/Messaging/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/Panic/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/RNG/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/SerialManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/TimersManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/TimersManager/Source; ../../../../../../../middleware/wireless/framework_5.3.8/ModuleInfo; ../../../../../../../middleware/wireless/framework_5.3.8/FunctionLib; ../../../../../../../middleware/wireless/framework_5.3.8/Lists; ../../../../../../../middleware/wireless/framework_5.3.8/SecLib; ../../../../../../../middleware/wireless/framework_5.3.8/MWSCoexistence/Interface; ../..; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/examples/common; ../../../../../../../devices/MKW41Z4/drivers; ../../../../../../../middleware/wireless/framework_5.3.8/DCDC/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/XCVR/MKW41Z4; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/phy/source/MKW41Z; ../../../../../../../devices/MKW41Z4; ../../../../../../../devices/MKW41Z4/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: otap_server_frdmkw41z.bin
  ILINK.IlinkOutputFile: otap_server_freertos.out
  ILINK.IlinkConfigDefines: gUseInternalStorageLink_d=0
  ILINK.IlinkIcfFile: MKW41Z512xxx4_connectivity.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/mac/lib/lib802.15.4_mac_06_cm0.a; ../../../../../../../middleware/wireless/framework_5.3.8/SecLib/lib_crypto_m0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW41Z512VHT4; FSL_RTOS_FREE_RTOS; FRDM_KW41Z; FREEDOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group freertos
    ../../../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
    ../../../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
    ../../../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group freertos/portable
    ../../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM0/: port.c fsl_tickless_systick.c fsl_tickless_generic.h portasm.s portmacro.h
  group startup
    ../../../../../../../devices/MKW41Z4/iar/: startup_MKW41Z4.s
    ../../../../../../../devices/MKW41Z4/: system_MKW41Z4.c system_MKW41Z4.h
  group framework/OSAbstraction
    ../../../../../../../middleware/wireless/framework_5.3.8/OSAbstraction/Interface/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h
    ../../../../../../../middleware/wireless/framework_5.3.8/OSAbstraction/Source/: fsl_os_abstraction_free_rtos.c
  group framework/GPIO/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/GPIO/: GPIO_Adapter.h
  group framework/GPIO/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/GPIO/: GPIO_Adapter.c
  group framework/Keyboard/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/Keyboard/Interface/: Keyboard.h
  group framework/Keyboard/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/Keyboard/Source/: Keyboard.c
  group framework/LED/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/LED/Interface/: LED.h
  group framework/LED/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/LED/Source/: LED.c
  group framework/Reset/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/Reset/: Reset.c
  group framework/SerialManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/SerialManager/Source/: UART_Adapter.h UART_Adapter.c I2C_Adapter.h I2C_Adapter.c SerialManager.c
  group framework/SerialManager/Source/SPI_Adapter
    ../../../../../../../middleware/wireless/framework_5.3.8/SerialManager/Source/SPI_Adapter/: SPI_Adapter.h SPI_Adapter.c
  group framework/SerialManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/SerialManager/Interface/: SerialManager.h
  group framework/Flash/External/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/Flash/External/Interface/: Eeprom.h
  group framework/Flash/External/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/Flash/External/Source/: Eeprom_AT26DF081A.c Eeprom_AT45DB021E.c Eeprom_AT45DB041E.c Eeprom_AT45DB161E.c Eeprom_InternalFlash.c
  group framework/Flash/Internal
    ../../../../../../../middleware/wireless/framework_5.3.8/Flash/Internal/: Flash_Adapter.h Flash_Adapter.c
  group framework/Common
    ../../../../../../../middleware/wireless/framework_5.3.8/Common/: EmbeddedTypes.h
  group framework/FSCI/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/FSCI/Interface/: FsciInterface.h
  group framework/FSCI/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/FSCI/Source/: FsciCommands.c FsciCommands.h FsciCommunication.c FsciCommunication.h FsciLogging.c FsciMain.c
  group framework/OtaSupport/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/OtaSupport/Interface/: OtaSupport.h
  group framework/OtaSupport/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/OtaSupport/Source/: OtaSupport.c
  group framework/MemManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/MemManager/Interface/: MemManager.h
  group framework/MemManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/MemManager/Source/: MemManager.c
  group framework/Messaging/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/Messaging/Source/: Messaging.c
  group framework/Panic/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/Panic/Interface/: Panic.h
  group framework/Panic/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/Panic/Source/: Panic.c
  group framework/RNG/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/RNG/Source/: RNG.c
  group framework/TimersManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/TimersManager/Interface/: TimersManager.h
  group framework/TimersManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/TimersManager/Source/: TimersManager.c TimersManagerInternal.h TMR_Adapter.h TMR_Adapter.c
  group framework/ModuleInfo
    ../../../../../../../middleware/wireless/framework_5.3.8/ModuleInfo/: ModuleInfo.h ModuleInfo.c
  group framework/FunctionLib
    ../../../../../../../middleware/wireless/framework_5.3.8/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/Lists
    ../../../../../../../middleware/wireless/framework_5.3.8/Lists/: GenericList.c GenericList.h
  group framework/SecLib
    ../../../../../../../middleware/wireless/framework_5.3.8/SecLib/: SecLib.h SecLib.c
  group framework/MWSCoexistence/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/MWSCoexistence/Interface/: MWS.h
  group framework/MWSCoexistence/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/MWSCoexistence/Source/: MWS.c
  group framework/DCDC/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/DCDC/Interface/: DCDC.h
  group framework/DCDC/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/DCDC/Source/: DCDC.c
  group framework/XCVR/MKW41Z4
    ../../../../../../../middleware/wireless/framework_5.3.8/XCVR/MKW41Z4/: fsl_xcvr.c fsl_xcvr.h ifr_radio.c ifr_radio.h fsl_xcvr_trim.c fsl_xcvr_trim.h dbg_ram_capture.c dbg_ram_capture.h
    ../../../../../../../middleware/wireless/framework_5.3.8/XCVR/MKW41Z4/cfgs_kw4x_3x_2x/: fsl_xcvr_ble_config.c fsl_xcvr_ant_config.c fsl_xcvr_zgbe_config.c fsl_xcvr_msk_config.c fsl_xcvr_common_config.c fsl_xcvr_mode_datarate_config.c fsl_xcvr_gfsk_bt_0p3_h_0p5_config.c fsl_xcvr_gfsk_bt_0p5_h_0p5_config.c fsl_xcvr_gfsk_bt_0p5_h_0p7_config.c fsl_xcvr_gfsk_bt_0p5_h_0p32_config.c fsl_xcvr_gfsk_bt_0p5_h_1p0_config.c fsl_xcvr_gfsk_bt_0p7_h_0p5_config.c
  group source
    ../: app_preinclude.h FreeRTOSConfig.h
    ../../: otap_server.c otap_server.h OtaMessages.h
  group board
    ../: board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h clock_config.c clock_config.h
  group ieee_802.15.4/App
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/mac/source/App/: FsciAspCommands.h FsciAspCommands.c FsciMacCommands.h FsciMacCommands.c MacGlobals.c MacGlobals.h
  group ieee_802.15.4/mac/interface
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/mac/interface/: MacFunctionalityDefines.h MacInterface.h MacMessages.h MacTypes.h
  group ieee_802.15.4/phy/Interface
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/phy/interface/: AspInterface.h MpmInterface.h PhyDebug.h PhyInterface.h PhyMessages.h PhyTypes.h
  group ieee_802.15.4/phy/source
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.8/phy/source/MKW41Z/: Phy.h ASP.c MPM.c PhyISR.c PhyPacketProcessor.c PhyPlmeData.c PhyStateMachine.c PhyTime.c
  group doc
    ../../: readme.txt
  group drivers
    ../../../../../../../devices/MKW41Z4/drivers/: fsl_common.h fsl_common.c fsl_trng.c fsl_trng.h fsl_flash.c fsl_flash.h fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_tpm.c fsl_tpm.h fsl_dspi.h fsl_dspi.c fsl_i2c.h fsl_i2c.c fsl_lptmr.c fsl_lptmr.h fsl_rtc.c fsl_rtc.h fsl_llwu.h fsl_llwu.c fsl_ltc.h fsl_ltc.c fsl_pmc.h fsl_pmc.c fsl_adc16.c fsl_adc16.h fsl_tsi_v4.h fsl_tsi_v4.c fsl_smc.h fsl_smc.c fsl_clock.h fsl_clock.c
  group utilities
    ../../../../../../../devices/MKW41Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
