# IAR project eh_switch_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW41Z512xxx4 NXP MKW41Z512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKW41Z512VHT4; FSL_RTOS_FREE_RTOS; FRDM_KW41Z; FREEDOM
  ICCARM.CCDiagSuppress: Pe188,Pa082,Pa050,Pe167
  ICCARM.PreInclude: ../../../../../../../boards/frdmkw41z/wireless_examples/zigbee_3_0/eh_switch/freertos/config.h
  ICCARM.CCIncludePath2: ../../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM0; ../../../../../../../rtos/freertos_9.0.0/Source/include; ../../../../../../../rtos/freertos_9.0.0/Source; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../middleware/wireless/framework_5.3.5/OSAbstraction/Interface; ..; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.5/mac/source/App; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.5/mac/interface; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.5/phy/interface; ../../../../../../../middleware/wireless/framework_5.3.5/GPIO; ../../../../../../../middleware/wireless/framework_5.3.5/Keyboard/Interface; ../../../../../../../middleware/wireless/framework_5.3.5/LED/Interface; ../../../../../../../middleware/wireless/framework_5.3.5/SerialManager/Source/SPI_Adapter; ../../../../../../../middleware/wireless/framework_5.3.5/SerialManager/Source; ../../../../../../../middleware/wireless/framework_5.3.5/Flash/Internal; ../../../../../../../middleware/wireless/framework_5.3.5/Flash/External/Interface; ../../../../../../../middleware/wireless/framework_5.3.5/OtaSupport/Interface; ../../../../../../../middleware/wireless/framework_5.3.5/Common; ../../../../../../../middleware/wireless/framework_5.3.5/MemManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.5/Messaging/Interface; ../../../../../../../middleware/wireless/framework_5.3.5/Panic/Interface; ../../../../../../../middleware/wireless/framework_5.3.5/RNG/Interface; ../../../../../../../middleware/wireless/framework_5.3.5/SerialManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.5/TimersManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.5/TimersManager/Source; ../../../../../../../middleware/wireless/framework_5.3.5/ModuleInfo; ../../../../../../../middleware/wireless/framework_5.3.5/FunctionLib; ../../../../../../../middleware/wireless/framework_5.3.5/Lists; ../../../../../../../middleware/wireless/framework_5.3.5/SecLib; ../../../../../../../middleware/wireless/framework_5.3.5/MWSCoexistence/Interface; ../../../../../../../middleware/wireless/framework_5.3.5/NVM/Interface; ../../../../../../../middleware/wireless/framework_5.3.5/NVM/Source; ../../../../../../../middleware/wireless/framework_5.3.5/LowPower/Interface/MKW41Z; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.6/core/ZigbeeCommon/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.6/core/ZPSAPL/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.6/core/ZPSMAC/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.6/core/ZPSNWK/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.6/core/ZPSTSV/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.6/core/PDUM/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.6/base/JennicCommon/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.6/base/PDM/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.6/base/PWRM/Include; ../../../../../../../middleware/wireless/zigbee_3_0_6.0.6/base/TimerServer/Include; ../../../../../../../devices/MKW41Z4/drivers; ../../../../../../../middleware/wireless/framework_5.3.5/DCDC/Interface; ../../../../../../../middleware/wireless/framework_5.3.5/XCVR/MKW41Z4; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.5/phy/source/MKW41Z; ../../../../../../../devices/MKW41Z4; ../../../../../../../devices/MKW41Z4/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __IAR_SYSTEMS_ICC__
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: eh_switch_frdmkw41z.bin
  ILINK.IlinkOutputFile: eh_switch_freertos.out
  ILINK.IlinkConfigDefines: gUseBootloaderLink_d=0; gUseNVMLink_d=1; __ram_vector_table__=1; gUseInternalStorageLink_d=0; gNVMSectorCountLink_d=32; gEraseNVMLink_d=1
  ILINK.IlinkIcfFile: MKW41Z512xxx4_connectivity.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../middleware/wireless/framework_5.3.5/SecLib/lib_crypto_m0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW41Z512VHT4; FSL_RTOS_FREE_RTOS; FRDM_KW41Z; FREEDOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: __IAR_SYSTEMS_ICC__
  group freertos
    ../../../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
    ../../../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
    ../../../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group freertos/portable
    ../../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM0/: port.c fsl_tickless_systick.c fsl_tickless_generic.h portasm.s portmacro.h
  group startup
    ../../../../../../../devices/MKW41Z4/iar/: startup_MKW41Z4.s
    ../../../../../../../devices/MKW41Z4/: system_MKW41Z4.c system_MKW41Z4.h
  group framework/OSAbstraction
    ../../../../../../../middleware/wireless/framework_5.3.5/OSAbstraction/Interface/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h
    ../../../../../../../middleware/wireless/framework_5.3.5/OSAbstraction/Source/: fsl_os_abstraction_free_rtos.c
  group framework/GPIO/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/GPIO/: GPIO_Adapter.h
  group framework/GPIO/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/GPIO/: GPIO_Adapter.c
  group framework/Keyboard/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/Keyboard/Interface/: Keyboard.h
  group framework/Keyboard/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/Keyboard/Source/: Keyboard.c
  group framework/LED/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/LED/Interface/: LED.h
  group framework/LED/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/LED/Source/: LED.c
  group framework/Reset/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/Reset/: Reset.c
  group framework/SerialManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/SerialManager/Source/: UART_Adapter.h UART_Adapter.c I2C_Adapter.h I2C_Adapter.c SerialManager.c
  group framework/SerialManager/Source/SPI_Adapter
    ../../../../../../../middleware/wireless/framework_5.3.5/SerialManager/Source/SPI_Adapter/: SPI_Adapter.h SPI_Adapter.c
  group framework/SerialManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/SerialManager/Interface/: SerialManager.h
  group framework/Flash/Internal
    ../../../../../../../middleware/wireless/framework_5.3.5/Flash/Internal/: Flash_Adapter.h Flash_Adapter.c
  group framework/Flash/External/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/Flash/External/Interface/: Eeprom.h
  group framework/Flash/External/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/Flash/External/Source/: Eeprom_AT26DF081A.c Eeprom_AT45DB021E.c Eeprom_AT45DB041E.c Eeprom_AT45DB161E.c Eeprom_InternalFlash.c
  group framework/OtaSupport/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/OtaSupport/Interface/: OtaSupport.h
  group framework/OtaSupport/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/OtaSupport/Source/: OtaSupport.c
  group framework/Common
    ../../../../../../../middleware/wireless/framework_5.3.5/Common/: EmbeddedTypes.h
  group framework/MemManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/MemManager/Interface/: MemManager.h
  group framework/MemManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/MemManager/Source/: MemManager.c
  group framework/Messaging/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/Messaging/Source/: Messaging.c
  group framework/Panic/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/Panic/Interface/: Panic.h
  group framework/Panic/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/Panic/Source/: Panic.c
  group framework/RNG/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/RNG/Source/: RNG.c
  group framework/TimersManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/TimersManager/Interface/: TimersManager.h
  group framework/TimersManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/TimersManager/Source/: TimersManager.c TimersManagerInternal.h TMR_Adapter.h TMR_Adapter.c
  group framework/ModuleInfo
    ../../../../../../../middleware/wireless/framework_5.3.5/ModuleInfo/: ModuleInfo.h ModuleInfo.c
  group framework/FunctionLib
    ../../../../../../../middleware/wireless/framework_5.3.5/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/Lists
    ../../../../../../../middleware/wireless/framework_5.3.5/Lists/: GenericList.c GenericList.h
  group framework/SecLib
    ../../../../../../../middleware/wireless/framework_5.3.5/SecLib/: SecLib.h SecLib.c
  group framework/MWSCoexistence/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/MWSCoexistence/Interface/: MWS.h
  group framework/MWSCoexistence/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/MWSCoexistence/Source/: MWS.c
  group framework/NVM/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/NVM/Interface/: NVM_Interface.h
  group framework/NVM/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/NVM/Source/: NV_Flash.c NV_Flash.h NV_FsciCommands.c NV_FsciCommands.h
  group framework/LowPower/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/LowPower/Interface/MKW41Z/: PWR_Configuration.h PWR_Interface.h
  group framework/LowPower/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/LowPower/Source/MKW41Z/: PWR.c PWRLib.c PWRLib.h
  group framework/DCDC/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/DCDC/Interface/: DCDC.h
  group framework/DCDC/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/DCDC/Source/: DCDC.c
  group framework/XCVR/MKW41Z4
    ../../../../../../../middleware/wireless/framework_5.3.5/XCVR/MKW41Z4/: fsl_xcvr.c fsl_xcvr.h ifr_radio.c ifr_radio.h fsl_xcvr_trim.c fsl_xcvr_trim.h dbg_ram_capture.c dbg_ram_capture.h
    ../../../../../../../middleware/wireless/framework_5.3.5/XCVR/MKW41Z4/cfgs_kw4x_3x_2x/: fsl_xcvr_ble_config.c fsl_xcvr_ant_config.c fsl_xcvr_zgbe_config.c fsl_xcvr_msk_config.c fsl_xcvr_common_config.c fsl_xcvr_mode_datarate_config.c fsl_xcvr_gfsk_bt_0p3_h_0p5_config.c fsl_xcvr_gfsk_bt_0p5_h_0p5_config.c fsl_xcvr_gfsk_bt_0p5_h_0p7_config.c fsl_xcvr_gfsk_bt_0p5_h_0p32_config.c fsl_xcvr_gfsk_bt_0p5_h_1p0_config.c fsl_xcvr_gfsk_bt_0p7_h_0p5_config.c
  group source
    ../: config.h FreeRTOSConfig.h app_cfg.h app_buttons.h app_events.h app_common.h app_main.c app_main.h EH_Button.c EH_Button.h EH_IEEE_802154_Switch.c EH_IEEE_802154_Switch.h EH_IEEE_Commands.c EH_IEEE_Commands.h EH_IEEE_Features.c EH_IEEE_Features.h EH_Switch_Configurations.h MMAC.h app_mac_config.h bdb_options.h app_framework_config.h app_zb_utils.h app_zb_utils.c
  group board
    ../: board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h clock_config.c clock_config.h
  group ieee_802.15.4/App
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.5/mac/source/App/: FsciAspCommands.h FsciAspCommands.c FsciMacCommands.h FsciMacCommands.c MacGlobals.c MacGlobals.h
  group ieee_802.15.4/mac/interface
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.5/mac/interface/: MacFunctionalityDefines.h MacInterface.h MacMessages.h MacTypes.h
  group ieee_802.15.4/phy/Interface
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.5/phy/interface/: AspInterface.h MpmInterface.h PhyDebug.h PhyInterface.h PhyMessages.h PhyTypes.h
  group ieee_802.15.4/phy/source
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.5/phy/source/MKW41Z/: Phy.h ASP.c MPM.c PhyISR.c PhyPacketProcessor.c PhyPlmeData.c PhyStateMachine.c PhyTime.c
  group zigbee_3.0/core/zigbee_common/include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.6/core/ZigbeeCommon/Include/: appZdpExtraction.h appZpsBeaconHandler.h ZQueue.h ZTimer.h
  group zigbee_3.0/core/zigbee_common/source
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.6/core/ZigbeeCommon/Source/: app_zps_link_keys.c appZdpExtraction.c appZpsBeaconHandler.c appZpsExtendedDebug.c pwrm_shim.c timer_server_shim.c zps_mutex_shim.c ZQueue.c ZTimer.c
  group zigbee_3.0/core/ZPSAPL/include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.6/core/ZPSAPL/Include/: zps_apl.h zps_apl_af.h zps_apl_aib.h zps_apl_aps.h zps_apl_zdo.h zps_apl_zdp.h
  group zigbee_3.0/core/ZPSMAC/include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.6/core/ZPSMAC/Include/: mac_sap.h mac_vs_sap.h zps_mac.h
  group zigbee_3.0/core/ZPSNWK/include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.6/core/ZPSNWK/Include/: zps_nwk_config.h zps_nwk_mac_sap.h zps_nwk_nib.h zps_nwk_pub.h zps_nwk_sap.h zps_nwk_sec.h zps_nwk_slist.h
  group zigbee_3.0/core/ZPSTSV/include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.6/core/ZPSTSV/Include/: zps_tsv.h
  group zigbee_3.0/core/PDUM/include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.6/core/PDUM/Include/: pdum_apl.h pdum_common.h pdum_nwk.h
  group zigbee_3.0/base/include
    ../../../../../../../middleware/wireless/zigbee_3_0_6.0.6/base/JennicCommon/Include/: jendefs.h
  group doc
    ../../: readme.txt
  group drivers
    ../../../../../../../devices/MKW41Z4/drivers/: fsl_common.h fsl_common.c fsl_trng.c fsl_trng.h fsl_flash.c fsl_flash.h fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_tpm.c fsl_tpm.h fsl_dspi.h fsl_dspi.c fsl_i2c.h fsl_i2c.c fsl_lptmr.c fsl_lptmr.h fsl_rtc.c fsl_rtc.h fsl_llwu.h fsl_llwu.c fsl_ltc.h fsl_ltc.c fsl_pmc.h fsl_pmc.c fsl_adc16.c fsl_adc16.h fsl_tsi_v4.h fsl_tsi_v4.c fsl_cop.c fsl_cop.h fsl_rcm.c fsl_rcm.h fsl_smc.h fsl_smc.c fsl_clock.h fsl_clock.c
  group utilities
    ../../../../../../../devices/MKW41Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
