# IAR project mc_pmsm_safe.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV11Z128xxx7 NXP MKV11Z128xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; MISRAC_DISABLE=_Pragma ("diag_suppress=Pm001,Pm002,Pm003,Pm004,Pm005,Pm006,Pm007,Pm008,Pm009,Pm010,Pm011,Pm012,Pm013,Pm014,Pm015,Pm016,Pm017,Pm018,Pm019,Pm020,Pm021,Pm022,Pm023,Pm024,Pm025,Pm026,Pm027,Pm028,Pm029,Pm030,Pm031,Pm032,Pm033,Pm034,Pm035,Pm036,Pm037,Pm038,Pm039,Pm040,Pm041,Pm042,Pm043,Pm044,Pm045,Pm046,Pm047,Pm048,Pm049,Pm050,Pm051,Pm052,Pm053,Pm054,Pm055,Pm056,Pm057,Pm058,Pm059,Pm060,Pm061,Pm062,Pm063,Pm064,Pm065,Pm066,Pm067,Pm068,Pm069,Pm070,Pm071,Pm072,Pm073,Pm074,Pm075,Pm076,Pm077,Pm078,Pm079,Pm080,Pm081,Pm082,Pm083,Pm084,Pm085,Pm086,Pm087,Pm088,Pm089,Pm090,Pm091,Pm092,Pm093,Pm094,Pm095,Pm096,Pm097,Pm098,Pm099,Pm100,Pm101,Pm102,Pm103,Pm104,Pm105,Pm106,Pm107,Pm108,Pm109,Pm110,Pm111,Pm112,Pm113,Pm114,Pm115,Pm116,Pm117,Pm118,Pm119,Pm120,Pm121,Pm122,Pm123,Pm124,Pm125,Pm126,Pm127,Pm128,Pm129,Pm130,Pm131,Pm132,Pm133,Pm134,Pm135,Pm136,Pm137,Pm138,Pm139,Pm140,Pm141,Pm142,Pm143,Pm144,Pm145,Pm146,Pm147,Pm148,Pm149,Pm150,Pm151,Pm152,Pm153,Pm154,Pm155"); MISRAC_ENABLE=_Pragma ("diag_default=Pm001,Pm002,Pm003,Pm004,Pm005,Pm006,Pm007,Pm008,Pm009,Pm010,Pm011,Pm012,Pm013,Pm014,Pm015,Pm016,Pm017,Pm018,Pm019,Pm020,Pm021,Pm022,Pm023,Pm024,Pm025,Pm026,Pm027,Pm028,Pm029,Pm030,Pm031,Pm032,Pm033,Pm034,Pm035,Pm036,Pm037,Pm038,Pm039,Pm040,Pm041,Pm042,Pm043,Pm044,Pm045,Pm046,Pm047,Pm048,Pm049,Pm050,Pm051,Pm052,Pm053,Pm054,Pm055,Pm056,Pm057,Pm058,Pm059,Pm060,Pm061,Pm062,Pm063,Pm064,Pm065,Pm066,Pm067,Pm068,Pm069,Pm070,Pm071,Pm072,Pm073,Pm074,Pm075,Pm076,Pm077,Pm078,Pm079,Pm080,Pm081,Pm082,Pm083,Pm084,Pm085,Pm086,Pm087,Pm088,Pm089,Pm090,Pm091,Pm092,Pm093,Pm094,Pm095,Pm096,Pm097,Pm098,Pm099,Pm100,Pm101,Pm102,Pm103,Pm104,Pm105,Pm106,Pm107,Pm108,Pm109,Pm110,Pm111,Pm112,Pm113,Pm114,Pm115,Pm116,Pm117,Pm118,Pm119,Pm120,Pm121,Pm122,Pm123,Pm124,Pm125,Pm126,Pm127,Pm128,Pm129,Pm130,Pm131,Pm132,Pm133,Pm134,Pm135,Pm136,Pm137,Pm138,Pm139,Pm140,Pm141,Pm142,Pm143,Pm144,Pm145,Pm146,Pm147,Pm148,Pm149,Pm150,Pm151,Pm152,Pm153,Pm154,Pm155"); CPU_MKV11Z128VLF7; RTCESL_MMDVSQ_ON
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: startup; ..; ../../../../../../middleware/motor_control/pmsm/pmsm_safe/mc_drivers; ../../../../../../devices/MKV11Z7; ../../../../../../middleware/motor_control/pmsm/pmsm_safe/mc_state_machine; ../../../../../../middleware/motor_control/pmsm/pmsm_safe; ../periph_init; ../../../../../../devices/MKV11Z7/drivers; ../../../../../../middleware/rtcesl/CM0_RTCESL_4.6_IAR/AMCLIB/Include; ../../../../../../middleware/rtcesl/CM0_RTCESL_4.6_IAR/GDFLIB/Include; ../../../../../../middleware/rtcesl/CM0_RTCESL_4.6_IAR/GFLIB/Include; ../../../../../../middleware/rtcesl/CM0_RTCESL_4.6_IAR/GMCLIB/Include; ../../../../../../middleware/rtcesl/CM0_RTCESL_4.6_IAR/MLIB/Include; ../../../../../../middleware/safety_iec60730b/safety/v4_1; ../../../../../../middleware/safety_iec60730b/safety/v4_1/core_test; ../../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0; ../../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/aio; ../../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/clock; ../../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/dio; ../../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/tsi; ../../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/wdog; ../../../../../../middleware/safety_iec60730b/safety/v4_1/compiler; ../../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/flash; ../../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/programCounter; ../../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/ram; ../../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/register; ../../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/stack; ../../../../../../middleware/motor_control/pmsm/pmsm_safe/safety_routines; ../../../../../../middleware/freemaster/src/common; ../../../../../../middleware/freemaster/src/platforms/gen32le; ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can; ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial; ../../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../../../devices/MKV11Z7; ../../../../../../middleware/safety_iec60730b/safety/v4_1; ../../../../../../middleware/safety_iec60730b/safety/v4_1/core_test; ../../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0; ../../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/aio; ../../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/clock; ../../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/dio; ../../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/tsi; ../../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/wdog; ../../../../../../middleware/safety_iec60730b/safety/v4_1/compiler; ../../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/flash; ../../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/programCounter; ../../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/ram; ../../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/register; ../../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/stack
  postbuild: ielftool --fill 0xFF;0-c_ui32fsSafetyFlashEnd+3 --checksum __checksum:2,crc16,0x0;0-c_ui32fsSafetyFlashEnd+3  --verbose "$TARGET_PATH$" "$TARGET_PATH$"
  ILINK.IlinkOutputFile: mc_pmsm_safe.out
  ILINK.IlinkIcfFile: linker/safety_hvpkv11z75m.icf
  ILINK.IlinkExtraOptions: --place_holder __checksum,4,.checksum,4; --keep=__checksum
  ILINK.IlinkAdditionalLibs: ../../../../../../middleware/rtcesl/CM0_RTCESL_4.6_IAR/AMCLIB/AMCLIB.a; ../../../../../../middleware/rtcesl/CM0_RTCESL_4.6_IAR/GFLIB/GFLIB.a; ../../../../../../middleware/rtcesl/CM0_RTCESL_4.6_IAR/GDFLIB/GDFLIB.a; ../../../../../../middleware/rtcesl/CM0_RTCESL_4.6_IAR/GMCLIB/GMCLIB.a; ../../../../../../middleware/rtcesl/CM0_RTCESL_4.6_IAR/MLIB/MLIB.a; ../../../../../../middleware/safety_iec60730b/safety/v4_1/IEC60730B_M0_IAR_v4_1.a; ../../../../../../middleware/safety_iec60730b/safety/v4_1/IEC60730B_M0_COM_IAR_v4_1.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; MISRAC_DISABLE=_Pragma ("diag_suppress=Pm001,Pm002,Pm003,Pm004,Pm005,Pm006,Pm007,Pm008,Pm009,Pm010,Pm011,Pm012,Pm013,Pm014,Pm015,Pm016,Pm017,Pm018,Pm019,Pm020,Pm021,Pm022,Pm023,Pm024,Pm025,Pm026,Pm027,Pm028,Pm029,Pm030,Pm031,Pm032,Pm033,Pm034,Pm035,Pm036,Pm037,Pm038,Pm039,Pm040,Pm041,Pm042,Pm043,Pm044,Pm045,Pm046,Pm047,Pm048,Pm049,Pm050,Pm051,Pm052,Pm053,Pm054,Pm055,Pm056,Pm057,Pm058,Pm059,Pm060,Pm061,Pm062,Pm063,Pm064,Pm065,Pm066,Pm067,Pm068,Pm069,Pm070,Pm071,Pm072,Pm073,Pm074,Pm075,Pm076,Pm077,Pm078,Pm079,Pm080,Pm081,Pm082,Pm083,Pm084,Pm085,Pm086,Pm087,Pm088,Pm089,Pm090,Pm091,Pm092,Pm093,Pm094,Pm095,Pm096,Pm097,Pm098,Pm099,Pm100,Pm101,Pm102,Pm103,Pm104,Pm105,Pm106,Pm107,Pm108,Pm109,Pm110,Pm111,Pm112,Pm113,Pm114,Pm115,Pm116,Pm117,Pm118,Pm119,Pm120,Pm121,Pm122,Pm123,Pm124,Pm125,Pm126,Pm127,Pm128,Pm129,Pm130,Pm131,Pm132,Pm133,Pm134,Pm135,Pm136,Pm137,Pm138,Pm139,Pm140,Pm141,Pm142,Pm143,Pm144,Pm145,Pm146,Pm147,Pm148,Pm149,Pm150,Pm151,Pm152,Pm153,Pm154,Pm155"); MISRAC_ENABLE=_Pragma ("diag_default=Pm001,Pm002,Pm003,Pm004,Pm005,Pm006,Pm007,Pm008,Pm009,Pm010,Pm011,Pm012,Pm013,Pm014,Pm015,Pm016,Pm017,Pm018,Pm019,Pm020,Pm021,Pm022,Pm023,Pm024,Pm025,Pm026,Pm027,Pm028,Pm029,Pm030,Pm031,Pm032,Pm033,Pm034,Pm035,Pm036,Pm037,Pm038,Pm039,Pm040,Pm041,Pm042,Pm043,Pm044,Pm045,Pm046,Pm047,Pm048,Pm049,Pm050,Pm051,Pm052,Pm053,Pm054,Pm055,Pm056,Pm057,Pm058,Pm059,Pm060,Pm061,Pm062,Pm063,Pm064,Pm065,Pm066,Pm067,Pm068,Pm069,Pm070,Pm071,Pm072,Pm073,Pm074,Pm075,Pm076,Pm077,Pm078,Pm079,Pm080,Pm081,Pm082,Pm083,Pm084,Pm085,Pm086,Pm087,Pm088,Pm089,Pm090,Pm091,Pm092,Pm093,Pm094,Pm095,Pm096,Pm097,Pm098,Pm099,Pm100,Pm101,Pm102,Pm103,Pm104,Pm105,Pm106,Pm107,Pm108,Pm109,Pm110,Pm111,Pm112,Pm113,Pm114,Pm115,Pm116,Pm117,Pm118,Pm119,Pm120,Pm121,Pm122,Pm123,Pm124,Pm125,Pm126,Pm127,Pm128,Pm129,Pm130,Pm131,Pm132,Pm133,Pm134,Pm135,Pm136,Pm137,Pm138,Pm139,Pm140,Pm141,Pm142,Pm143,Pm144,Pm145,Pm146,Pm147,Pm148,Pm149,Pm150,Pm151,Pm152,Pm153,Pm154,Pm155"); CPU_MKV11Z128VLF7; RTCESL_MMDVSQ_ON
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group linker
    linker/: safety_hvpkv11z75m.icf
  group startup
    startup/: startup_iar.c vectors_iar.c vectors_iar.h
  group source
    ../: freemaster_cfg.h hardware_cfg.h safety_cfg.h main.c main.h m1_pmsm_appconfig.h m1_mcdrv.h
    ../../../../../../middleware/motor_control/pmsm/pmsm_safe/: freemaster_tsa_pmsm.c freemaster_tsa_pmsm.h
  group mc_drivers
    ../../../../../../middleware/motor_control/pmsm/pmsm_safe/mc_drivers/: mcdrv_adc_adc16.h mcdrv_adc_adc16.c mcdrv_pwm3ph_ftm.c mcdrv_pwm3ph_ftm.h mcdrv_gpio.c mcdrv_gpio.h
  group MKV11Z7
    ../../../../../../MKV11Z7/: system_MKV11Z7.c system_MKV11Z7.h
  group motor_control/freemaster
    ../../../../../../middleware/motor_control/freemaster/: pmsm_safe.pmp
  group motor_control/safety_routines
    ../../../../../../middleware/motor_control/pmsm/pmsm_safe/safety_routines/: safety_routines.c safety_routines.h safety_error_handler.h safety_flow_check.h
  group mc_state_machine
    ../../../../../../middleware/motor_control/pmsm/pmsm_safe/mc_state_machine/: m1_state_machine.c m1_state_machine.h m1_state_routines.c m1_state_routines.h
  group periph_init
    ../periph_init/: safety_periph_init.c safety_periph_init.h app_periph_init.c app_periph_init.h mcdrv_periph_init.c mcdrv_periph_init.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MKV11Z7/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_uart.h fsl_uart.c
  group rtcesl/CM0_RTCESL_4.6_IAR/AMCLIB/Include
    ../../../../../../middleware/rtcesl/CM0_RTCESL_4.6_IAR/AMCLIB/Include/: amclib.h AMCLIB_AngleTrackObsrv_F32.h AMCLIB_CtrlFluxWkng_A32.h AMCLIB_PMSMBemfObsrvDQ_A32.h AMCLIB_PMSMBemfObsrvDQHw_A32.h AMCLIB_PMSMBemfObsrvAB_A32.h AMCLIB_PMSMBemfObsrvABHw_A32.h AMCLIB_TrackObsrv_F32.h amclib_types.h
  group rtcesl/CM0_RTCESL_4.6_IAR/GDFLIB/Include
    ../../../../../../middleware/rtcesl/CM0_RTCESL_4.6_IAR/GDFLIB/Include/: gdflib.h GDFLIB_FilterExp_F32.h GDFLIB_FilterIIR1_F32.h GDFLIB_FilterIIR2_F32.h GDFLIB_FilterMA_A32.h GDFLIB_FilterMA_A32_Asmi.h gdflib_types.h
  group rtcesl/CM0_RTCESL_4.6_IAR/GFLIB/Include
    ../../../../../../middleware/rtcesl/CM0_RTCESL_4.6_IAR/GFLIB/Include/: gflib.h GFLIB_Atan_F32.h GFLIB_AtanYX_F32.h GFLIB_AtanYXHw_F32.h GFLIB_CtrlBetaIPp_A32.h GFLIB_CtrlPIp_A32.h GFLIB_DFlexRamp_A32.h GFLIB_DFlexRampHw_A32.h GFLIB_DRamp_F16.h GFLIB_DRamp_F32.h GFLIB_FlexRamp_A32.h GFLIB_FlexRampHw_A32.h GFLIB_Hyst_F16_Asmi.h GFLIB_Integrator_A32.h GFLIB_Limit_F16.h GFLIB_Limit_F32.h GFLIB_LowerLimit_F16.h GFLIB_LowerLimit_F32.h GFLIB_Lut_F16_Asmi.h GFLIB_Lut_F32.h GFLIB_LutPer_F16_Asmi.h GFLIB_LutPer_F32.h GFLIB_Ramp_F16.h GFLIB_Ramp_F16_Asmi.h GFLIB_Ramp_F32.h GFLIB_Ramp_F32_Asmi.h GFLIB_SinCos_A32.h GFLIB_Sqrt_F16.h GFLIB_Sqrt_F32.h GFLIB_SqrtHw_F16.h GFLIB_SqrtHw_F16_Asmi.h GFLIB_SqrtHw_F32.h GFLIB_SqrtHw_F32_Asmi.h gflib_types.h GFLIB_UpperLimit_F16.h GFLIB_UpperLimit_F32.h GFLIB_VectorLimit1_F16.h GFLIB_VectorLimit1Hw_F16.h
  group rtcesl/CM0_RTCESL_4.6_IAR/GMCLIB/Include
    ../../../../../../middleware/rtcesl/CM0_RTCESL_4.6_IAR/GMCLIB/Include/: gmclib.h GMCLIB_Clark_F16_Asmi.h GMCLIB_Decoupling_A32.h GMCLIB_ElimDcBusRip_A32.h GMCLIB_ElimDcBusRip_F16.h GMCLIB_ElimDcBusRipHw_A32.h GMCLIB_ElimDcBusRipHw_F16.h GMCLIB_Park_F16_Asmi.h GMCLIB_Svm_F16.h gmclib_types.h
  group rtcesl/CM0_RTCESL_4.6_IAR/MLIB/Include
    ../../../../../../middleware/rtcesl/CM0_RTCESL_4.6_IAR/MLIB/Include/: asm_mac.h mlib.h MLIB_Abs_F16.h MLIB_Abs_F16_Asmi.h MLIB_Abs_F32.h MLIB_Abs_F32_Asmi.h MLIB_Add_A32.h MLIB_Add_A32_Asmi.h MLIB_Add_F16.h MLIB_Add_F16_Asmi.h MLIB_Add_F32.h MLIB_Add_F32_Asmi.h MLIB_Add4_F16.h MLIB_Add4_F16_Asmi.h MLIB_Add4_F32.h MLIB_Add4_F32_Asmi.h MLIB_BiShift_F16.h MLIB_BiShift_F16_Asmi.h MLIB_BiShift_F32.h MLIB_BiShift_F32_Asmi.h MLIB_Clb_F16_Asmi.h MLIB_Clb_F32.h MLIB_Clb_F32_Asmi.h MLIB_Conv_F32.h MLIB_Div_A32_Asm.h MLIB_Div_F16_Asm.h MLIB_Div_F32_Asm.h MLIB_Div1Q_A32_Asm.h MLIB_Div1Q_F16_Asm.h MLIB_Div1Q_F32_Asm.h MLIB_DivHw_A32_Asm.h MLIB_DivHw_F16_Asm.h MLIB_DivHw_F32.h MLIB_DivHw_F32_Asm.h MLIB_DivHw1Q_A32_Asm.h MLIB_DivHw1Q_F16_Asm.h MLIB_DivHw1Q_F32_Asm.h MLIB_Log2_U16_Asmi.h MLIB_Mac_A32.h MLIB_Mac_F16.h MLIB_Mac_F16_Asmi.h MLIB_Mac_F32.h MLIB_Mac_F32_Asmi.h MLIB_Mac4_F32.h MLIB_Mac4Rnd_F16.h MLIB_Mac4Rnd_F16_Asmi.h MLIB_Mac4Rnd_F32_Asm.h MLIB_MacRnd_A32.h MLIB_MacRnd_A32_Asmi.h MLIB_MacRnd_F16.h MLIB_MacRnd_F16_Asmi.h MLIB_MacRnd_F32.h MLIB_MacRnd_F32_Asmi.h MLIB_MMDVSQ.h MLIB_Mnac_A32.h MLIB_Mnac_F16.h MLIB_Mnac_F16_Asmi.h MLIB_Mnac_F32.h MLIB_Mnac_F32_Asmi.h MLIB_MnacRnd_A32.h MLIB_MnacRnd_A32_Asmi.h MLIB_MnacRnd_F16.h MLIB_MnacRnd_F16_Asmi.h MLIB_MnacRnd_F32.h MLIB_MnacRnd_F32_Asmi.h MLIB_Msu_A32.h MLIB_Msu_F16.h MLIB_Msu_F16_Asmi.h MLIB_Msu_F32.h MLIB_Msu_F32_Asmi.h MLIB_Msu4_F32.h MLIB_Msu4Rnd_F16.h MLIB_Msu4Rnd_F16_Asmi.h MLIB_Msu4Rnd_F32_Asm.h MLIB_MsuRnd_A32.h MLIB_MsuRnd_A32_Asmi.h MLIB_MsuRnd_F16.h MLIB_MsuRnd_F16_Asmi.h MLIB_MsuRnd_F32.h MLIB_MsuRnd_F32_Asmi.h MLIB_Mul_A32.h MLIB_Mul_A32_Asmi.h MLIB_Mul_F16.h MLIB_Mul_F16_Asmi.h MLIB_Mul_F32.h MLIB_Mul_F32_Asmi.h MLIB_MulRnd_A32.h MLIB_MulRnd_A32_Asmi.h MLIB_MulRnd_F16.h MLIB_MulRnd_F16_Asmi.h MLIB_MulRnd_F32.h MLIB_MulRnd_F32_Asmi.h MLIB_Neg_F16.h MLIB_Neg_F16_Asmi.h MLIB_Neg_F32.h MLIB_Neg_F32_Asmi.h MLIB_Rcp_A32_Asm.h MLIB_Rcp1Q_A32_Asm.h MLIB_RcpHw_A32_Asm.h MLIB_RcpHw1Q_A32_Asmi.h MLIB_Rnd_F32.h MLIB_Rnd_F32_Asmi.h MLIB_Sat_A32.h MLIB_Sat_A32_Asmi.h MLIB_Shift_F16.h MLIB_Shift_F16_Asmi.h MLIB_Shift_F32.h MLIB_Shift_F32_Asmi.h MLIB_Sign_F16_Asmi.h MLIB_Sign_F32_Asmi.h MLIB_Sub_A32.h MLIB_Sub_A32_Asmi.h MLIB_Sub_F16.h MLIB_Sub_F16_Asmi.h MLIB_Sub_F32.h MLIB_Sub_F32_Asmi.h MLIB_Sub4_F16.h MLIB_Sub4_F16_Asmi.h MLIB_Sub4_F32.h MLIB_Sub4_F32_Asmi.h mlib_types.h RTCESL_cfg.h
  group safety_iec60730b/safety_library/iec60730b_cm0_v4_1
    ../../../../../../middleware/safety_iec60730b/safety/v4_1/: iec60730b.h iec60730b_types.h
  group safety_iec60730b/safety_library/iec60730b_cm0_v4_1/core_test/cm0
    ../../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/: iec60730b_core.h
  group safety_iec60730b/safety_library/iec60730b_cm0_v4_1/core_test/cm0/flash
    ../../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/flash/: iec60730b_cm0_flash.h
  group safety_iec60730b/safety_library/iec60730b_cm0_v4_1/core_test/cm0/programCounter
    ../../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/programCounter/: iec60730b_cm0_pc.h iec60730b_cm0_pc_object.S
  group safety_iec60730b/safety_library/iec60730b_cm0_v4_1/core_test/cm0/ram
    ../../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/ram/: iec60730b_cm0_ram.h
  group safety_iec60730b/safety_library/iec60730b_cm0_v4_1/core_test/cm0/register
    ../../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/register/: iec60730b_cm0_reg.h
  group safety_iec60730b/safety_library/iec60730b_cm0_v4_1/core_test/cm0/stack
    ../../../../../../middleware/safety_iec60730b/safety/v4_1/core_test/cm0/stack/: iec60730b_cm0_stack.h
  group safety_iec60730b/safety_library/iec60730b_cm0_v4_1/common_test/aio
    ../../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/aio/: iec60730b_aio.h
  group safety_iec60730b/safety_library/iec60730b_cm0_v4_1/common_test/clock
    ../../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/clock/: iec60730b_clock.h
  group safety_iec60730b/safety_library/iec60730b_cm0_v4_1/common_test/dio
    ../../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/dio/: iec60730b_dio.h iec60730b_dio_ext.h
  group safety_iec60730b/safety_library/iec60730b_cm0_v4_1/common_test/tsi
    ../../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/tsi/: iec60730b_tsi.h
  group safety_iec60730b/safety_library/iec60730b_cm0_v4_1/common_test/wdog
    ../../../../../../middleware/safety_iec60730b/safety/v4_1/common_test/wdog/: iec60730b_wdog.c iec60730b_wdog.h
  group safety_iec60730b/safety_library/iec60730b_cm0_v4_1/compiler
    ../../../../../../middleware/safety_iec60730b/safety/v4_1/compiler/: asm_mac_common.h
  group device
    ../../../../../../devices/MKV11Z7/: fsl_device_registers.h MKV11Z7.h MKV11Z7_features.h
  group freemaster
    ../../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_defcfg.h freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h freemaster_can.c freemaster_can.h freemaster_sha.c freemaster_pdbdm.c freemaster_serial.c freemaster_serial.h
  group freemaster/platforms
    ../../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group freemaster/drivers
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mscan.c freemaster_mscan.h freemaster_mcan.c freemaster_mcan.h
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_usb.c freemaster_serial_usb.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm0plus.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
