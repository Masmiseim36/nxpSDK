# IAR project freertos_uart.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV11Z128xxx7 NXP MKV11Z128xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKV11Z128VLF7; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../devices/MKV11Z7/drivers; ../../../../../devices/MKV11Z7; ../../../../../devices/MKV11Z7/utilities/str; ../../../../../devices/MKV11Z7/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../CMSIS/Include; ../../../../../rtos/freertos/freertos_kernel/include; ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM0
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: freertos_uart.out
  ILINK.IlinkIcfFile: MKV11Z128xxx7_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV11Z128VLF7; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: freertos_uart.c FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKV11Z7/drivers/: fsl_port.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_uart.h fsl_uart.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c
  group drivers/freertos
    ../../../../../devices/MKV11Z7/drivers/: fsl_uart_freertos.h fsl_uart_freertos.c
  group freertos/freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos_kernel/portable/IAR/ARM_CM0
    ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/include
    ../../../../../rtos/freertos/freertos_kernel/include/: croutine.h StackMacros.h atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group device
    ../../../../../devices/MKV11Z7/: fsl_device_registers.h MKV11Z7.h MKV11Z7_features.h system_MKV11Z7.c system_MKV11Z7.h
  group utilities
    ../../../../../devices/MKV11Z7/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MKV11Z7/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MKV11Z7/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MKV11Z7/iar/: startup_MKV11Z7.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm0plus.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
