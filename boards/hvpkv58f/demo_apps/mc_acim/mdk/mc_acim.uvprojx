# Keil uVision project mc_acim.uvprojx, settings and files
target mc_acim debug (ARM-ADS)
  device: MKV58F1M0VLQ24 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: mc_acim.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_MKV58F1M0VLQ24, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../middleware/motor_control/boards/hvpkv58f/mc_acim;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../middleware/motor_control/fmstr_cfg_uart;../../../../../middleware/motor_control/acim/mc_drivers;../../../../../middleware/motor_control/acim/meterlib/cm7f_4.0;../../../../../middleware/motor_control/acim/meterlib/cm7f_4.0/fraclib;../../../../../middleware/motor_control/acim/meterlib/cm7f_4.0/fraclib/inc;../../../../../middleware/motor_control/acim/meterlib/cm7f_4.0/fraclib/inc/cm7f;../../../../../middleware/motor_control/acim/meterlib/cm7f_4.0/meterlib;../../../../../middleware/motor_control/acim/meterlib/cm7f_4.0/meterlib/inc;../../../../../middleware/motor_control/acim/meterlib/cm7f_4.0/meterliblp;../../../../../middleware/motor_control/acim/meterlib/cm7f_4.0/meterliblp/inc;..;../../../../../devices/MKV58F24/drivers;../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_KEIL/AMCLIB;../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_KEIL/AMCLIB/Include;../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_KEIL/GDFLIB;../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_KEIL/GDFLIB/Include;../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_KEIL/GFLIB;../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_KEIL/GFLIB/Include;../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_KEIL/GMCLIB;../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_KEIL/GMCLIB/Include;../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_KEIL/MLIB;../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_KEIL/MLIB/Include;../../../../../middleware/motor_control/acim;../../../../../middleware/motor_control/acim/mc_algorithms;../../../../../middleware/motor_control/acim/mc_state_machine;../../../../../middleware/motor_control/acim/state_machine;../../../../../middleware/motor_control/acim/mc_identification;../../../../../middleware/motor_control/acim/mc_identification/src_common;../../../../../middleware/motor_control/acim/mc_identification/src_routines;../../../../../middleware/motor_control/acim/meterlib;../../../../../middleware/motor_control/acim/meterlib/cm4f_4.0;../../../../../middleware/motor_control/acim/meterlib/cm4f_4.0/fraclib;../../../../../middleware/motor_control/acim/meterlib/cm4f_4.0/fraclib/inc;../../../../../middleware/motor_control/acim/meterlib/cm4f_4.0/fraclib/inc/cm4f;../../../../../middleware/motor_control/acim/meterlib/cm4f_4.0/meterlib;../../../../../middleware/motor_control/acim/meterlib/cm4f_4.0/meterlib/inc;../../../../../middleware/motor_control/acim/meterlib/cm4f_4.0/meterliblp;../../../../../middleware/motor_control/acim/meterlib/cm4f_4.0/meterliblp/inc;../../../../../middleware/motor_control/acim/meterlib/cm7f_4.0/fraclib/inc/cm7;../../../../../devices/MKV58F24;../../../../../devices/MKV58F24/utilities/str;../../../../../devices/MKV58F24/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../middleware/freemaster/src/common;../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial;../../../../../middleware/freemaster/src/drivers/mcuxsdk/can;../../../../../middleware/freemaster/src/platforms/gen32le;../../../../../devices/MKV58F24/utilities
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: MKV58F1M0xxx24_flash.scf
  link misc: ../../../../../middleware/motor_control/acim/meterlib/cm7f_4.0/meterliblp/meterliblp_cm7f_arm.lib ../../../../../middleware/motor_control/acim/meterlib/cm7f_4.0/meterlib/meterlib_cm7f_arm.lib ../../../../../middleware/motor_control/acim/meterlib/cm7f_4.0/fraclib/fraclib_cm7f_arm.lib ../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_KEIL/AMCLIB/AMCLIB.lib ../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_KEIL/GDFLIB/GDFLIB.lib ../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_KEIL/GFLIB/GFLIB.lib ../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_KEIL/GMCLIB/GMCLIB.lib ../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_KEIL/MLIB/MLIB.lib --remove --keep=*(.FlashConfig)
  group source
    ../../../../../middleware/motor_control/fmstr_cfg_uart/: freemaster_cfg.h
    ../: main.c main.h
    ../../../../../middleware/motor_control/acim/: fm_tsa_acim.c fm_tsa_acim.h
  group mc_drivers
    ../../../../../middleware/motor_control/acim/mc_drivers/: mcdrv_adc_hsadc.c mcdrv_adc_hsadc.h mcdrv_pwm3ph_pwma.c mcdrv_pwm3ph_pwma.h
  group meterlib/fraclib/cm7f
    ../../../../../middleware/motor_control/acim/meterlib/cm7f_4.0/fraclib/inc/cm7f/: fraclib_inlines.h
  group meterlib/fraclib
    ../../../../../middleware/motor_control/acim/meterlib/cm7f_4.0/fraclib/inc/: fraclib.h types.h
  group meterlib/meterlib
    ../../../../../middleware/motor_control/acim/meterlib/cm7f_4.0/meterlib/inc/: meterlib.h
  group meterlib/meterliblp
    ../../../../../middleware/motor_control/acim/meterlib/cm7f_4.0/meterliblp/inc/: meterliblp.h
  group board
    ../: m1_acim_appconfig.h mcdrv_hvpkv58f.c mcdrv_hvpkv58f.h mcdrv.h char_pwrstg.h pin_mux.c pin_mux.h meterlibcfg.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKV58F24/drivers/: fsl_sim.c fsl_sim.h fsl_port.h fsl_dmamux.c fsl_dmamux.h fsl_clock.c fsl_clock.h fsl_xbara.c fsl_xbara.h fsl_common.c fsl_common.h fsl_uart.c fsl_uart.h fsl_smc.c fsl_smc.h fsl_gpio.c fsl_gpio.h
  group rtcesl/amclib
    ../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_KEIL/AMCLIB/Include/: AMCLIB_ACIMCtrlMTPA_FLT.h AMCLIB_ACIMRotFluxObsrv_FLT.h AMCLIB_ACIMSpeedMRAS_FLT.h AMCLIB_AngleTrackObsrv_F32.h AMCLIB_AngleTrackObsrv_FLT.h AMCLIB_CtrlFluxWkng_A32.h AMCLIB_CtrlFluxWkng_FLT.h AMCLIB_PMSMBemfObsrvAB_A32.h AMCLIB_PMSMBemfObsrvAB_FLT.h AMCLIB_PMSMBemfObsrvDQ_A32.h AMCLIB_PMSMBemfObsrvDQ_FLT.h AMCLIB_TrackObsrv_F32.h AMCLIB_TrackObsrv_FLT.h amclib.h amclib_FP.h amclib_types.h
  group rtcesl/gdflib
    ../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_KEIL/GDFLIB/Include/: GDFLIB_FilterExp_F32.h GDFLIB_FilterExp_FLT.h GDFLIB_FilterIIR1_F32.h GDFLIB_FilterIIR1_F32_Asmi.h GDFLIB_FilterIIR1_FLT.h GDFLIB_FilterIIR2_F32.h GDFLIB_FilterIIR2_FLT.h GDFLIB_FilterIIR3_F32.h GDFLIB_FilterIIR3_FLT.h GDFLIB_FilterIIR4_F32.h GDFLIB_FilterIIR4_FLT.h GDFLIB_FilterMA_A32.h GDFLIB_FilterMA_FLT.h gdflib.h gdflib_FP.h gdflib_types.h
  group rtcesl/gflib
    ../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_KEIL/GFLIB/Include/: GFLIB_Acos_F16.h GFLIB_Acos_FLT.h GFLIB_Asin_F16.h GFLIB_Asin_FLT.h GFLIB_AtanYX_F16.h GFLIB_AtanYX_FLT.h GFLIB_Atan_F32.h GFLIB_Atan_FLT.h GFLIB_CtrlBetaIPDp_A32.h GFLIB_CtrlBetaIPDp_FLT.h GFLIB_CtrlBetaIPp_A32.h GFLIB_CtrlBetaIPp_FLT.h GFLIB_CtrlPIDp_A32.h GFLIB_CtrlPIDp_FLT.h GFLIB_CtrlPIp_A32.h GFLIB_CtrlPIp_FLT.h GFLIB_DFlexRamp_A32.h GFLIB_DFlexRamp_FLT.h GFLIB_DRamp_F16.h GFLIB_DRamp_F32.h GFLIB_DRamp_FLT.h GFLIB_FlexRamp_A32.h GFLIB_FlexRamp_FLT.h GFLIB_FlexSRamp_A32.h GFLIB_FlexSRamp_FLT.h GFLIB_Hyst_F16_Asmi.h GFLIB_Hyst_FLT.h GFLIB_Integrator_A32.h GFLIB_Integrator_FLT.h GFLIB_Limit_F16.h GFLIB_Limit_F32.h GFLIB_Limit_FLT.h GFLIB_LowerLimit_F16.h GFLIB_LowerLimit_F32.h GFLIB_LowerLimit_FLT.h GFLIB_LutPer_F16_Asmi.h GFLIB_LutPer_F32.h GFLIB_LutPer_FLT.h GFLIB_Lut_F16_Asmi.h GFLIB_Lut_F32.h GFLIB_Lut_FLT.h GFLIB_Ramp_F16.h GFLIB_Ramp_F32.h GFLIB_Ramp_FLT.h GFLIB_SinCos_F32.h GFLIB_SinCos_FLT.h GFLIB_Sqrt_F16.h GFLIB_Sqrt_F32.h GFLIB_Sqrt_FLT_Asmi.h GFLIB_Tan_F32.h GFLIB_Tan_FLT.h GFLIB_UpperLimit_F16.h GFLIB_UpperLimit_F32.h GFLIB_UpperLimit_FLT.h GFLIB_VectorLimit_F16.h GFLIB_VectorLimit_FLT.h gflib.h gflib_FP.h gflib_types.h
  group rtcesl/gmclib
    ../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_KEIL/GMCLIB/Include/: GMCLIB_Clark_F16_Asmi.h GMCLIB_Clark_FLT.h GMCLIB_Decoupling_A32.h GMCLIB_Decoupling_FLT.h GMCLIB_ElimDcBusRip_A32_Asmi.h GMCLIB_ElimDcBusRip_F16_Asmi.h GMCLIB_ElimDcBusRip_FLT.h GMCLIB_Park_F16_Asmi.h GMCLIB_Park_FLT.h GMCLIB_Svm_F16.h gmclib.h gmclib_FP.h gmclib_types.h
  group rtcesl/mlib
    ../../../../../middleware/rtcesl/CM7F_RTCESL_4.5.1_KEIL/MLIB/Include/: MLIB_Abs_F16.h MLIB_Abs_F16_Asmi.h MLIB_Abs_F32.h MLIB_Abs_F32_Asmi.h MLIB_Abs_FLT.h MLIB_Abs_FLT_Asmi.h MLIB_Add4_F16_Asmi.h MLIB_Add4_F32_Asmi.h MLIB_Add4_FLT.h MLIB_Add_A32.h MLIB_Add_F16.h MLIB_Add_F16_Asmi.h MLIB_Add_F32.h MLIB_Add_F32_Asmi.h MLIB_Add_FLT.h MLIB_BiShift_F16.h MLIB_BiShift_F32.h MLIB_Clb_F16.h MLIB_Clb_F32.h MLIB_ConvSc_FLT_Asmi.h MLIB_Conv_F32.h MLIB_Conv_FLT_Asmi.h MLIB_Div1Q_A32.h MLIB_Div1Q_F16.h MLIB_Div1Q_F32.h MLIB_Div_A32.h MLIB_Div_F16.h MLIB_Div_F32.h MLIB_Div_FLT.h MLIB_Log2_U16.h MLIB_Mac4Rnd_F16_Asmi.h MLIB_Mac4Rnd_F32.h MLIB_Mac4Rnd_F32_Asmi.h MLIB_Mac4_F32.h MLIB_Mac4_F32_Asmi.h MLIB_Mac4_FLT.h MLIB_MacRnd_A32.h MLIB_MacRnd_F16_Asmi.h MLIB_MacRnd_F32.h MLIB_MacRnd_F32_Asmi.h MLIB_Mac_A32.h MLIB_Mac_F16_Asmi.h MLIB_Mac_F32.h MLIB_Mac_F32_Asmi.h MLIB_Mac_FLT.h MLIB_MnacRnd_A32.h MLIB_MnacRnd_F16_Asmi.h MLIB_MnacRnd_F32.h MLIB_MnacRnd_F32_Asmi.h MLIB_Mnac_A32.h MLIB_Mnac_F16_Asmi.h MLIB_Mnac_F32.h MLIB_Mnac_F32_Asmi.h MLIB_Mnac_FLT.h MLIB_Msu4Rnd_F16.h MLIB_Msu4Rnd_F16_Asmi.h MLIB_Msu4Rnd_F32.h MLIB_Msu4Rnd_F32_Asmi.h MLIB_Msu4_F32.h MLIB_Msu4_F32_Asmi.h MLIB_Msu4_FLT.h MLIB_MsuRnd_A32.h MLIB_MsuRnd_F16_Asmi.h MLIB_MsuRnd_F32.h MLIB_MsuRnd_F32_Asmi.h MLIB_Msu_A32.h MLIB_Msu_F16_Asmi.h MLIB_Msu_F32_Asmi.h MLIB_Msu_FLT.h MLIB_MulRnd_A32.h MLIB_MulRnd_A32_Asmi.h MLIB_MulRnd_F16.h MLIB_MulRnd_F16_Asmi.h MLIB_MulRnd_F32.h MLIB_MulRnd_F32_Asmi.h MLIB_Mul_A32.h MLIB_Mul_A32_Asmi.h MLIB_Mul_F16.h MLIB_Mul_F16_Asmi.h MLIB_Mul_F32.h MLIB_Mul_F32_Asmi.h MLIB_Mul_FLT.h MLIB_Neg_F16.h MLIB_Neg_F16_Asmi.h MLIB_Neg_F32.h MLIB_Neg_F32_Asmi.h MLIB_Neg_FLT.h MLIB_Rcp1Q_A32.h MLIB_Rcp_A32.h MLIB_Rnd_F32.h MLIB_Rnd_F32_Asmi.h MLIB_Sat_A32_Asmi.h MLIB_Shift_F16.h MLIB_Shift_F16_Asmi.h MLIB_Shift_F32.h MLIB_Shift_F32_Asmi.h MLIB_Sign_F16_Asmi.h MLIB_Sign_F32_Asmi.h MLIB_Sign_FLT_Asmi.h MLIB_Sub4_F16_Asmi.h MLIB_Sub4_F32_Asmi.h MLIB_Sub4_FLT.h MLIB_Sub_A32.h MLIB_Sub_F16.h MLIB_Sub_F16_Asmi.h MLIB_Sub_F32.h MLIB_Sub_F32_Asmi.h MLIB_Sub_F64.h MLIB_Sub_FLT.h RTCESL_cfg.h asm_mac.h mlib.h mlib_FP.h mlib_types.h
  group mc_algorithms
    ../../../../../middleware/motor_control/acim/mc_algorithms/: acim_control.c acim_control.h
  group mc_identification/src_common
    ../../../../../middleware/motor_control/acim/mc_identification/src_common/: mid_def.h mid_sm_ctrl.c mid_sm_ctrl.h mid_sm_states.c mid_sm_states.h
  group mc_identification/src_routines
    ../../../../../middleware/motor_control/acim/mc_identification/src_routines/: blocked_test.c blocked_test.h calc_acim.c calc_acim.h calc_power.c calc_power.h mech_measure.c mech_measure.h noload_test.c noload_test.h pwrstg_characteristic.c pwrstg_characteristic.h rs_measure.c rs_measure.h
  group mc_state_machine
    ../../../../../middleware/motor_control/acim/mc_state_machine/: m1_sm_ref_sol.c m1_sm_ref_sol.h
  group state_machine
    ../../../../../middleware/motor_control/acim/state_machine/: state_machine.c state_machine.h
  group device
    ../../../../../devices/MKV58F24/: MKV58F24.h MKV58F24_features.h fsl_device_registers.h system_MKV58F24.c system_MKV58F24.h
  group utilities
    ../../../../../devices/MKV58F24/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MKV58F24/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MKV58F24/utilities/: fsl_assert.c
  group component-uart
    ../../../../../components/uart/: uart.h uart_adapter.c
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MKV58F24/arm/: startup_MKV58F24.S
  group freemaster
    ../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_can.c freemaster_can.h freemaster_defcfg.h freemaster_pdbdm.c freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_serial.c freemaster_serial.h freemaster_sha.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h
  group freemaster/drivers/mcuxsdk/can
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mcan.c freemaster_mcan.h freemaster_mscan.c freemaster_mscan.h
  group freemaster/drivers/mcuxsdk/serial
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_usb.c freemaster_serial_usb.h
  group freemaster/platforms
    ../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
target mc_acim release (ARM-ADS)
  device: MKV58F1M0VLQ24 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: mc_acim.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_MKV58F1M0VLQ24, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: MKV58F1M0xxx24_flash.scf
  link misc: as above
