# IAR project mcofd_manager.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S06 NXP LPC55S06
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_LPC55S06JBD64; USE_CANOPEN_FD; SDK_DEBUGCONSOLE=1; CUSTOM_CAN_BITTIMING=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../mco_config/EDS-FD; ../mco_config; ..; ../..; ../../../../../devices/LPC55S06/drivers; ../../../../../devices/LPC55S06/utilities/debug_console_lite; ../../../../../middleware/canopen/mco; ../../../../../devices/LPC55S06; ../../../../../components/uart; ../../../../../components/lists; ../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: mcofd_manager.out
  ILINK.IlinkIcfFile: LPC55S06_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/canopen/mcolibs/LPC55xx/mco_manager/libMCOFD_MGR_LPC55xx_SDK.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_LPC55S06JBD64; USE_CANOPEN_FD; SDK_DEBUGCONSOLE=1; CUSTOM_CAN_BITTIMING=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: main.c user_LPC5xxxx.c mco_types.h mcohw_cfg.h mcohw_com_generic.c mcohw_LEDs.h mcohw_nvol_sim.c mco_libcb.c
  group MCO-Config
    ../mco_config/: user_mgr_401.c nodecfg.h procimg.h user_cbdata.c user_od.c
  group MCO-Config/EDS-FD
    ../mco_config/EDS-FD/: entriesandreplies.h pimg.h stackinit.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/LPC55S06/drivers/: fsl_inputmux.h fsl_inputmux.c fsl_wwdt.h fsl_wwdt.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_mcan.h fsl_mcan.c fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iocon.h fsl_gpio.h fsl_gpio.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_inputmux_connections.h
  group utilities
    ../../../../../devices/LPC55S06/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group mco
    ../../../../../middleware/canopen/mco/: comgr.h concisedcf.h mco.h mcohw.h mcohw_com.h mcop.h mcop_inc.h mcop_mgr_inc.h mcop_xod_inc.h raccess.h racrc.h raserial.h sdoclnt.h usdo.h usdoclnt.h
  group device
    ../../../../../devices/LPC55S06/: fsl_device_registers.h LPC55S06.h LPC55S06_features.h system_LPC55S06.c system_LPC55S06.h
  group startup
    ../../../../../devices/LPC55S06/iar/: startup_LPC55S06.s
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
