# Keil uVision project mcofd_manager.uvprojx, settings and files
target mcofd_manager debug (6140001::V6.14.1::ARMCLANG)
  device: LPC55S06JBD64 NXP
  pack: NXP.LPC55S06_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: mcofd_manager.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_LPC55S06JBD64, USE_CANOPEN_FD, SDK_DEBUGCONSOLE=1, CUSTOM_CAN_BITTIMING=1, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../mco_config/EDS-FD;../mco_config;..;../..;../../../../../devices/LPC55S06/drivers;../../../../../devices/LPC55S06/utilities/debug_console_lite;../../../../../middleware/canopen/mco;../../../../../devices/LPC55S06;../../../../../components/uart;../../../../../components/lists;../../../../../CMSIS/Core/Include
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL, DEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x38000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x10000
  memory RVCT7: RAM 0x20010000 size 0x4000
  memory RVCT8: RAM 0x30010000 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x38000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: LPC55S06_flash.scf
  link misc: ../../../../../middleware/canopen/mcolibs/LPC55xx/mco_manager/libMCOFD_MGR_LPC55xx_KSDK.a --remove --entry=Reset_Handler
  group source
    ../: main.c user_LPC5xxxx.c mco_types.h mcohw_cfg.h mcohw_com_generic.c mcohw_LEDs.h mcohw_nvol_sim.c mco_libcb.c
  group MCO-Config
    ../mco_config/: user_mgr_401.c nodecfg.h procimg.h user_cbdata.c user_od.c
  group MCO-Config/EDS-FD
    ../mco_config/EDS-FD/: entriesandreplies.h pimg.h stackinit.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/LPC55S06/drivers/: fsl_inputmux.h fsl_inputmux.c fsl_wwdt.h fsl_wwdt.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_mcan.h fsl_mcan.c fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iocon.h fsl_gpio.h fsl_gpio.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_inputmux_connections.h
  group utilities
    ../../../../../devices/LPC55S06/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group mco
    ../../../../../middleware/canopen/mco/: comgr.h concisedcf.h mco.h mcohw.h mcohw_com.h mcop.h mcop_inc.h mcop_mgr_inc.h mcop_xod_inc.h raccess.h racrc.h raserial.h sdoclnt.h usdo.h usdoclnt.h
  group device
    ../../../../../devices/LPC55S06/: fsl_device_registers.h LPC55S06.h LPC55S06_features.h system_LPC55S06.c system_LPC55S06.h
  group startup
    ../../../../../devices/LPC55S06/arm/: startup_LPC55S06.S
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target mcofd_manager release (6130001::V6.13.1::.\ARMCLANG)
  device: LPC55S06JBD64 NXP
  pack: NXP.LPC55S16_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: mcofd_manager.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_LPC55S06JBD64, USE_CANOPEN_FD, SDK_DEBUGCONSOLE=1, CUSTOM_CAN_BITTIMING=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x20040000 size 0x4000
  memory RVCT7: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S06_flash.scf
  link misc: as above
