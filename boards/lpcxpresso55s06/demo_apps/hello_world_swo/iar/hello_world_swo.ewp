# IAR project hello_world_swo.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S06 NXP LPC55S06
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_LPC55S06JBD64; SERIAL_PORT_TYPE_SWO=1; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../devices/LPC55S06/drivers; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../devices/LPC55S06; ../../../../../devices/LPC55S06/utilities/str; ../../../../../devices/LPC55S06/utilities/debug_console; ../../../../../components/uart; ../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: hello_world_swo.out
  ILINK.IlinkIcfFile: LPC55S06_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_LPC55S06JBD64; SERIAL_PORT_TYPE_SWO=1; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: hello_world_swo.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/LPC55S06/drivers/: fsl_pint.h fsl_pint.c fsl_inputmux.h fsl_inputmux.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_iocon.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_gpio.h fsl_gpio.c fsl_inputmux_connections.h
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_swo.h fsl_component_serial_port_swo.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group device
    ../../../../../devices/LPC55S06/: fsl_device_registers.h LPC55S06.h LPC55S06_features.h system_LPC55S06.c system_LPC55S06.h
  group startup
    ../../../../../devices/LPC55S06/iar/: startup_LPC55S06.s
  group utilities
    ../../../../../devices/LPC55S06/utilities/: fsl_assert.c
    ../../../../../devices/LPC55S06/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/LPC55S06/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
