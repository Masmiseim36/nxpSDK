# IAR project lpadc_temperature_measurement.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S06 NXP LPC55S06
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_LPC55S06JBD64; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/LPC55S06/utilities/debug_console_lite; ../../../../../../devices/LPC55S06/drivers; ../../../../../../devices/LPC55S06; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: lpadc_temperature_measurement.out
  ILINK.IlinkIcfFile: LPC55S06_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_LPC55S06JBD64; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: lpadc_temperature_measurement.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../../devices/LPC55S06/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../devices/LPC55S06/drivers/: fsl_lpadc.c fsl_lpadc.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_iocon.h fsl_gpio.h fsl_gpio.c fsl_inputmux.h fsl_inputmux.c fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_reset.h fsl_reset.c fsl_inputmux_connections.h
  group device
    ../../../../../../devices/LPC55S06/: fsl_device_registers.h LPC55S06.h LPC55S06_features.h system_LPC55S06.c system_LPC55S06.h
  group startup
    ../../../../../../devices/LPC55S06/iar/: startup_LPC55S06.s
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
