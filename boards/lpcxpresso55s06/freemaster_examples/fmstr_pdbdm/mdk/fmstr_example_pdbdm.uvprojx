# Keil uVision project fmstr_example_pdbdm.uvprojx, settings and files
target fmstr_example_pdbdm debug (6140001::V6.14.1::ARMCLANG)
  device: LPC55S06JBD64 NXP
  pack: NXP.LPC55S06_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: fmstr_example_pdbdm.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_LPC55S06JBD64, SDK_DEBUGCONSOLE=1, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../common/fmstr_example;../../../../../devices/LPC55S06/drivers;../../../../../devices/LPC55S06/utilities/debug_console_lite;../../../../../middleware/freemaster/src/common;../../../../../devices/LPC55S06;../../../../../components/uart;../../../../../components/lists;../../../../../middleware/freemaster/src/platforms/gen32le;../../../../../middleware/freemaster/src/drivers/mcuxsdk/can;../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial;../../../../../CMSIS/Core/Include
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL, DEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x38000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x10000
  memory RVCT7: RAM 0x20010000 size 0x4000
  memory RVCT8: RAM 0x30010000 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x38000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: LPC55S06_flash.scf
  link misc: --remove --entry=Reset_Handler
  group source
    ../: main.c freemaster_cfg.h
    ../../common/fmstr_example/: freemaster_example.c freemaster_example.h
  group board
    ../: clock_config.c clock_config.h pin_mux.c pin_mux.h board.c board.h
  group source/example_data
    ../../common/fmstr_example/: data_example_pmp.h data_img_logo.h data_img_file.h data_img_fmstrlogo.h data_html_index.h example_data.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/LPC55S06/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iocon.h fsl_gpio.h fsl_gpio.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c
  group utilities
    ../../../../../devices/LPC55S06/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group freemaster
    ../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_defcfg.h freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h freemaster_can.c freemaster_can.h freemaster_sha.c freemaster_pdbdm.c freemaster_serial.c freemaster_serial.h freemaster_net.c freemaster_net.h
  group device
    ../../../../../devices/LPC55S06/: fsl_device_registers.h LPC55S06.h LPC55S06_features.h system_LPC55S06.c system_LPC55S06.h
  group startup
    ../../../../../devices/LPC55S06/arm/: startup_LPC55S06.S
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group freemaster/platforms
    ../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group freemaster/drivers
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mscan.c freemaster_mscan.h freemaster_mcan.c freemaster_mcan.h
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_usb.c freemaster_serial_usb.h
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/network/: freemaster_net_lwip_udp.c freemaster_net_lwip_udp.h freemaster_net_lwip_tcp.c freemaster_net_lwip_tcp.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target fmstr_example_pdbdm release (6130001::V6.13.1::.\ARMCLANG)
  device: LPC55S06JBD64 NXP
  pack: NXP.LPC55S16_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: fmstr_example_pdbdm.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_LPC55S06JBD64, SDK_DEBUGCONSOLE=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x20040000 size 0x4000
  memory RVCT7: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S06_flash.scf
  link misc: --remove --entry=Reset_Handler
