# Keil uVision project ntag_i2c_explorer_blink.uvprojx, settings and files
target ntag_i2c_explorer_blink debug (6140001::V6.14.1::ARMCLANG)
  device: LPC55S06JBD64 NXP
  pack: NXP.LPC55S06_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: ntag_i2c_explorer_blink.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_LPC55S06JBD64, PRINTF_ADVANCED_ENABLE=1, I2C_LPC, PRINTF_ADVANCED_ENABLE=1, HAVE_STDBOOL_H, HAVE_STDINT_H, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../devices/LPC55S06/drivers;../../../../../devices/LPC55S06/utilities/debug_console_lite;../../../../../middleware/ntag_i2c_plus/HAL_NTAG/inc;../../../../../middleware/ntag_i2c_plus/HAL_NTAG;../../../../../middleware/ntag_i2c_plus/HAL_I2C/inc;../../../../../middleware/ntag_i2c_plus/HAL_ISR/inc;../../../../../middleware/ntag_i2c_plus/HAL_ISR;../../../../../middleware/ntag_i2c_plus/HAL_TMR/inc;../../../../../middleware/ntag_i2c_plus/inc;../../../../../devices/LPC55S06;../../../../../components/uart;../../../../../components/lists;../../../../../CMSIS/Core/Include
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL, DEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x38000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x10000
  memory RVCT7: RAM 0x20010000 size 0x4000
  memory RVCT8: RAM 0x30010000 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x38000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: LPC55S06_flash.scf
  link misc: --remove --entry=Reset_Handler
  group source
    ../: ntag_i2c_explorer_blink.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/LPC55S06/drivers/: fsl_inputmux.h fsl_inputmux.c fsl_inputmux_connections.h fsl_pint.h fsl_pint.c fsl_i2c.h fsl_i2c.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iocon.h fsl_gpio.h fsl_gpio.c
  group utilities
    ../../../../../devices/LPC55S06/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group ntag_i2c_plus/HAL_NTAG/inc
    ../../../../../middleware/ntag_i2c_plus/HAL_NTAG/inc/: ntag_bridge.h ntag_defines.h ntag_device_list.h ntag_driver.h
  group ntag_i2c_plus/HAL_NTAG
    ../../../../../middleware/ntag_i2c_plus/HAL_NTAG/: ntag_driver_intern.h ntag_bridge.c ntag_driver.c
  group ntag_i2c_plus/HAL_I2C/inc
    ../../../../../middleware/ntag_i2c_plus/HAL_I2C/inc/: HAL_I2C_driver.h HAL_I2C_lpc_fsl.h
  group ntag_i2c_plus/HAL_I2C
    ../../../../../middleware/ntag_i2c_plus/HAL_I2C/: i2c_lpc_fsl.c
  group ntag_i2c_plus/HAL_ISR/inc
    ../../../../../middleware/ntag_i2c_plus/HAL_ISR/inc/: HAL_ISR_callback_list.h HAL_ISR_driver.h
  group ntag_i2c_plus/HAL_ISR
    ../../../../../middleware/ntag_i2c_plus/HAL_ISR/: isr_driver_intern.h isr_lpc_intern.h isr_common.c isr_lpc.c
  group ntag_i2c_plus/HAL_TMR/inc
    ../../../../../middleware/ntag_i2c_plus/HAL_TMR/inc/: HAL_timer_driver.h
  group ntag_i2c_plus/HAL_TMR
    ../../../../../middleware/ntag_i2c_plus/HAL_TMR/: timer_driver.c
  group ntag_i2c_plus/inc
    ../../../../../middleware/ntag_i2c_plus/inc/: global_types.h nfc_device.h
  group device
    ../../../../../devices/LPC55S06/: fsl_device_registers.h LPC55S06.h LPC55S06_features.h system_LPC55S06.c system_LPC55S06.h
  group startup
    ../../../../../devices/LPC55S06/arm/: startup_LPC55S06.S
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target ntag_i2c_explorer_blink release (6130001::V6.13.1::.\ARMCLANG)
  device: LPC55S06JBD64 NXP
  pack: NXP.LPC55S16_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: ntag_i2c_explorer_blink.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_LPC55S06JBD64, PRINTF_ADVANCED_ENABLE=1, I2C_LPC, PRINTF_ADVANCED_ENABLE=1, HAVE_STDBOOL_H, HAVE_STDINT_H, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x20040000 size 0x4000
  memory RVCT7: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S06_flash.scf
  link misc: --remove --entry=Reset_Handler
