# IAR project tfm_regression_ns.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S06 NXP LPC55S06
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_LPC55S06JBD64; TFM_LVL=2; ITS_MAX_ASSET_SIZE=512; PS_MAX_ASSET_SIZE=512; __DOMAIN_NS=1; DOMAIN_NS=1; TFM_CRYPTO_TEST_ALG_CBC; TFM_CRYPTO_TEST_ALG_CCM; TFM_CRYPTO_TEST_ALG_CFB; TFM_CRYPTO_TEST_ALG_CTR; TFM_CRYPTO_TEST_ALG_GCM; TFM_CRYPTO_TEST_ALG_SHA_512; TFM_CRYPTO_TEST_HKDF; TFM_PARTITION_PLATFORM; TFM_PARTITION_PROTECTED_STORAGE; TFM_PARTITION_INTERNAL_TRUSTED_STORAGE; TFM_PARTITION_CRYPTO; TFM_PARTITION_INITIAL_ATTESTATION; OS_DYNAMIC_MEM_SIZE=8192; TEST_FRAMEWORK_NS; SERVICES_TEST_NS; ENABLE_INTERNAL_TRUSTED_STORAGE_SERVICE_TESTS; ENABLE_ATTESTATION_SERVICE_TESTS; T_COSE_USE_PSA_CRYPTO; ENABLE_CRYPTO_SERVICE_TESTS; TFM_PSA_API; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pa084,Pe128,Pe186,Pe546,Pe940
  ICCARM.IExtraOptions: --diag_suppress Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../devices/LPC55S06; ..; ../../../../../../devices/LPC55S06/drivers; ../../../../../../middleware/tfm/tf-m/platform/include; ../../../../../../middleware/tfm/tf-m/platform/ext; ../../../../../../middleware/tfm/tf-m/platform/ext/common; ../../../../../../middleware/tfm/tf-m/platform/ext/driver; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/lpcxpresso55s06/Device/Include; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/lpcxpresso55s06; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/lpcxpresso55s06/partition; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/lpcxpresso55s06/Device/Config; ../../../../../../middleware/tfm/tf-m/interface/include; ../../../../../../middleware/tfm/tf-m/interface/include/os_wrapper; ../../../../../../middleware/tfm/tf-m/interface/include/psa; ../../../../../../middleware/tfm/tf-m/bl2/include; ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include; ../../../../../../middleware/tfm/tf-m/secure_fw/include/tfm; ../../../../../../middleware/tfm/tf-m-tests/test/framework; ../../../../../../middleware/tfm/tf-m-tests/test/suites/core/non_secure; ../../../../../../middleware/tfm/tf-m-tests/test/suites/ipc/non_secure; ../../../../../../middleware/tfm/tf-m-tests/test/suites/audit/non_secure; ../../../../../../middleware/tfm/tf-m-tests/test/suites/t_cose/non_secure; ../../../../../../middleware/tfm/tf-m-tests/test/suites/multi_core/non_secure; ../../../../../../middleware/tfm/tf-m-tests/test/suites/ps/non_secure; ../../../../../../middleware/tfm/tf-m-tests/test/suites/qcbor/non_secure; ../../../../../../middleware/tfm/tf-m-tests/test/suites/platform/non_secure; ../../../../../../middleware/tfm/tf-m-tests; ../../../../../../middleware/tfm/tf-m-tests/test/suites/its; ../../../../../../middleware/tfm/tf-m-tests/test/suites/its/non_secure; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation; ../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/inc; ../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/src; ../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/util; ../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/test; ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/src; ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/inc; ../../../../../../middleware/tfm/tf-m; ../../../../../../middleware/tfm/tf-m-tests/test/suites/crypto; ../../../../../../middleware/tfm/tf-m-tests/test/suites/crypto/non_secure; ../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest; ../../../../../../devices/LPC55S06/utilities/str; ../../../../../../devices/LPC55S06/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../CMSIS/Core/Include; ../../../../../../middleware/tfm/tf-m-tests/app; ../../../../../../middleware/tfm/tf-m-tests/log; ../../../../../../CMSIS/RTOS2/RTX/Source; ../../../../../../CMSIS/RTOS2/RTX/Include; ../../../../../../CMSIS/RTOS2/RTX/Config; ../../../../../../CMSIS/RTOS2/Include; ../../../../../../middleware/tfm/tf-m-tests/test/suites/attestation/non_secure; ../../../../../../middleware/tfm/tf-m-tests/test/suites/attestation
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  prebuild: "$TOOLKIT_DIR$/bin/iccarm.exe" -I../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/lpcxpresso55s06/partition ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/iar/tfm_common_ns.icf --silent --preprocess=ns ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/iar/tfm_common_ns_pre.icf
  ILINK.IlinkOutputFile: tfm_regression_ns.out
  ILINK.IlinkIcfFile: ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/iar/tfm_common_ns_pre.icf
  ILINK.IlinkAdditionalLibs: ../../tfm_regression_s/iar/debug/tfm_regression_s_import_lib.o; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/os/rtx/IAR/RTX_V8MMFN.a; ../../../../../../CMSIS/RTOS2/RTX/Library/IAR/RTX_V8MMFN.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_LPC55S06JBD64; TFM_LVL=2; ITS_MAX_ASSET_SIZE=512; PS_MAX_ASSET_SIZE=512; __DOMAIN_NS=1; DOMAIN_NS=1; TFM_CRYPTO_TEST_ALG_CBC; TFM_CRYPTO_TEST_ALG_CCM; TFM_CRYPTO_TEST_ALG_CFB; TFM_CRYPTO_TEST_ALG_CTR; TFM_CRYPTO_TEST_ALG_GCM; TFM_CRYPTO_TEST_ALG_SHA_512; TFM_CRYPTO_TEST_HKDF; TFM_PARTITION_PLATFORM; TFM_PARTITION_PROTECTED_STORAGE; TFM_PARTITION_INTERNAL_TRUSTED_STORAGE; TFM_PARTITION_CRYPTO; TFM_PARTITION_INITIAL_ATTESTATION; OS_DYNAMIC_MEM_SIZE=8192; TEST_FRAMEWORK_NS; SERVICES_TEST_NS; ENABLE_INTERNAL_TRUSTED_STORAGE_SERVICE_TESTS; ENABLE_ATTESTATION_SERVICE_TESTS; T_COSE_USE_PSA_CRYPTO; ENABLE_CRYPTO_SERVICE_TESTS; TFM_PSA_API; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG
  ILINK.IlinkAdditionalLibs: ../../tfm_regression_s/iar/release/tfm_regression_s_import_lib.o; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/os/rtx/IAR/RTX_V8MMFN.a; ../../../../../../CMSIS/RTOS2/RTX/Library/IAR/RTX_V8MMFN.a
  group startup
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/lpcxpresso55s06/Device/Source/iar/: startup_LPC55S06_ns.s
  group device
    ../../../../../../devices/LPC55S06/: system_LPC55S06.c system_LPC55S06.h fsl_device_registers.h LPC55S06.h LPC55S06_features.h system_LPC55S06.c system_LPC55S06.h
  group board
    ../: pin_mux.c pin_mux.h hardware_init.c app.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/LPC55S06/drivers/: fsl_ctimer.h fsl_ctimer.c fsl_iocon.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_gpio.h fsl_gpio.c
  group tf-m/platform/include
    ../../../../../../middleware/tfm/tf-m/platform/include/: tfm_plat_crypto_keys.h tfm_hal_device_header.h tfm_plat_boot_seed.h tfm_plat_device_id.h tfm_plat_defs.h tfm_plat_ns.h region.h tfm_plat_test.h
  group tf-m/platform/ext/common
    ../../../../../../middleware/tfm/tf-m/platform/ext/common/: uart_stdout.h uart_stdout.c
  group tf-m/platform/ext/driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/driver/: Driver_USART.h Driver_Common.h
  group tf-m/platform/ext/target/nxp/lpcxpresso55s06
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/lpcxpresso55s06/: target_cfg.h tfm_peripherals_def.h
  group tf-m/platform/ext/target/nxp/lpcxpresso55s06/Device/Include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/lpcxpresso55s06/Device/Include/: cmsis.h device_definition.h platform_irq.h platform_regs.h platform_base_address.h
  group tf-m/platform/ext/target/nxp/lpcxpresso55s06/Device/Config
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/lpcxpresso55s06/Device/Config/: device_cfg.h
  group tf-m/platform/ext/target/nxp/lpcxpresso55s06/partition
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/lpcxpresso55s06/partition/: region_defs.h flash_layout.h
  group tf-m/platform/ext/target/nxp/common
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/: plat_attestation_key.c plat_test.c
  group tf-m/platform/ext/target/nxp/common/CMSIS_Driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/CMSIS_Driver/: Driver_USART.c
  group tf-m/interface/src
    ../../../../../../middleware/tfm/tf-m/interface/src/: tfm_ns_interface.c tfm_crypto_ipc_api.c tfm_initial_attestation_ipc_api.c tfm_its_ipc_api.c tfm_ps_ipc_api.c tfm_platform_ipc_api.c tfm_psa_ns_api.c
  group tf-m/interface/include
    ../../../../../../middleware/tfm/tf-m/interface/include/: tfm_veneers.h tfm_crypto_defs.h tfm_its_defs.h tfm_ps_defs.h tfm_api.h tfm_ns_interface.h tfm_ns_svc.h tfm_nspm_api.h tfm_nspm_svc_handler.h tfm_platform_api.h
  group tf-m/interface/include/os_wrapper
    ../../../../../../middleware/tfm/tf-m/interface/include/os_wrapper/: common.h msg_queue.h mutex.h semaphore.h thread.h
  group tf-m/interface/include/psa
    ../../../../../../middleware/tfm/tf-m/interface/include/psa/: client.h crypto.h crypto_client_struct.h crypto_extra.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h error.h initial_attestation.h internal_trusted_storage.h lifecycle.h protected_storage.h service.h storage_common.h crypto_compat.h
  group tf-m/interface/include/psa_manifest
    ../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest/: sid.h
  group tf-m/secure_fw/spm/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/: tfm_arch.h tfm_arch_v8m.h utilities.h tfm_boot_status.h tfm_memory_utils.h
  group tf-m/secure_fw/include/tfm
    ../../../../../../middleware/tfm/tf-m/secure_fw/include/tfm/: tfm_core_svc.h
  group tf-m/secure_fw/partitions/initial_attestation
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation/: attest.h attest_token.h attest_asymmetric_key.c attest_key.h attest_eat_defines.h
  group tf-m/lib/ext/qcbor/inc
    ../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/inc/: qcbor.h q_useful_buf.h UsefulBuf.h
  group tf-m/lib/ext/qcbor/src
    ../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/src/: ieee754.c ieee754.h qcbor_decode.c qcbor_encode.c UsefulBuf.c
  group tf-m/lib/ext/qcbor/util
    ../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/util/: qcbor_util.c qcbor_util.h
  group tf-m/lib/ext/qcbor/test
    ../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/test/: half_to_double_from_rfc7049.c half_to_double_from_rfc7049.h qcbor_encode_tests.c qcbor_encode_tests.h not_well_formed_cbor.h qcbor_decode_tests.c qcbor_decode_tests.h float_tests.c float_tests.h run_tests.c run_tests.h UsefulBuf_Tests.c UsefulBuf_Tests.h
  group tf-m/lib/ext/t_cose/src
    ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/src/: t_cose_crypto.h t_cose_parameters.c t_cose_parameters.h t_cose_sign1_sign.c t_cose_standard_constants.h t_cose_util.c t_cose_util.h t_cose_sign1_verify.c
  group tf-m/lib/ext/t_cose/crypto_adapters
    ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/crypto_adapters/: t_cose_psa_crypto.c
  group tf-m/lib/ext/t_cose/inc
    ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/inc/: t_cose_common.h q_useful_buf.h t_cose_sign1_sign.h t_cose_sign1_verify.h
  group tf-m-tests/app
    ../../../../../../middleware/tfm/tf-m-tests/app/: tfm_integ_test.c os_wrapper_cmsis_rtos_v2.c tfm_integ_test.h main_ns.c psa_api_test.c psa_api_test.h tfm_log.h
  group tf-m-tests/test/framework
    ../../../../../../middleware/tfm/tf-m-tests/test/framework/: non_secure_suites.c test_framework.c test_framework.h test_framework_error_codes.h test_framework_integ_test.h test_framework_integ_test_helper.c test_framework_integ_test_helper.h test_framework_helpers.c test_framework_helpers.h
  group tf-m-tests/test/suites/core/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/core/non_secure/: core_ns_tests.h
  group tf-m-tests/test/suites/ipc/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/ipc/non_secure/: ipc_ns_tests.h
  group tf-m-tests/test/suites/audit/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/audit/non_secure/: audit_ns_tests.h
  group tf-m-tests/test/suites/t_cose/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/t_cose/non_secure/: t_cose_ns_tests.h
  group tf-m-tests/test/suites/multi_core/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/multi_core/non_secure/: multi_core_ns_test.h
  group tf-m-tests/test/suites/ps/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/ps/non_secure/: ps_ns_tests.h
  group tf-m-tests/test/suites/qcbor/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/qcbor/non_secure/: qcbor_ns_tests.h
  group tf-m-tests/test/suites/platform/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/platform/non_secure/: platform_ns_tests.h
  group tf-m-tests/test/suites/its
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/its/: its_tests_common.c its_tests_common.h
  group tf-m-tests/test/suites/its/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/its/non_secure/: psa_its_ns_interface_testsuite.c its_ns_tests.h
  group tf-m-tests/test/suites/crypto
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/crypto/: crypto_tests_common.c crypto_tests_common.h
  group tf-m-tests/test/suites/crypto/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/crypto/non_secure/: crypto_ns_interface_testsuite.c crypto_ns_tests.h
  group tf-m-tests/test/suites/attestation
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/attestation/: attest_public_key.c attest_public_key.h attest_token_decode_asymmetric.c attest_token_decode.h attest_token_decode_common.c attest_token_test.c attest_token_test.h attest_token_test_values.h attest_tests_common.h
  group tf-m-tests/test/suites/attestation/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/suites/attestation/non_secure/: attest_asymmetric_ns_interface_testsuite.c attest_ns_tests.h
  group tf-m-tests/log
    ../../../../../../middleware/tfm/tf-m-tests/log/: tfm_log_raw.c tfm_log_raw.h
  group utilities
    ../../../../../../devices/LPC55S06/utilities/: fsl_assert.c
    ../../../../../../devices/LPC55S06/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/LPC55S06/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group CMSIS/RTOS2/RTX/Source
    ../../../../../../CMSIS/RTOS2/RTX/Source/: rtx_core_c.h rtx_core_ca.h rtx_core_cm.h rtx_lib.h rtx_lib.c
  group CMSIS/RTOS2/RTX/Include
    ../../../../../../CMSIS/RTOS2/RTX/Include/: rtx_evr.h rtx_os.h
  group CMSIS/RTOS2/RTX/Config
    ../../../../../../CMSIS/RTOS2/RTX/Config/: RTX_Config.c RTX_Config.h
  group CMSIS/RTOS2/Include
    ../../../../../../CMSIS/RTOS2/Include/: os_tick.h cmsis_os2.h
