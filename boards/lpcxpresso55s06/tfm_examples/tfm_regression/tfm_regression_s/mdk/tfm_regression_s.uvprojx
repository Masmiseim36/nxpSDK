# Keil uVision project tfm_regression_s.uvprojx, settings and files
target tfm_regression_s debug (6140001::V6.14.1::ARMCLANG)
  device: LPC55S06JBD64 NXP
  pack: NXP.LPC55S06_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tfm_regression_s.out
  BeforeMake: $KARM/ARMCLANG/bin/armclang -DTFM_LVL=2 -DTFM_PSA_API -DTFM_PARTITION_CRYPTO -DTFM_PARTITION_INITIAL_ATTESTATION -DTFM_PARTITION_INTERNAL_TRUSTED_STORAGE -DTFM_PARTITION_PROTECTED_STORAGE -DTFM_PARTITION_PLATFORM --target=arm-arm-none-eabi -march=armv8-m.main -E -P -xc -I"$P../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/lpcxpresso55s06/partition" "$P../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/armclang/tfm_common_s.sct" -o "$P../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/armclang/tfm_common_s_pre.sct"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_LPC55S06JBD64, MBEDTLS_MCUX_CASPER_ECC=0, MBEDTLS_MCUX_CASPER_PKHA=0, TFM_CRYPTO_IOVEC_BUFFER_SIZE=2048, PLAT_HAS_BOOT_SEED, TFM_LVL=2, TFM_SPM_LOG_LEVEL=TFM_SPM_LOG_LEVEL_INFO, TFM_PARTITION_LOG_LEVEL=TFM_PARTITION_LOG_LEVEL_INFO, TFM_CRYPTO_ENGINE_BUF_SIZE=9400, ITS_MAX_ASSET_SIZE=512, ITS_NUM_ASSETS=5, PS_MAX_ASSET_SIZE=512, PS_NUM_ASSETS=5, PS_CREATE_FLASH_LAYOUT, PS_WIPE_ALL, ITS_CREATE_FLASH_LAYOUT, ITS_WIPE_ALL, DAUTH_CHIP_DEFAULT, MBEDTLS_CONFIG_FILE='\"lpcxpresso55s06_mbedcrypto_config.h\"', INCLUDE_TEST_CODE_AND_KEY_ID, __SEMIHOST_HARDFAULT_DISABLE, TFM_CRYPTO_TEST_ALG_CBC, TFM_CRYPTO_TEST_ALG_CCM, TFM_CRYPTO_TEST_ALG_CFB, TFM_CRYPTO_TEST_ALG_CTR, TFM_CRYPTO_TEST_ALG_GCM, TFM_CRYPTO_TEST_ALG_SHA_512, TFM_CRYPTO_TEST_HKDF, TFM_PARTITION_INTERNAL_TRUSTED_STORAGE, TFM_PARTITION_CRYPTO, TFM_PARTITION_INITIAL_ATTESTATION, T_COSE_USE_PSA_CRYPTO, TFM_PARTITION_PLATFORM, TFM_PSA_API, CONFIG_TFM_ENABLE_MEMORY_PROTECT, SERIAL_PORT_TYPE_UART=1, ENABLE_ATTESTATION_SERVICE_TESTS, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../../devices/LPC55S06;..;../../../../../../devices/LPC55S06/drivers;../../../../../../middleware/tfm/mbed-crypto/include/mbedtls;../../../../../../middleware/tfm/mbed-crypto/include/mbed_psa;../../../../../../middleware/tfm/mbed-crypto/library;../../../../../../middleware/tfm/mbed-crypto/port;../../../../../../middleware/tfm/mbed-crypto/include;../../../../../../middleware/tfm/tf-m;../../../../../../middleware/tfm/tf-m/bl2/include;../../../../../../middleware/tfm/tf-m/bl2/ext/mcuboot/bootutil/include/bootutil;../../../../../../middleware/tfm/tf-m/platform/ext;../../../../../../middleware/tfm/tf-m/platform/ext/common;../../../../../../middleware/tfm/tf-m/platform/ext/driver;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Native_Driver;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/lpcxpresso55s06;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/lpcxpresso55s06/Device/Config;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/lpcxpresso55s06/Device/Include;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/lpcxpresso55s06/partition;../../../../../../middleware/tfm/tf-m/platform/include;../../../../../../middleware/tfm/tf-m/interface/include/log;../../../../../../middleware/tfm/tf-m/interface/include/psa;../../../../../../middleware/tfm/tf-m/interface/include;../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest;../../../../../../middleware/tfm/tf-m/secure_fw/include;../../../../../../middleware/tfm/tf-m/secure_fw/include/tfm;../../../../../../middleware/tfm/tf-m/secure_fw/spm;../../../../../../middleware/tfm/tf-m/secure_fw/spm/include;../../../../../../middleware/tfm/tf-m/secure_fw/spm/cmsis_func/include;../../../../../../middleware/tfm/tf-m/secure_fw/partitions;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/psa_manifest;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/audit_logging/psa_manifest;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/psa_manifest;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform/psa_manifest;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation/psa_manifest;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/psa_manifest;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/lib/sprt/include;../../../../../../middleware/tfm/tf-m/lib/fih/inc;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/flash;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/flash_fs;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation;../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/src;../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/inc;../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/src;../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/inc;../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/util;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform;../../../../../../middleware/tfm/tf-m/interface/include/ext;../../../../../../middleware/tfm/tf-m/secure_fw/spm/cmsis_psa;../../../../../../devices/LPC55S06/utilities/str;../../../../../../devices/LPC55S06/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../CMSIS/Core/Include
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL, DEBUG
  asm include: ../../../../../../middleware/tfm/tf-m/platform/include
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x38000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x10000
  memory RVCT7: RAM 0x20010000 size 0x4000
  memory RVCT8: RAM 0x30010000 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x38000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/armclang/tfm_common_s_pre.sct
  link misc: --remove --entry=Reset_Handler --import-cmse-lib-out="./debug/tfm_regression_s_CMSE_lib.o"
  group startup
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/lpcxpresso55s06/Device/Source/armclang/: startup_LPC55S06_s.S
  group device
    ../../../../../../devices/LPC55S06/: system_LPC55S06.c system_LPC55S06.h fsl_device_registers.h LPC55S06.h LPC55S06_features.h system_LPC55S06.c system_LPC55S06.h
  group board
    ../: pin_mux.c pin_mux.h hardware_init.c app.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/LPC55S06/drivers/: fsl_casper.h fsl_casper.c fsl_hashcrypt.h fsl_hashcrypt.c fsl_rng.h fsl_rng.c fsl_ctimer.h fsl_ctimer.c fsl_iocon.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_gpio.h fsl_gpio.c fsl_iap.h fsl_iap.c fsl_iap_ffr.h fsl_iap_kbp.h fsl_iap_skboot_authenticate.h
  group tf-m/platform/ext/target/nxp/common/CMSIS_Driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/CMSIS_Driver/: Driver_Flash_iap1.c Driver_USART.c
  group mbed-crypto/include/mbedtls
    ../../../../../../middleware/tfm/mbed-crypto/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h config_psa.h ctr_drbg.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h psa_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h threading.h timing.h version.h xtea.h
  group mbed-crypto/include/mbed_psa
    ../../../../../../middleware/tfm/mbed-crypto/include/mbed_psa/: crypto.h crypto_accel_driver.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_entropy_driver.h crypto_extra.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group mbed-crypto/library
    ../../../../../../middleware/tfm/mbed-crypto/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cmac.c common.h ctr_drbg.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_se.c psa_crypto_se.h psa_crypto_service_integration.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c threading.c timing.c version.c version_features.c xtea.c
  group mbed-crypto/port
    ../../../../../../middleware/tfm/mbed-crypto/port/: aes_alt.h mbedcrypto_mcux_casper.c mbedcrypto_mcux_hashcrypt.c mbedcrypto_mcux_config.h mbedcrypto_mcux_entropy.c mbedcrypto_mcux_hw_config.h sha1_alt.h sha256_alt.h
  group tf-m/lib/fih/inc
    ../../../../../../middleware/tfm/tf-m/lib/fih/inc/: fih.h
  group tf-m/lib/fih/src
    ../../../../../../middleware/tfm/tf-m/lib/fih/src/: fih.c
  group tf-m/platform/ext/common
    ../../../../../../middleware/tfm/tf-m/platform/ext/common/: tfm_hal_isolation_mpu_v8m.c tfm_hal_its.c tfm_hal_memory_symbols.c tfm_hal_ps.c tfm_hal_sp_logdev.h tfm_hal_sp_logdev_periph.c tfm_hal_spm_logdev.h tfm_hal_spm_logdev_peripheral.c tfm_platform.c uart_stdout.c uart_stdout.h
  group tf-m/platform/ext/driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/driver/: Driver_Common.h Driver_Flash.h Driver_MPC.h Driver_PPC.h Driver_USART.h
  group tf-m/platform/ext/target/nxp/common
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/: plat_attest_hal.c mini_mbedcrypto_config.h maxi_mbedcrypto_config.h spm_hal.c tfm_hal_isolation.c plat_attestation_key.c plat_huk_key.c plat_test.c
  group tf-m/platform/ext/common/template
    ../../../../../../middleware/tfm/tf-m/platform/ext/common/template/: nv_counters.c
  group tf-m/platform/ext/target/nxp/common/Native_Driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Native_Driver/: mpu_armv8m_drv.c mpu_armv8m_drv.h
  group tf-m/platform/ext/target/nxp/common/services/src
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/services/src/: tfm_platform_system.c
  group tf-m/platform/ext/target/nxp/lpcxpresso55s06
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/lpcxpresso55s06/: target_cfg.c target_cfg.h tfm_peripherals_def.h lpcxpresso55s06_mbedcrypto_config.h
  group tf-m/platform/ext/target/nxp/lpcxpresso55s06/Device/Config
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/lpcxpresso55s06/Device/Config/: device_cfg.h
  group tf-m/platform/ext/target/nxp/lpcxpresso55s06/Device/Include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/lpcxpresso55s06/Device/Include/: cmsis.h device_definition.h platform_description.h platform_irq.h platform_regs.h platform_base_address.h
  group tf-m/platform/ext/target/nxp/lpcxpresso55s06/partition
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/lpcxpresso55s06/partition/: flash_layout.h region_defs.h
  group tf-m/platform/include
    ../../../../../../middleware/tfm/tf-m/platform/include/: region.h tfm_attest_hal.h tfm_hal_defs.h tfm_hal_device_header.h tfm_hal_isolation.h tfm_hal_its.h tfm_hal_memory_symbols.h tfm_hal_platform.h tfm_hal_ps.h tfm_plat_boot_seed.h tfm_plat_config.h tfm_plat_crypto_keys.h tfm_plat_defs.h tfm_plat_device_id.h tfm_plat_ns.h tfm_plat_nv_counters.h tfm_plat_test.h tfm_platform_system.h tfm_spm_hal.h
  group tf-m/interface/include/log
    ../../../../../../middleware/tfm/tf-m/interface/include/log/: tfm_log.h tfm_log_raw.h
  group tf-m/interface/include/psa
    ../../../../../../middleware/tfm/tf-m/interface/include/psa/: client.h crypto.h crypto_client_struct.h crypto_compat.h crypto_extra.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h error.h initial_attestation.h internal_trusted_storage.h lifecycle.h protected_storage.h service.h storage_common.h
  group tf-m/interface/include
    ../../../../../../middleware/tfm/tf-m/interface/include/: psa_audit_defs.h tfm_api.h tfm_crypto_defs.h tfm_platform_api.h tfm_veneers.h tfm_its_defs.h
  group tf-m/interface/include/psa_manifest
    ../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest/: pid.h sid.h
  group tf-m/interface/src/log
    ../../../../../../middleware/tfm/tf-m/interface/src/log/: tfm_log_raw.c
  group tf-m/secure_fw/spm/include/ffm
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/ffm/: spm_error_base.h
  group tf-m/secure_fw/spm/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/: bitops.h exception_info.h lists.h spm_partition_defs.h tfm_assert.h tfm_boot_status.h tfm_core_mem_check.h tfm_core_trustzone.h tfm_core_utils.h tfm_irq_list.h tfm_nspm.h tfm_platform_core_api.h tfm_secure_api.h tfm_spm_log.h tfm_version.h utilities.h tfm_arch.h tfm_arch_v8m.h tfm_memory_utils.h
  group tf-m/secure_fw/spm/ffm
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/ffm/: psa_client_service_apis.c psa_client_service_apis.h spm_log.c spm_psa_client_call.c spm_psa_client_call.h tfm_boot_data.c tfm_boot_data.h tfm_core_mem_check.c tfm_core_utils.c utilities.c
  group tf-m/secure_fw/spm/cmsis_psa
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/cmsis_psa/: tfm_wait.h exception_info.c internal_errors.h main.c tfm_pools.h tfm_rpc.h tfm_svcalls.h tfm_thread.h tfm_wait.h spm_ipc.c spm_ipc.h tfm_core_svcalls_ipc.c tfm_nspm_ipc.c tfm_pools.c tfm_psa_api_veneers.c tfm_secure_irq_handlers_ipc.inc tfm_spm_db_ipc.inc tfm_thread.c tfm_wait.c
  group tf-m/secure_fw/spm/cmsis_func/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/cmsis_func/include/: spm_func.h
  group tf-m/secure_fw/include/tfm
    ../../../../../../middleware/tfm/tf-m/secure_fw/include/tfm/: tfm_core_svc.h tfm_spm_services.h
  group tf-m/secure_fw/partitions
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/: tfm_service_list.inc
  group tf-m/secure_fw/partitions/lib/sprt/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/lib/sprt/include/: service_api.h tfm_sp_log.h
  group tf-m/secure_fw/partitions/lib/sprt
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/lib/sprt/: service_api.c sprt_partition_metadata_indicator.c tfm_sp_log_raw.c
  group tf-m/secure_fw/partitions/internal_trusted_storage/auto_generated
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/auto_generated/: intermedia_tfm_internal_trusted_storage.c
  group tf-m/secure_fw/partitions/internal_trusted_storage
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/: its_utils.c its_utils.h tfm_internal_trusted_storage.c tfm_internal_trusted_storage.h tfm_its_req_mngr.h tfm_its_req_mngr.c tfm_its_secure_api.c
  group tf-m/secure_fw/partitions/internal_trusted_storage/psa_manifest
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/psa_manifest/: tfm_internal_trusted_storage.h
  group tf-m/secure_fw/partitions/internal_trusted_storage/flash
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/flash/: its_flash.c its_flash.h its_flash_nand.c its_flash_nand.h its_flash_nor.c its_flash_nor.h its_flash_ram.c its_flash_ram.h
  group tf-m/secure_fw/partitions/internal_trusted_storage/flash_fs
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/flash_fs/: its_flash_fs.c its_flash_fs.h its_flash_fs_dblock.c its_flash_fs_dblock.h its_flash_fs_mblock.c its_flash_fs_mblock.h
  group tf-m/secure_fw/partitions/protected_storage
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/: ps_object_defs.h
  group tf-m/secure_fw/partitions/crypto/auto_generated
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/auto_generated/: intermedia_tfm_crypto.c
  group tf-m/secure_fw/partitions/crypto
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/: crypto_aead.c crypto_alloc.c crypto_asymmetric.c crypto_cipher.c crypto_hash.c crypto_init.c crypto_key.c crypto_key_derivation.c crypto_mac.c crypto_spe.h tfm_crypto_api.h tfm_crypto_private.h tfm_crypto_secure_api.c tfm_mbedcrypto_include.h
  group tf-m/secure_fw/partitions/crypto/psa_manifest
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/psa_manifest/: tfm_crypto.h
  group tf-m/secure_fw/partitions/initial_attestation/auto_generated
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation/auto_generated/: intermedia_tfm_initial_attestation.c
  group tf-m/secure_fw/partitions/initial_attestation
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation/: attest.h attest_asymmetric_key.c attest_core.c attest_eat_defines.h attest_key.h attest_token.h attest_token_encode.c tfm_attest.c tfm_attest_req_mngr.c tfm_attest_secure_api.c
  group tf-m/secure_fw/partitions/initial_attestation/psa_manifest
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation/psa_manifest/: tfm_initial_attestation.h
  group tf-m/lib/ext/t_cose/crypto_adapters
    ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/crypto_adapters/: t_cose_psa_crypto.c
  group tf-m/lib/ext/t_cose/src
    ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/src/: t_cose_crypto.h t_cose_parameters.c t_cose_parameters.h t_cose_sign1_sign.c t_cose_standard_constants.h t_cose_util.c t_cose_util.h t_cose_sign1_verify.c
  group tf-m/lib/ext/t_cose/inc
    ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/inc/: t_cose_common.h q_useful_buf.h t_cose_sign1_sign.h t_cose_sign1_verify.h
  group tf-m/lib/ext/qcbor/src
    ../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/src/: ieee754.c ieee754.h qcbor_decode.c qcbor_encode.c UsefulBuf.c
  group tf-m/lib/ext/qcbor/inc
    ../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/inc/: qcbor.h q_useful_buf.h UsefulBuf.h
  group tf-m/lib/ext/qcbor/util
    ../../../../../../middleware/tfm/tf-m/lib/ext/qcbor/util/: qcbor_util.c qcbor_util.h
  group tf-m/secure_fw/partitions/platform/auto_generated
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform/auto_generated/: intermedia_tfm_platform.c
  group tf-m/secure_fw/partitions/platform
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform/: platform_sp.c platform_sp.h tfm_platform_secure_api.c
  group tf-m/secure_fw/partitions/platform/psa_manifest
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform/psa_manifest/: tfm_platform.h
  group tf-m/interface/include/ext
    ../../../../../../middleware/tfm/tf-m/interface/include/ext/: tz_context.h
  group tf-m/secure_fw/spm/cmsis_psa/arch
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/cmsis_psa/arch/: tfm_arch.c tfm_arch_v8m_main.c
  group tf-m/interface/src/psa
    ../../../../../../middleware/tfm/tf-m/interface/src/psa/: psa_client.c psa_service.c psa_lifecycle.c
  group utilities
    ../../../../../../devices/LPC55S06/utilities/: fsl_assert.c
    ../../../../../../devices/LPC55S06/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/LPC55S06/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target tfm_regression_s release (6130001::V6.13.1::.\ARMCLANG)
  device: LPC55S06JBD64 NXP
  pack: NXP.LPC55S16_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tfm_regression_s.out
  BeforeMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_LPC55S06JBD64, MBEDTLS_MCUX_CASPER_ECC=0, MBEDTLS_MCUX_CASPER_PKHA=0, TFM_CRYPTO_IOVEC_BUFFER_SIZE=2048, PLAT_HAS_BOOT_SEED, TFM_LVL=2, TFM_SPM_LOG_LEVEL=TFM_SPM_LOG_LEVEL_INFO, TFM_PARTITION_LOG_LEVEL=TFM_PARTITION_LOG_LEVEL_INFO, TFM_CRYPTO_ENGINE_BUF_SIZE=9400, ITS_MAX_ASSET_SIZE=512, ITS_NUM_ASSETS=5, PS_MAX_ASSET_SIZE=512, PS_NUM_ASSETS=5, PS_CREATE_FLASH_LAYOUT, PS_WIPE_ALL, ITS_CREATE_FLASH_LAYOUT, ITS_WIPE_ALL, DAUTH_CHIP_DEFAULT, MBEDTLS_CONFIG_FILE='\"lpcxpresso55s06_mbedcrypto_config.h\"', INCLUDE_TEST_CODE_AND_KEY_ID, __SEMIHOST_HARDFAULT_DISABLE, TFM_CRYPTO_TEST_ALG_CBC, TFM_CRYPTO_TEST_ALG_CCM, TFM_CRYPTO_TEST_ALG_CFB, TFM_CRYPTO_TEST_ALG_CTR, TFM_CRYPTO_TEST_ALG_GCM, TFM_CRYPTO_TEST_ALG_SHA_512, TFM_CRYPTO_TEST_HKDF, TFM_PARTITION_INTERNAL_TRUSTED_STORAGE, TFM_PARTITION_CRYPTO, TFM_PARTITION_INITIAL_ATTESTATION, T_COSE_USE_PSA_CRYPTO, TFM_PARTITION_PLATFORM, TFM_PSA_API, CONFIG_TFM_ENABLE_MEMORY_PROTECT, SERIAL_PORT_TYPE_UART=1, ENABLE_ATTESTATION_SERVICE_TESTS, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL, NDEBUG
  asm include: ../../../../../../middleware/tfm/tf-m/platform/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x20040000 size 0x4000
  memory RVCT7: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: as above
  link misc: --remove --entry=Reset_Handler --import-cmse-lib-out="./release/tfm_regression_s_CMSE_lib.o"
