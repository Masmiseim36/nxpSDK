# Keil uVision project aws_greengrass_discovery_wifi.uvprojx, settings and files
target aws_greengrass_discovery_wifi debug (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: aws_greengrass_discovery_wifi.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_LPC55S69JBD100_cm33_core0, USE_RTOS=1, MBEDTLS_CONFIG_FILE='\"aws_mbedtls_config.h\"', A_LITTLE_ENDIAN, SDK_DEBUGCONSOLE_UART, FSL_RTOS_FREE_RTOS, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM33_NTZ/non_secure;..;../config_files;../../../../cm33_core0;../../../../../src/aws_examples/common;../..;../../../..;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/LPC55S69;../../../../../../rtos/freertos/demos/include;../../../../../../rtos/freertos/demos/network_manager;../../../../../../rtos/freertos/demos/dev_mode_key_provisioning/include;../../../../../../rtos/freertos/libraries/abstractions/wifi/include;../../../../../../rtos/freertos/libraries/freertos_plus/aws/greengrass/include;../../../../../../rtos/freertos/libraries/freertos_plus/aws/greengrass/src;../../../../../../rtos/freertos/freertos_kernel/include;../../../../../../rtos/freertos/libraries/abstractions/platform/freertos/include;../../../../../../rtos/freertos/libraries/abstractions/platform/include;../../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/include;../../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/src;../../../../../../rtos/freertos/libraries/c_sdk/standard/common/include;../../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/private;../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/include;../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/src;../../../../../../rtos/freertos/libraries/c_sdk/standard/serializer/include;../../../../../../rtos/freertos/libraries/abstractions/secure_sockets/include;../../../../../../rtos/freertos/libraries/freertos_plus/standard/crypto/include;../../../../../../rtos/freertos/libraries/freertos_plus/standard/pkcs11/include;../../../../../../rtos/freertos/libraries/freertos_plus/standard/utils/include;../../../../../../rtos/freertos/libraries/freertos_plus/standard/tls/include;../../../../../../rtos/freertos/libraries/abstractions/pkcs11/include;../../../../../../rtos/freertos/libraries/abstractions/pkcs11/mbedtls;../../../../../../rtos/freertos/libraries/3rdparty/pkcs11;../../../../../../rtos/freertos/libraries/3rdparty/jsmn;../../../../../../middleware/mbedtls/include;../../../../../../middleware/mbedtls/port/ksdk;../../../../../../middleware/wifi_qca/port/boards/lpcxpresso55s69/freertos/gt202;../../../../../../middleware/wifi_qca/port/boards/lpcxpresso55s69/freertos/wifi10click;../../../../../../middleware/wifi_qca/port/boards/lpcxpresso55s69/freertos/silex2401;../../../../../../devices/LPC55S69/drivers;../../../../../../middleware/mflash/lpc55xxx;../../../../../../middleware/wifi_qca;../../../../../../middleware/wifi_qca/include;../../../../../../middleware/wifi_qca/include/AR6002;../../../../../../middleware/wifi_qca/include/AR6002/hw2.0/hw;../../../../../../middleware/wifi_qca/include/AR6002/hw4.0/hw;../../../../../../middleware/wifi_qca/custom_src/stack_custom;../../../../../../middleware/wifi_qca/custom_src/include;../../../../../../middleware/wifi_qca/common_src/include;../../../../../../middleware/wifi_qca/common_src/stack_common;../../../../../../middleware/wifi_qca/common_src/hcd;../../../../../../middleware/wifi_qca/common_src/wmi;../../../../../../middleware/wifi_qca/port;../../../../../../devices/LPC55S69/utilities/str;../../../../../../devices/LPC55S69/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../middleware/wifi_qca/port/boards/lpcxpresso55s69/freertos;../../../../../../middleware/wifi_qca/port/env/freertos;../../../../../../middleware/wifi_qca/port/drivers/flexcomm_freertos;../../../../../../devices/LPC55S69/utilities
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  asm include: ../../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM33_NTZ/non_secure;../config_files;../../../..;../..;..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: ../../../../../../devices/LPC55S69/arm/keil_lib_power_cm33_core0.lib --remove --predefine="-D__stack_size__=0x200" --predefine="-D__heap_size__=0x200"
  group freertos-config_files
    ../config_files/: FreeRTOSConfig.h aws_demo_config.h aws_mqtt_config.h aws_secure_sockets_config.h aws_shadow_config.h FreeRTOSIPConfig.h iot_config.h iot_mqtt_agent_config.h iot_pkcs11_config.h aws_iot_network_config.h aws_ggd_config.h aws_wifi_config.h
  group source
    ../config_files/: aws_mbedtls_config.h
    ../: main_wifi.c
  group freertos:config_files
    ../config_files/: aws_bufferpool_config.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group wifi_qca-port-boards-lpcxpresso55s69-freertos-gt202
    ../../../../../../middleware/wifi_qca/port/boards/lpcxpresso55s69/freertos/gt202/: wifi_shield_gt202.h
  group wifi_qca-port-boards-lpcxpresso55s69-freertos-wifi10click
    ../../../../../../middleware/wifi_qca/port/boards/lpcxpresso55s69/freertos/wifi10click/: wifi_shield_wifi10click.h
  group wifi_qca-port-boards-lpcxpresso55s69-freertos-silex2401
    ../../../../../../middleware/wifi_qca/port/boards/lpcxpresso55s69/freertos/silex2401/: wifi_shield_silex2401.h
  group drivers
    ../../../../../../devices/LPC55S69/drivers/: fsl_casper.c fsl_casper.h fsl_hashcrypt.c fsl_hashcrypt.h fsl_rng.c fsl_rng.h fsl_iap.c fsl_iap.h fsl_iap_ffr.h fsl_iap_kbp.h fsl_iap_skboot_authenticate.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_iocon.h fsl_gpio.c fsl_gpio.h fsl_power.c fsl_power.h fsl_spi.c fsl_spi.h fsl_reset.c fsl_reset.h fsl_spi_dma.c fsl_spi_dma.h fsl_dma.c fsl_dma.h fsl_pint.c fsl_pint.h fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h
  group mflash-lpc55xxx
    ../../../../../../middleware/mflash/lpc55xxx/: mflash_drv.c mflash_drv.h mflash_file.c mflash_file.h
  group freertos-freertos_kernel-portable-GCC-ARM_CM33_NTZ-non_secure
    ../../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c portasm.h portmacro.h
  group wifi_qca
    ../../../../../../middleware/wifi_qca/: ChangeLogKSDK.txt atheros_stack_offload.h atheros_wifi.h atheros_wifi_api.h atheros_wifi_internal.h license.txt qcom_api.h
  group wifi_qca-common_src-api_interface
    ../../../../../../middleware/wifi_qca/common_src/api_interface/: api_init.c api_ioctl.c api_txrx.c api_wmi_rx.c
  group wifi_qca-common_src-bmi
    ../../../../../../middleware/wifi_qca/common_src/bmi/: bmi.c
  group wifi_qca-common_src-driver
    ../../../../../../middleware/wifi_qca/common_src/driver/: driver_diag.c driver_init.c driver_main.c driver_netbuf.c driver_txrx.c
  group wifi_qca-common_src-hcd
    ../../../../../../middleware/wifi_qca/common_src/hcd/: hcd_api.h spi_hcd.c
  group wifi_qca-common_src-htc
    ../../../../../../middleware/wifi_qca/common_src/htc/: htc.c
  group wifi_qca-common_src-hw_interface
    ../../../../../../middleware/wifi_qca/common_src/hw_interface/: hw_api.c
  group wifi_qca-common_src-include
    ../../../../../../middleware/wifi_qca/common_src/include/: a_debug.h a_drv.h a_drv_api.h aggr_recv_api.h bmi.h common_api.h dbglog_api.h driver_cxt.h dset.h dset_api.h hif_internal.h htc_api.h ieee80211.h netbuf.h spi_hcd_if.h wlan_api.h wmi_api.h
  group wifi_qca-common_src-qapi
    ../../../../../../middleware/wifi_qca/common_src/qapi/: qcom_api.c qcom_dns.c qcom_legacy.c
  group wifi_qca-common_src-reorder
    ../../../../../../middleware/wifi_qca/common_src/reorder/: rcv_aggr.c
  group wifi_qca-common_src-stack_common
    ../../../../../../middleware/wifi_qca/common_src/stack_common/: api_stack_offload.c common_stack_offload.h
  group wifi_qca-common_src-storerecall
    ../../../../../../middleware/wifi_qca/common_src/storerecall/: dset.c dset_api.c storerecall.c
  group wifi_qca-common_src-util
    ../../../../../../middleware/wifi_qca/common_src/util/: util.c
  group wifi_qca-common_src-wmi
    ../../../../../../middleware/wifi_qca/common_src/wmi/: wmi.c wmi_host.h
  group wifi_qca-custom_src-api_interface
    ../../../../../../middleware/wifi_qca/custom_src/api_interface/: cust_api_init.c cust_api_ioctl.c cust_api_txrx.c cust_api_wmi_rx.c
  group wifi_qca-custom_src-driver
    ../../../../../../middleware/wifi_qca/custom_src/driver/: cust_driver_main.c cust_driver_netbuf.c
  group wifi_qca-custom_src-hw_interface
    ../../../../../../middleware/wifi_qca/custom_src/hw_interface/: cust_spi_hcd.c
  group wifi_qca-custom_src-include
    ../../../../../../middleware/wifi_qca/custom_src/include/: a_config.h a_osapi.h a_types.h cust_netbuf.h custom_wlan_api.h wlan_config.h
  group wifi_qca-custom_src-qapi
    ../../../../../../middleware/wifi_qca/custom_src/qapi/: custom_qcom_api.c
  group wifi_qca-custom_src-stack_custom
    ../../../../../../middleware/wifi_qca/custom_src/stack_custom/: cust_api_stack_offload.c cust_api_stack_txrx.c custom_stack_offload.h qca_structs.h
  group wifi_qca-include-AR6002
    ../../../../../../middleware/wifi_qca/include/AR6002/: AR6K_version.h
  group wifi_qca-include-AR6002-hw2.0-hw
    ../../../../../../middleware/wifi_qca/include/AR6002/hw2.0/hw/: hw20_apb_map.h hw20_gpio_reg.h hw20_mbox_host_reg.h hw20_mbox_reg.h hw20_rtc_reg.h hw20_si_reg.h hw20_uart_reg.h hw20_vmc_reg.h
  group wifi_qca-include-AR6002-hw4.0-hw
    ../../../../../../middleware/wifi_qca/include/AR6002/hw4.0/hw/: hw40_rtc_reg.h hw40_rtc_wlan_reg.h
  group wifi_qca-include
    ../../../../../../middleware/wifi_qca/include/: athdefs.h bmi_msg.h dbglog.h dbglog_id.h htc.h htc_services.h p2p.h pkt_log.h pmu.h targaddrs.h wlan_defs.h wmi.h
  group wifi_qca-port
    ../../../../../../middleware/wifi_qca/port/: wifi_common.h wifi_shield_common.h
  group freertos-vendors-nxp-secure_sockets-wifi_qca
    ../../../../../../rtos/freertos/vendors/nxp/secure_sockets/wifi_qca/: iot_secure_sockets.c
  group freertos-vendors-nxp-wifi-qca_400x
    ../../../../../../rtos/freertos/vendors/nxp/wifi/qca_400x/: iot_wifi.c
  group freertos-demos-demo_runner
    ../../../../../../rtos/freertos/demos/demo_runner/: aws_demo.c iot_demo_freertos.c
  group freertos-demos-include
    ../../../../../../rtos/freertos/demos/include/: aws_clientcredential.h aws_clientcredential_keys.h aws_demo.h aws_iot_demo_network.h aws_ota_codesigner_certificate.h aws_wifi_connect_task.h iot_ble_numericComparison.h iot_config_common.h iot_demo_logging.h iot_demo_runner.h
  group freertos-demos-network_manager
    ../../../../../../rtos/freertos/demos/network_manager/: aws_iot_demo_network.c aws_iot_network_manager.c iot_network_manager_private.h
  group freertos-demos-greengrass_connectivity
    ../../../../../../rtos/freertos/demos/greengrass_connectivity/: aws_greengrass_discovery_demo.c
  group freertos-demos-dev_mode_key_provisioning-include
    ../../../../../../rtos/freertos/demos/dev_mode_key_provisioning/include/: aws_dev_mode_key_provisioning.h
  group freertos-demos-dev_mode_key_provisioning-src
    ../../../../../../rtos/freertos/demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c
  group freertos-libraries-3rdparty-mbedtls-utils
    ../../../../../../rtos/freertos/libraries/3rdparty/mbedtls/utils/: mbedtls_utils.c
  group freertos-libraries-abstractions-wifi-include
    ../../../../../../rtos/freertos/libraries/abstractions/wifi/include/: iot_wifi.h
  group freertos-libraries-freertos_plus-aws-greengrass-include
    ../../../../../../rtos/freertos/libraries/freertos_plus/aws/greengrass/include/: aws_ggd_config_defaults.h aws_greengrass_discovery.h
  group freertos-libraries-freertos_plus-aws-greengrass-src
    ../../../../../../rtos/freertos/libraries/freertos_plus/aws/greengrass/src/: aws_greengrass_discovery.c aws_helper_secure_connect.c aws_helper_secure_connect.h
  group freertos-freertos_kernel
    ../../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos-freertos_kernel-include
    ../../../../../../rtos/freertos/freertos_kernel/include/: FreeRTOS.h StackMacros.h atomic.h croutine.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos-freertos_kernel-portable-MemMang
    ../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos-freertos_kernel-portable
    ../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos-libraries-abstractions-platform-freertos-include-platform
    ../../../../../../rtos/freertos/libraries/abstractions/platform/freertos/include/platform/: iot_network_ble.h iot_network_freertos.h iot_platform_types_freertos.h
  group freertos-libraries-abstractions-platform-freertos
    ../../../../../../rtos/freertos/libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_metrics.c iot_network_freertos.c iot_threads_freertos.c
  group freertos-libraries-abstractions-platform-include-platform
    ../../../../../../rtos/freertos/libraries/abstractions/platform/include/platform/: iot_clock.h iot_metrics.h iot_network.h iot_threads.h
  group freertos-libraries-abstractions-platform-include-types
    ../../../../../../rtos/freertos/libraries/abstractions/platform/include/types/: iot_platform_types.h
  group freertos-libraries-c_sdk-aws-shadow-include
    ../../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/include/: aws_iot_shadow.h aws_shadow.h
  group freertos-libraries-c_sdk-aws-shadow-include-types
    ../../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/include/types/: aws_iot_shadow_types.h
  group freertos-libraries-c_sdk-aws-shadow-src
    ../../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/src/: aws_iot_shadow_api.c aws_iot_shadow_operation.c aws_iot_shadow_parser.c aws_iot_shadow_static_memory.c aws_iot_shadow_subscription.c aws_shadow.c aws_shadow_config_defaults.h
  group freertos-libraries-c_sdk-aws-shadow-src-private
    ../../../../../../rtos/freertos/libraries/c_sdk/aws/shadow/src/private/: aws_iot_shadow_internal.h
  group freertos-libraries-c_sdk-standard-common-include
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/: iot_appversion32.h iot_atomic.h iot_init.h iot_linear_containers.h iot_logging_setup.h iot_logging_task.h iot_taskpool.h
  group freertos-libraries-c_sdk-standard-common-include-private
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/private/: iot_default_root_certificates.h iot_doubly_linked_list.h iot_error.h iot_lib_init.h iot_logging.h iot_static_memory.h iot_taskpool_internal.h
  group freertos-libraries-c_sdk-standard-common-include-types
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/types/: iot_network_types.h iot_taskpool_types.h
  group freertos-libraries-c_sdk-standard-common
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/common/: iot_device_metrics.c iot_init.c iot_static_memory_common.c
  group freertos-libraries-c_sdk-standard-common-logging
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/common/logging/: iot_logging.c iot_logging_task_dynamic_buffers.c
  group freertos-libraries-c_sdk-standard-common-taskpool
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group freertos-libraries-c_sdk-standard-mqtt-include
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/include/: iot_mqtt.h iot_mqtt_agent.h iot_mqtt_agent_config_defaults.h iot_mqtt_config_defaults.h iot_mqtt_lib.h
  group freertos-libraries-c_sdk-standard-mqtt-include-types
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/include/types/: iot_mqtt_types.h
  group freertos-libraries-c_sdk-standard-mqtt-src
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/src/: iot_mqtt_agent.c iot_mqtt_api.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_serialize.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_validate.c
  group freertos-libraries-c_sdk-standard-mqtt-src-private
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/src/private/: iot_mqtt_internal.h
  group freertos-libraries-c_sdk-standard-serializer-include
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/serializer/include/: iot_json_utils.h iot_serializer.h
  group freertos-libraries-c_sdk-standard-serializer-src
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/serializer/src/: iot_json_utils.c iot_serializer_static_memory.c
  group freertos-libraries-c_sdk-standard-serializer-src-json
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/serializer/src/json/: iot_serializer_json_decoder.c iot_serializer_json_encoder.c
  group freertos-libraries-abstractions-secure_sockets-include
    ../../../../../../rtos/freertos/libraries/abstractions/secure_sockets/include/: iot_secure_sockets.h iot_secure_sockets_config_defaults.h iot_secure_sockets_wrapper_metrics.h
  group freertos-libraries-freertos_plus-standard-crypto-include
    ../../../../../../rtos/freertos/libraries/freertos_plus/standard/crypto/include/: iot_crypto.h
  group freertos-libraries-freertos_plus-standard-crypto-src
    ../../../../../../rtos/freertos/libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group freertos-libraries-freertos_plus-standard-pkcs11-include
    ../../../../../../rtos/freertos/libraries/freertos_plus/standard/pkcs11/include/: iot_pkcs11.h
  group freertos-libraries-freertos_plus-standard-pkcs11-src
    ../../../../../../rtos/freertos/libraries/freertos_plus/standard/pkcs11/src/: iot_pkcs11.c
  group freertos-libraries-freertos_plus-standard-utils-include
    ../../../../../../rtos/freertos/libraries/freertos_plus/standard/utils/include/: iot_pki_utils.h iot_system_init.h
  group freertos-libraries-freertos_plus-standard-utils-src
    ../../../../../../rtos/freertos/libraries/freertos_plus/standard/utils/src/: iot_pki_utils.c iot_system_init.c
  group freertos-libraries-freertos_plus-standard-tls-include
    ../../../../../../rtos/freertos/libraries/freertos_plus/standard/tls/include/: iot_tls.h
  group freertos-libraries-freertos_plus-standard-tls-src
    ../../../../../../rtos/freertos/libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group freertos-libraries-abstractions-pkcs11-include
    ../../../../../../rtos/freertos/libraries/abstractions/pkcs11/include/: iot_pkcs11_pal.h
  group freertos-libraries-abstractions-pkcs11-mbedtls
    ../../../../../../rtos/freertos/libraries/abstractions/pkcs11/mbedtls/: iot_pkcs11_mbedtls.c threading_alt.h
  group freertos-libraries-3rdparty-pkcs11
    ../../../../../../rtos/freertos/libraries/3rdparty/pkcs11/: CONTRIBUTING.md LICENSE.md README.md pkcs11.h pkcs11f.h pkcs11t.h
  group freertos-libraries-3rdparty-jsmn
    ../../../../../../rtos/freertos/libraries/3rdparty/jsmn/: jsmn.c jsmn.h
  group freertos-vendors-nxp-pkcs11-common
    ../../../../../../rtos/freertos/vendors/nxp/pkcs11/common/: iot_pkcs11_pal.c
  group mbedtls-include-mbedtls
    ../../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls-library
    ../../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls-port-ksdk
    ../../../../../../middleware/mbedtls/port/ksdk/: aes_alt.c aes_alt.h des_alt.c des_alt.h ecp_alt.c ecp_alt.h ecp_alt_ksdk.c ecp_curves_alt.c ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h
  group device
    ../../../../../../devices/LPC55S69/: LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h fsl_device_registers.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group startup
    ../../../../../../devices/LPC55S69/arm/: startup_LPC55S69_cm33_core0.S
  group utilities
    ../../../../../../devices/LPC55S69/utilities/: fsl_assert.c
    ../../../../../../devices/LPC55S69/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group component-uart
    ../../../../../../components/uart/: uart.h usart_adapter.c
  group component-serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group wifi_qca-port-boards-lpcxpresso55s69-freertos
    ../../../../../../middleware/wifi_qca/port/boards/lpcxpresso55s69/freertos/: wifi_shield.c wifi_shield.h
  group wifi_qca-port-env-freertos
    ../../../../../../middleware/wifi_qca/port/env/freertos/: wifi_env.c wifi_env.h wifi_env_port.h wifi_port.h
  group wifi_qca-port-drivers-flexcomm_freertos
    ../../../../../../middleware/wifi_qca/port/drivers/flexcomm_freertos/: wifi_spi.c wifi_spi.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
target aws_greengrass_discovery_wifi release (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: aws_greengrass_discovery_wifi.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_LPC55S69JBD100_cm33_core0, USE_RTOS=1, MBEDTLS_CONFIG_FILE='\"aws_mbedtls_config.h\"', A_LITTLE_ENDIAN, SDK_DEBUGCONSOLE_UART, FSL_RTOS_FREE_RTOS, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: as above
