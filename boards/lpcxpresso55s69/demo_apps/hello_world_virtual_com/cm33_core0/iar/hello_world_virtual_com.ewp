# IAR project hello_world_virtual_com.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S69_core0 NXP LPC55S69_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_LPC55S69JBD100_cm33_core0; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; SERIAL_PORT_TYPE_USBCDC=1; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; USB_STACK_BM; BOARD_USE_VIRTUALCOM=1; USB_DEVICE_CONFIG_CDC_ACM=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../..; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/LPC55S69; ../../../../../../components/serial_manager; ../../../../../../devices/LPC55S69/drivers; ../../../../../../components/lists; ../../../../../../components/serial_manager/usb_cdc_adapter; ../../../../../../components/osa; ../../../../../../middleware/usb/device; ../../../../../../middleware/usb/include; ../../../../../../devices/LPC55S69/utilities/str; ../../../../../../devices/LPC55S69/utilities/debug_console; ../../../../../../components/uart; ../../../../../../middleware/usb/output/source/device/class; ../../../../../../middleware/usb/output/source/device; ../../../../../../devices/LPC55S69/utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: hello_world_virtual_com.out
  ILINK.IlinkIcfFile: LPC55S69_cm33_core0_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../devices/LPC55S69/iar/iar_lib_power_cm33_core0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_LPC55S69JBD100_cm33_core0; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; SERIAL_PORT_TYPE_USBCDC=1; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; USB_STACK_BM; BOARD_USE_VIRTUALCOM=1; USB_DEVICE_CONFIG_CDC_ACM=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: hello_world.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_usb.c serial_port_usb.h serial_port_uart.c serial_port_uart.h
  group component/serial_manager/usb_cdc_adapter
    ../../../../../../components/serial_manager/usb_cdc_adapter/: usb_device_descriptor.c usb_device_descriptor.h
    ../: usb_device_config.h
  group component/lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group component/uart
    ../../../../../../components/uart/: uart.h usart_adapter.c
  group drivers
    ../../../../../../devices/LPC55S69/drivers/: fsl_common.c fsl_common.h fsl_iocon.h fsl_clock.c fsl_clock.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h
  group usb/device/include
    ../../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group usb/device/source
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h usb_device_dci.h
    ../../../../../../middleware/usb/output/source/device/: usb_device_ch9.c usb_device_ch9.h
  group usb/device/source/lpcip3511
    ../../../../../../middleware/usb/device/: usb_device_lpcip3511.c usb_device_lpcip3511.h
  group usb/device/class
    ../../../../../../middleware/usb/output/source/device/class/: usb_device_class.c usb_device_class.h
  group usb/device/class/cdc
    ../../../../../../middleware/usb/output/source/device/class/: usb_device_cdc_acm.c usb_device_cdc_acm.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group device
    ../../../../../../devices/LPC55S69/: LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h fsl_device_registers.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group startup
    ../../../../../../devices/LPC55S69/iar/: startup_LPC55S69_cm33_core0.s
  group utilities
    ../../../../../../devices/LPC55S69/utilities/: fsl_assert.c
    ../../../../../../devices/LPC55S69/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
