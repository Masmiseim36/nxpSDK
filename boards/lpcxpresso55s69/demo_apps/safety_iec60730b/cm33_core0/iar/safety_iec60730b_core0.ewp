# IAR project safety_iec60730b_core0.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S69_core0 NXP LPC55S69_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_LPC55S69JBD100_cm33_core0=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../middleware/safety_iec60730b/boards/lpcxpresso55s69; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/LPC55S69; ../../../../../../middleware/safety_iec60730b/boards/lpcxpresso55s69/core0; ..; ../../../../../../middleware/safety_iec60730b/dev/lpcxpresso55s69/cm33_core0; ../../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm33/register; ../../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm33/ram; ../../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm33/flash; ../../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm33/stack; ../../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm33/programCounter; ../../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm33; ../../../../../../middleware/safety_iec60730b/safety/v4_0; ../../../../../../middleware/safety_iec60730b/safety/v4_0/compiler; ../../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/wdog; ../../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/dio; ../../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/clock; ../../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/aio; ../../../../../../middleware/safety_iec60730b/boards/common/cm33/startup/cm33; ../../../../../../devices/LPC55S69/iar; ../../../../../../devices/LPC55S69/drivers; ../../../../../../devices/LPC55S69/utilities/str; ../../../../../../devices/LPC55S69/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../middleware/freemaster/src/common; ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial; ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can; ../../../../../../middleware/freemaster/src/platforms/gen32le; ../../../../../../devices/LPC55S69/utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm33; ../../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm33/register; ../../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm33/ram; ../../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm33/flash; ../../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm33/stack; ../../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm33/programCounter; ../../../../../../middleware/safety_iec60730b/safety/v4_0; ../../../../../../middleware/safety_iec60730b/safety/v4_0/compiler; ../../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/wdog; ../../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/dio; ../../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/clock; ../../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/aio
  postbuild: ielftool --fill 0xFF;c_checksumStart-c_checksumEnd+3 --checksum __checksum:2,crc16,0x0;c_checksumStart-c_checksumEnd+3  --verbose "$TARGET_PATH$" "$TARGET_PATH$"
  ILINK.IlinkOutputFile: safety_iec60730b_core0.out
  ILINK.IlinkIcfFile: linker/lpcxpresso55s69_safety.icf
  ILINK.IlinkExtraOptions: --place_holder __checksum,4,.checksum,4; --keep=__checksum
  ILINK.IlinkAdditionalLibs: ../../../../../../middleware/safety_iec60730b/safety/v4_0/IEC60730_CM33_Class_B_IAR_v4_0.a; ../../../../../../devices/LPC55S69/iar/iar_lib_power_cm33_core0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group source
    ../: main.c freemaster_cfg.h safety_test_items.h safety_test_items.c isr.h safety_config.h project_setup_lpcxpresso55s69.h project_setup_lpcxpresso55s69.c safety_cm33_lpc.c safety_cm33_lpc.h
  group doc
    ../: readme.txt
  group board
    ../: pin_mux.c pin_mux.h clock_config.c clock_config.h board.c board.h
  group tools/srec
    ../: srecord-1.64.zip
  group linker
    linker/: lpcxpresso55s69_safety.icf
  group GUI
    ../GUI/: safety.pmp
  group device
    ../../../../../../devices/LPC55S69/: system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h fsl_device_registers.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group cpu
    ../../../../../../middleware/safety_iec60730b/boards/common/cm33/startup/cm33/: start.c startup_iar.c vectors_iar.c vectors_iar.h
  group IEC60730_Class_B
    ../../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm33/: iec60730b_core.h
    ../../../../../../middleware/safety_iec60730b/safety/v4_0/: iec60730b.h
  group IEC60730_Class_B/aio
    ../../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/aio/: iec60730b_aio.h
  group IEC60730_Class_B/clock
    ../../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/clock/: iec60730b_clock.h
  group IEC60730_Class_B/dio
    ../../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/dio/: iec60730b_dio.h iec60730b_dio_ext.h
  group IEC60730_Class_B/watchdog
    ../../../../../../middleware/safety_iec60730b/safety/v4_0/common_test/wdog/: iec60730b_wdog.c iec60730b_wdog.h
  group IEC60730_Class_B/compiler
    ../../../../../../middleware/safety_iec60730b/safety/v4_0/compiler/: asm_mac_common.h
  group IEC60730_Class_B/flash
    ../../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm33/flash/: iec60730b_cm33_flash.h
  group IEC60730_Class_B/programCounter
    ../../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm33/programCounter/: iec60730b_cm33_pc.h iec60730b_cm33_pc_object.S
  group IEC60730_Class_B/ram
    ../../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm33/ram/: iec60730b_cm33_ram.h
  group IEC60730_Class_B/register
    ../../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm33/register/: iec60730b_cm33_reg.h
  group IEC60730_Class_B/stack
    ../../../../../../middleware/safety_iec60730b/safety/v4_0/core_test/cm33/stack/: iec60730b_cm33_stack.h
  group drivers
    ../../../../../../devices/LPC55S69/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_iocon.h fsl_gpio.c fsl_gpio.h fsl_power.c fsl_power.h fsl_lpadc.c fsl_lpadc.h fsl_reset.c fsl_reset.h
  group utilities
    ../../../../../../devices/LPC55S69/utilities/: fsl_assert.c
    ../../../../../../devices/LPC55S69/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group component/uart
    ../../../../../../components/uart/: uart.h usart_adapter.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group freemaster
    ../../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_can.c freemaster_can.h freemaster_defcfg.h freemaster_pdbdm.c freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_serial.c freemaster_serial.h freemaster_sha.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h
  group freemaster/drivers/mcuxsdk/can
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mcan.c freemaster_mcan.h freemaster_mscan.c freemaster_mscan.h
  group freemaster/drivers/mcuxsdk/serial
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_usb.c freemaster_serial_usb.h
  group freemaster/platforms
    ../../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
