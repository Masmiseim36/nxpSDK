# IAR project i2s_dma_record_playback.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S69_core0 NXP LPC55S69_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_LPC55S69JBD100_cm33_core0; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8904_ENABLE; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../dma_playback/cm33_core0; ../../../cm33_core0; ..; ../..; ../../../../..; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../devices/LPC55S69; ../../../../../../../devices/LPC55S69/drivers; ../../../../../../../components/codec/i2c; ../../../../../../../components/i2c; ../../../../../../../components/codec/wm8904; ../../../../../../../components/codec; ../../../../../../../components/codec/port/wm8904; ../../../../../../../devices/LPC55S69/utilities/str; ../../../../../../../devices/LPC55S69/utilities/debug_console; ../../../../../../../components/uart; ../../../../../../../components/serial_manager; ../../../../../../../components/lists; ../../../../../../../devices/LPC55S69/utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: i2s_dma_record_playback.out
  ILINK.IlinkIcfFile: LPC55S69_cm33_core0_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../devices/LPC55S69/iar/iar_lib_power_cm33_core0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_LPC55S69JBD100_cm33_core0; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8904_ENABLE; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: i2s_dma_record_playback.c
    ../../../cm33_core0/: music.h
  group board
    ../../../cm33_core0/: pin_mux.c pin_mux.h
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/LPC55S69/drivers/: fsl_sysctl.c fsl_sysctl.h fsl_common.c fsl_common.h fsl_iocon.h fsl_i2c.c fsl_i2c.h fsl_i2s.c fsl_i2s.h fsl_i2s_dma.c fsl_i2s_dma.h fsl_dma.c fsl_dma.h fsl_usart.c fsl_usart.h fsl_clock.c fsl_clock.h fsl_power.c fsl_power.h fsl_gpio.c fsl_gpio.h fsl_inputmux.c fsl_inputmux.h fsl_flexcomm.c fsl_flexcomm.h fsl_reset.c fsl_reset.h fsl_inputmux_connections.h
  group codec
    ../../../../../../../components/codec/i2c/: fsl_codec_i2c.c fsl_codec_i2c.h
    ../../../../../../../components/codec/wm8904/: fsl_wm8904.c fsl_wm8904.h
    ../../../../../../../components/codec/: fsl_codec_common.c fsl_codec_common.h
    ../../../../../../../components/codec/port/wm8904/: fsl_codec_adapter.c fsl_codec_adapter.h
  group component/i2c
    ../../../../../../../components/i2c/: flexcomm_i2c_adapter.c i2c.h
  group component/uart
    ../../../../../../../components/uart/: uart.h usart_adapter.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
  group device
    ../../../../../../../devices/LPC55S69/: LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h fsl_device_registers.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group startup
    ../../../../../../../devices/LPC55S69/iar/: startup_LPC55S69_cm33_core0.s
  group utilities
    ../../../../../../../devices/LPC55S69/utilities/: fsl_assert.c
    ../../../../../../../devices/LPC55S69/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
