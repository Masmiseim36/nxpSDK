# Keil uVision project i2s_interrupt_record_playback.uvprojx, settings and files
target i2s_interrupt_record_playback debug (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: i2s_interrupt_record_playback.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_LPC55S69JBD100_cm33_core0, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8904_ENABLE, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../cm33_core0;../..;../../../../..;../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../devices/LPC55S69;../../../../../../../devices/LPC55S69/drivers;../../../../../../../components/codec/i2c;../../../../../../../components/i2c;../../../../../../../components/codec/wm8904;../../../../../../../components/codec;../../../../../../../components/codec/port/wm8904;../../../../../../../devices/LPC55S69/utilities/str;../../../../../../../devices/LPC55S69/utilities/debug_console;../../../../../../../components/uart;../../../../../../../components/serial_manager;../../../../../../../components/lists;../../../../../../../devices/LPC55S69/utilities
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: ../../../../../../../devices/LPC55S69/arm/keil_lib_power_cm33_core0.lib --remove
  group source
    ../: i2s_interrupt_record_playback.c
    ../../../cm33_core0/: music.h
  group board
    ../../../cm33_core0/: pin_mux.c pin_mux.h
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/LPC55S69/drivers/: fsl_sysctl.c fsl_sysctl.h fsl_common.c fsl_common.h fsl_iocon.h fsl_i2c.c fsl_i2c.h fsl_i2s.c fsl_i2s.h fsl_i2s_dma.c fsl_i2s_dma.h fsl_dma.c fsl_dma.h fsl_usart.c fsl_usart.h fsl_clock.c fsl_clock.h fsl_power.c fsl_power.h fsl_gpio.c fsl_gpio.h fsl_inputmux.c fsl_inputmux.h fsl_flexcomm.c fsl_flexcomm.h fsl_reset.c fsl_reset.h fsl_inputmux_connections.h
  group codec
    ../../../../../../../components/codec/i2c/: fsl_codec_i2c.c fsl_codec_i2c.h
    ../../../../../../../components/codec/wm8904/: fsl_wm8904.c fsl_wm8904.h
    ../../../../../../../components/codec/: fsl_codec_common.c fsl_codec_common.h
    ../../../../../../../components/codec/port/wm8904/: fsl_codec_adapter.c fsl_codec_adapter.h
  group component/i2c
    ../../../../../../../components/i2c/: flexcomm_i2c_adapter.c i2c.h
  group device
    ../../../../../../../devices/LPC55S69/: LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h fsl_device_registers.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group startup
    ../../../../../../../devices/LPC55S69/arm/: startup_LPC55S69_cm33_core0.S
  group utilities
    ../../../../../../../devices/LPC55S69/utilities/: fsl_assert.c
    ../../../../../../../devices/LPC55S69/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group component-uart
    ../../../../../../../components/uart/: uart.h usart_adapter.c
  group component-serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
target i2s_interrupt_record_playback release (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: i2s_interrupt_record_playback.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_LPC55S69JBD100_cm33_core0, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8904_ENABLE, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: as above
