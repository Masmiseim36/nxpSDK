# IAR project powerquad_benchmark_sw_filter.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S69_core0 NXP LPC55S69_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_LPC55S69JBD100_cm33_core0; __FPU_PRESENT=1; __DSP_PRESENT=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../..; ../../../../..; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../devices/LPC55S69; ../../../../../unit_tests/powerquad; ../../../../../../../devices/LPC55S69/drivers; ../../../../../../../devices/LPC55S69/utilities/str; ../../../../../../../devices/LPC55S69/utilities/debug_console; ../../../../../../../components/uart; ../../../../../../../components/serial_manager; ../../../../../../../components/lists; ../../../../../../../devices/LPC55S69/utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: powerquad_benchmark_sw_filter.out
  ILINK.IlinkConfigDefines: __stack_size__=0x8000
  ILINK.IlinkIcfFile: LPC55S69_cm33_core0_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../devices/LPC55S69/iar/iar_lib_power_cm33_core0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_LPC55S69JBD100_cm33_core0; __FPU_PRESENT=1; __DSP_PRESENT=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group CMSIS
    ../../../../../../../CMSIS/DSP/Source/TransformFunctions/: arm_bitreversal.c arm_bitreversal2.c arm_cfft_radix2_q31.c arm_cfft_radix2_init_q31.c arm_cfft_radix4_q31.c arm_cfft_radix4_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_init_q15.c arm_cfft_radix4_q15.c arm_cfft_radix4_init_q15.c arm_rfft_q15.c arm_rfft_init_q15.c arm_rfft_q31.c arm_rfft_init_q31.c arm_cfft_q15.c arm_cfft_q31.c arm_dct4_q15.c arm_dct4_init_q15.c arm_dct4_q31.c arm_dct4_init_q31.c
    ../../../../../../../CMSIS/DSP/Source/BasicMathFunctions/: arm_mult_q31.c arm_shift_q31.c arm_mult_q15.c arm_shift_q15.c
    ../../../../../../../CMSIS/DSP/Source/ComplexMathFunctions/: arm_cmplx_mult_cmplx_q31.c arm_cmplx_mult_cmplx_q15.c
    ../../../../../../../CMSIS/DSP/Source/MatrixFunctions/: arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_add_f32.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_sub_f32.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_mult_f32.c arm_mat_inverse_f32.c arm_mat_trans_q15.c arm_mat_trans_q31.c arm_mat_trans_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_scale_f32.c arm_mat_init_f32.c arm_mat_init_q31.c arm_mat_init_q15.c
    ../../../../../../../CMSIS/DSP/Source/FastMathFunctions/: arm_sqrt_q15.c arm_sqrt_q31.c arm_sin_q15.c arm_sin_q31.c arm_sin_f32.c arm_cos_q15.c arm_cos_q31.c arm_cos_f32.c
    ../../../../../../../CMSIS/DSP/Source/FilteringFunctions/: arm_fir_q15.c arm_fir_init_q15.c arm_fir_q31.c arm_fir_init_q31.c arm_fir_f32.c arm_fir_init_f32.c arm_conv_q15.c arm_conv_q31.c arm_conv_f32.c arm_correlate_q15.c arm_correlate_q31.c arm_correlate_f32.c arm_biquad_cascade_df2T_init_f32.c arm_biquad_cascade_df2T_f32.c
    ../../../../../../../CMSIS/DSP/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../../../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
  group source
    ../: powerquad_benchmark_sw_filter.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/LPC55S69/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_power.c fsl_power.h fsl_iocon.h fsl_gpio.c fsl_gpio.h fsl_inputmux.c fsl_inputmux.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_reset.c fsl_reset.h fsl_inputmux_connections.h
  group utilities
    ../../../../../../../devices/LPC55S69/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/LPC55S69/utilities/: fsl_assert.c
  group device
    ../../../../../../../devices/LPC55S69/: LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h fsl_device_registers.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group startup
    ../../../../../../../devices/LPC55S69/iar/: startup_LPC55S69_cm33_core0.s
  group component/uart
    ../../../../../../../components/uart/: uart.h usart_adapter.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
