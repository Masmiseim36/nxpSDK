# Keil uVision project powerquad_benchmark_sw_filter.uvprojx, settings and files
target powerquad_benchmark_sw_filter debug (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: powerquad_benchmark_sw_filter.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_LPC55S69JBD100_cm33_core0, __FPU_PRESENT=1, __DSP_PRESENT=1, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../..;../../../../..;../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../devices/LPC55S69;../../../../../unit_tests/powerquad;../../../../../../../devices/LPC55S69/drivers;../../../../../../../devices/LPC55S69/utilities/str;../../../../../../../devices/LPC55S69/utilities/debug_console;../../../../../../../components/uart;../../../../../../../components/serial_manager;../../../../../../../components/lists;../../../../../../../devices/LPC55S69/utilities
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: ../../../../../../../devices/LPC55S69/arm/keil_lib_power_cm33_core0.lib --remove --predefine="-D__stack_size__=0x8000"
  group CMSIS
    ../../../../../../../CMSIS/DSP/Source/TransformFunctions/: arm_bitreversal.c arm_bitreversal2.c arm_cfft_radix2_q31.c arm_cfft_radix2_init_q31.c arm_cfft_radix4_q31.c arm_cfft_radix4_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_init_q15.c arm_cfft_radix4_q15.c arm_cfft_radix4_init_q15.c arm_rfft_q15.c arm_rfft_init_q15.c arm_rfft_q31.c arm_rfft_init_q31.c arm_cfft_q15.c arm_cfft_q31.c arm_dct4_q15.c arm_dct4_init_q15.c arm_dct4_q31.c arm_dct4_init_q31.c
    ../../../../../../../CMSIS/DSP/Source/BasicMathFunctions/: arm_mult_q31.c arm_shift_q31.c arm_mult_q15.c arm_shift_q15.c
    ../../../../../../../CMSIS/DSP/Source/ComplexMathFunctions/: arm_cmplx_mult_cmplx_q31.c arm_cmplx_mult_cmplx_q15.c
    ../../../../../../../CMSIS/DSP/Source/MatrixFunctions/: arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_add_f32.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_sub_f32.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_mult_f32.c arm_mat_inverse_f32.c arm_mat_trans_q15.c arm_mat_trans_q31.c arm_mat_trans_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_scale_f32.c arm_mat_init_f32.c arm_mat_init_q31.c arm_mat_init_q15.c
    ../../../../../../../CMSIS/DSP/Source/FastMathFunctions/: arm_sqrt_q15.c arm_sqrt_q31.c arm_sin_q15.c arm_sin_q31.c arm_sin_f32.c arm_cos_q15.c arm_cos_q31.c arm_cos_f32.c
    ../../../../../../../CMSIS/DSP/Source/FilteringFunctions/: arm_fir_q15.c arm_fir_init_q15.c arm_fir_q31.c arm_fir_init_q31.c arm_fir_f32.c arm_fir_init_f32.c arm_conv_q15.c arm_conv_q31.c arm_conv_f32.c arm_correlate_q15.c arm_correlate_q31.c arm_correlate_f32.c arm_biquad_cascade_df2T_init_f32.c arm_biquad_cascade_df2T_f32.c
    ../../../../../../../CMSIS/DSP/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../../../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
  group source
    ../: powerquad_benchmark_sw_filter.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/LPC55S69/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_power.c fsl_power.h fsl_iocon.h fsl_gpio.c fsl_gpio.h fsl_inputmux.c fsl_inputmux.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_reset.c fsl_reset.h fsl_inputmux_connections.h
  group utilities
    ../../../../../../../devices/LPC55S69/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/LPC55S69/utilities/: fsl_assert.c
  group device
    ../../../../../../../devices/LPC55S69/: LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h fsl_device_registers.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group startup
    ../../../../../../../devices/LPC55S69/arm/: startup_LPC55S69_cm33_core0.S
  group component-uart
    ../../../../../../../components/uart/: uart.h usart_adapter.c
  group component-serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
target powerquad_benchmark_sw_filter release (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: powerquad_benchmark_sw_filter.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_LPC55S69JBD100_cm33_core0, __FPU_PRESENT=1, __DSP_PRESENT=1, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: as above
