# Keil uVision project fmstr_example_usb_cdc.uvprojx, settings and files
target fmstr_example_usb_cdc debug (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: IRAM(0x20000000,0x044000) IRAM2(0x04000000,0x8000) IROM(0x00000000,0x098000) XRAM(0x40100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: fmstr_example_usb_cdc.out
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_LPC55S69JBD100_cm33_core0=1, USB_STACK_USE_DEDICATED_RAM=1, USB_STACK_BM=1, SERIAL_PORT_TYPE_UART=1
  c misc: -mno-unaligned-access
  c include: ../../common/fmstr_example;..;../support/mcuxsdk_usb;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../devices/LPC55S69;../../../../../components/osa;../../../../../middleware/usb/device;../../../../../middleware/usb/include;../../../../../middleware/usb/phy;../../../../../devices/LPC55S69/drivers;../../../../../middleware/freemaster/src/common;../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial;../../../../../middleware/freemaster/src/drivers/mcuxsdk/can;../../../../../devices/LPC55S69/utilities/str;../../../../../devices/LPC55S69/utilities/debug_console;../../../../../components/uart;../../../../../components/lists;../../../../../components/serial_manager;../../../../../middleware/freemaster/src/platforms/gen32le;../../../../../devices/LPC55S69/utilities
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: ../../../../../devices/LPC55S69/arm/keil_lib_power_cm33_core0.lib --remove --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x1000"
  group source
    ../: main.c freemaster_cfg.h
    ../../common/fmstr_example/: freemaster_example.c freemaster_example.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source/support/mcuxsdk_usb
    ../support/mcuxsdk_usb/: freemaster_usb.c freemaster_usb.h freemaster_usb_device_descriptor.c freemaster_usb_device_descriptor.h usb_device_config.h
  group source/example_data
    ../../common/fmstr_example/: data_example_pmp.h data_img_logo.h data_img_file.h data_img_fmstrlogo.h data_html_index.h example_data.h
  group doc
    ../: readme.txt
  group usb-device-include
    ../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group usb-device-source
    ../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h usb_device_dci.h
    ../: usb_device_ch9.c usb_device_ch9.h
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group usb-device-source-lpcip3511
    ../../../../../middleware/usb/device/: usb_device_lpcip3511.c usb_device_lpcip3511.h
  group usb-device-class
    ../: usb_device_class.c usb_device_class.h
  group usb-device-class-cdc
    ../: usb_device_cdc_acm.c usb_device_cdc_acm.h
  group usb-phy
    ../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group drivers
    ../../../../../devices/LPC55S69/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_iocon.h fsl_gpio.c fsl_gpio.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h
  group freemaster
    ../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_can.c freemaster_can.h freemaster_defcfg.h freemaster_pdbdm.c freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_serial.c freemaster_serial.h freemaster_sha.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h
  group freemaster/drivers/mcuxsdk/can
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mcan.c freemaster_mcan.h freemaster_mscan.c freemaster_mscan.h
  group freemaster/drivers/mcuxsdk/serial
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_usb.c freemaster_serial_usb.h
  group device
    ../../../../../devices/LPC55S69/: LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h fsl_device_registers.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group startup
    ../../../../../devices/LPC55S69/arm/: startup_LPC55S69_cm33_core0.S
  group utilities
    ../../../../../devices/LPC55S69/utilities/: fsl_assert.c
    ../../../../../devices/LPC55S69/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group component-uart
    ../../../../../components/uart/: uart.h usart_adapter.c
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group freemaster/platforms
    ../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
  group usb-include
    ../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
target fmstr_example_usb_cdc release (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: as above
  output: fmstr_example_usb_cdc.out
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_LPC55S69JBD100_cm33_core0=1, USB_STACK_USE_DEDICATED_RAM=1, USB_STACK_BM=1, SERIAL_PORT_TYPE_UART=1
  c misc: -mno-unaligned-access
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: as above
