# Keil uVision project multicore_manager_cm33_core0.uvprojx, settings and files
target multicore_manager_cm33_core0 debug (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: multicore_manager_cm33_core0.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CORE1_IMAGE_COPY_TO_RAM, CPU_LPC55S69JBD100_cm33_core0, MCMGR_HANDLE_EXCEPTIONS=1, __SEMIHOST_HARDFAULT_DISABLE=1, MULTICORE_APP=1, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../..;../../../..;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/LPC55S69;../../../../../../devices/LPC55S69/drivers;../../../../../../middleware/multicore/mcmgr/src;../../../../../../devices/LPC55S69/utilities/str;../../../../../../devices/LPC55S69/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../devices/LPC55S69/utilities
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  asm include: ../../cm33_core1/mdk/debug
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: ../../../../../../devices/LPC55S69/arm/keil_lib_power_cm33_core0.lib --remove --keep=*(.m0code)
  group source
    ../: mcmgr_core0.c incbin.S
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group mcmgr
    ../../../../../../middleware/multicore/mcmgr/src/: mcmgr_internal_core_api_lpc55s69.c mcmgr.c mcmgr.h mcmgr_internal_core_api.h
  group drivers
    ../../../../../../devices/LPC55S69/drivers/: fsl_mailbox.h fsl_iocon.h fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h
  group device
    ../../../../../../devices/LPC55S69/: LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h fsl_device_registers.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group startup
    ../../../../../../devices/LPC55S69/arm/: startup_LPC55S69_cm33_core0.S
  group utilities
    ../../../../../../devices/LPC55S69/utilities/: fsl_assert.c
    ../../../../../../devices/LPC55S69/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group component-uart
    ../../../../../../components/uart/: uart.h usart_adapter.c
  group component-serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
target multicore_manager_cm33_core0 release (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: multicore_manager_cm33_core0.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CORE1_IMAGE_COPY_TO_RAM, CPU_LPC55S69JBD100_cm33_core0, MCMGR_HANDLE_EXCEPTIONS=1, __SEMIHOST_HARDFAULT_DISABLE=1, MULTICORE_APP=1, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  asm include: ../../cm33_core1/mdk/release
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: as above
