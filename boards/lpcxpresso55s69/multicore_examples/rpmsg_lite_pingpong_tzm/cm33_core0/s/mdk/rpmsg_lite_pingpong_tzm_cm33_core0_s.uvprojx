# Keil uVision project rpmsg_lite_pingpong_tzm_cm33_core0_s.uvprojx, settings and files
target rpmsg_lite_pingpong_tzm_cm33_core0_s debug (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: IRAM(0x20000000,0x044000) IRAM2(0x04000000,0x8000) IROM(0x00000000,0x098000) XRAM(0x40100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rpmsg_lite_pingpong_tzm_cm33_core0_s.out
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CORE1_IMAGE_COPY_TO_RAM, CPU_LPC55S69JBD100_cm33_core0, MULTICORE_APP=1, SERIAL_PORT_TYPE_UART=1
  c include: ../../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/lpc55s69;..;../../../s;../../..;../../../../..;../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../devices/LPC55S69;../../../../../../../devices/LPC55S69/drivers;../../../../../../../middleware/multicore/rpmsg_lite/lib/include;../../../../../../../middleware/multicore/mcmgr/src;../../../../../../../devices/LPC55S69/utilities/str;../../../../../../../devices/LPC55S69/utilities/debug_console;../../../../../../../components/uart;../../../../../../../components/serial_manager;../../../../../../../components/lists;../../../../../../../devices/LPC55S69/utilities
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  asm include: ../../../cm33_core1/mdk/debug
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash_s.scf
  link misc: ../../../../../../../devices/LPC55S69/arm/keil_lib_power_cm33_core0_s.lib --remove --keep=*(.m0code) --import-cmse-lib-out=".\debug\rpmsg_lite_pingpong_tzm_s_CMSE_lib.o" --predefine="-D__stack_size__=0x400" --predefine="-D__heap_size__=0x2000" --predefine="-D__use_shmem__=1"
  group source
    ../: main_master_tzm_s.c incbin.S rpmsg_config.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group trustzone
    ../: tzm_config.c tzm_config.h veneer_table.h veneer_table.c
  group doc
    ../: readme.txt
  group mcmgr
    ../../../../../../../middleware/multicore/mcmgr/src/: mcmgr_internal_core_api_lpc55s69.c mcmgr.c mcmgr.h mcmgr_internal_core_api.h
  group rpmsg_lite-porting
    ../../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/lpc55s69/: rpmsg_platform.h
    ../../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/platform/lpc55s69/: rpmsg_platform.c
  group drivers
    ../../../../../../../devices/LPC55S69/drivers/: fsl_power.c fsl_power.h fsl_iocon.h fsl_mailbox.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h
  group rpmsg_lite-env-bm
    ../../../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_env.h
    ../../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_bm.c
  group device
    ../../../../../../../devices/LPC55S69/: LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h fsl_device_registers.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group startup
    ../../../../../../../devices/LPC55S69/arm/: startup_LPC55S69_cm33_core0.S
  group utilities
    ../../../../../../../devices/LPC55S69/utilities/: fsl_assert.c
    ../../../../../../../devices/LPC55S69/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group component-uart
    ../../../../../../../components/uart/: uart.h usart_adapter.c
  group component-serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
  group rpmsg_lite
    ../../../../../../../middleware/multicore/rpmsg_lite/lib/common/: llist.c
    ../../../../../../../middleware/multicore/rpmsg_lite/lib/include/: llist.h rpmsg_compiler.h rpmsg_default_config.h rpmsg_lite.h rpmsg_ns.h virtio_ring.h virtqueue.h
    ../../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c
    ../../../../../../../middleware/multicore/rpmsg_lite/lib/virtio/: virtqueue.c
target rpmsg_lite_pingpong_tzm_cm33_core0_s release (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: as above
  output: rpmsg_lite_pingpong_tzm_cm33_core0_s.out
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CORE1_IMAGE_COPY_TO_RAM, CPU_LPC55S69JBD100_cm33_core0, MULTICORE_APP=1, SERIAL_PORT_TYPE_UART=1
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  asm include: ../../../cm33_core1/mdk/release
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash_s.scf
  link misc: ../../../../../../../devices/LPC55S69/arm/keil_lib_power_cm33_core0_s.lib --remove --keep=*(.m0code) --import-cmse-lib-out=".\release\rpmsg_lite_pingpong_tzm_s_CMSE_lib.o" --predefine="-D__stack_size__=0x400" --predefine="-D__heap_size__=0x2000" --predefine="-D__use_shmem__=1"
