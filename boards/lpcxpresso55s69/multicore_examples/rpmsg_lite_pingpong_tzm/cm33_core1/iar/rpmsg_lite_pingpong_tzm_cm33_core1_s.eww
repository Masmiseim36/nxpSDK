<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>rpmsg_lite_pingpong_tzm_cm33_core1_s</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>rpmsg_lite_pingpong_tzm_cm33_core1_s</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>rpmsg_lite_pingpong_tzm_cm33_core1_s</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>rpmsg_lite_pingpong_tzm_cm33_core1_s</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/rpmsg_lite_pingpong_tzm_cm33_core1_s.ewp</path>
  </project>
</workspace>
