<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>se_SE05x_cloud_gcp</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>se_SE05x_cloud_gcp</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>se_SE05x_cloud_gcp</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>se_SE05x_cloud_gcp</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/se_SE05x_cloud_gcp.ewp</path>
  </project>
</workspace>
