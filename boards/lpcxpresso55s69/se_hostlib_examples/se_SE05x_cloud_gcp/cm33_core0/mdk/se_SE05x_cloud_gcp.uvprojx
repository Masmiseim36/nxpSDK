# Keil uVision project se_SE05x_cloud_gcp.uvprojx, settings and files
target se_SE05x_cloud_gcp debug (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: se_SE05x_cloud_gcp.out
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_LPC55S69JBD100_cm33_core0, LPC_55x=1, GCP_IOT, SSS_HAVE_GCP, PRINTF_ADVANCED_ENABLE=1, LPC_WIFI, WIFISHIELD_IS=WIFISHIELD_IS_SILEX2401, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS, A_LITTLE_ENDIAN, SDK_DEBUGCONSOLE_UART, T1oI2C, T1oI2C_UM11225, SSS_USE_FTR_FILE, NO_SECURE_CHANNEL_SUPPORT, MBEDTLS, SDK_OS_FREE_RTOS, USE_RTOS, mqttconfigENABLE_METRICS=0, MBEDTLS_CONFIG_FILE='\"sss_mbedtls_frdmk64f_config.h\"', SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC
  c misc: -O1  -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM33_NTZ/non_secure;..;../../../../../../middleware/se_hostlib/demos/ksdk/se050/gcp;../../../../../../middleware/se_hostlib/demos/ksdk/gcp;../../../../../../middleware/se_hostlib/demos/ksdk/common;../../../../../../middleware/se_hostlib/demos/ksdk/common/https_client;../../../../../../middleware/se_hostlib/hostlib/demo/gcp_jwt_demo;../../../..;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/LPC55S69;../../../../../../middleware/mbedtls/include;../../../../../../middleware/mbedtls/port/ksdk;../../../../../../rtos/freertos/freertos_kernel/include;../../../../../../rtos/freertos/libraries/abstractions/wifi/include;../../../../../../rtos/freertos/libraries/abstractions/secure_sockets/include;../../../../../../rtos/freertos/libraries/abstractions/platform/freertos/include;../../../../../../rtos/freertos/libraries/abstractions/platform/include;../../../../../../rtos/freertos/libraries/freertos_plus/standard/tls/include;../../../../../../rtos/freertos/libraries/freertos_plus/standard/pkcs11/include;../../../../../../rtos/freertos/libraries/freertos_plus/standard/crypto/include;../../../../../../rtos/freertos/libraries/freertos_plus/standard/utils/include;../../../../../../rtos/freertos/demos/network_manager;../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/include;../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/src;../../../../../../rtos/freertos/libraries/c_sdk/standard/common/include;../../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/private;../../../../../../rtos/freertos/libraries/3rdparty/pkcs11;../../../../../../rtos/freertos/libraries/3rdparty/jsmn;../../../../../../devices/LPC55S69/drivers;../../../../../../middleware/se_hostlib/sss/inc;../../../../../../middleware/se_hostlib/sss/ex/inc;../../../../../../middleware/se_hostlib/sss/port/ksdk;../../../../../../middleware/se_hostlib/hostlib/hostLib/se05x_03_xx_xx;../../../mainA71CH;../../../../../../middleware/se_hostlib/sss/plugin/mbedtls;../../../../../../middleware/se_hostlib/hostlib/hostLib/tstUtil;../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/infra;../../../../../../middleware/se_hostlib/hostlib/hostLib/mbedtls/inc;../../../../../../rtos/freertos/lib/include/private;../../../../../../rtos/freertos/lib/pkcs11/portable/nxp/se_hostlib;../../../../../../rtos/freertos/libraries/abstractions/pkcs11/mbedtls;../../../../../../middleware/se_hostlib/demos/ksdk/common/freertos/boards/lpcxpresso55s69;../../../../../../devices/LPC55S69/utilities/str;../../../../../../devices/LPC55S69/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../middleware/wifi_qca/port/boards/lpcxpresso55s69/freertos/silex2401;../../../../../../middleware/wifi_qca/port/boards/lpcxpresso55s69/freertos;../../../../../../middleware/wifi_qca/port/env/freertos;../../../../../../middleware/wifi_qca;../../../../../../middleware/wifi_qca/include;../../../../../../middleware/wifi_qca/include/AR6002;../../../../../../middleware/wifi_qca/include/AR6002/hw2.0/hw;../../../../../../middleware/wifi_qca/include/AR6002/hw4.0/hw;../../../../../../middleware/wifi_qca/custom_src/stack_custom;../../../../../../middleware/wifi_qca/custom_src/include;../../../../../../middleware/wifi_qca/common_src/include;../../../../../../middleware/wifi_qca/common_src/stack_common;../../../../../../middleware/wifi_qca/common_src/hcd;../../../../../../middleware/wifi_qca/common_src/wmi;../../../../../../middleware/wifi_qca/port;../../../../../../middleware/wifi_qca/port/drivers/flexcomm_freertos;../../../../../../middleware/se_hostlib;../../../../../../middleware/se_hostlib/hostlib/hostLib/inc;../../../../../../middleware/se_hostlib/platform;../../../../../../middleware/se_hostlib/hostlib/hostLib/platform/inc;../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom;../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/T1oI2C;../../../../../../middleware/se_hostlib/demos/ksdk/common/boards/lpcxpresso55s69/se_hostlib_examples/cloud_demo;../../../../../../devices/LPC55S69/utilities
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  asm include: ../../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM33_NTZ/non_secure;../../../../../../middleware/se_hostlib/demo/se_SE05x_cloud_gcp;..;../../../..;../../../../../../middleware/se_hostlib/demos/ksdk/common/freertos/boards/lpcxpresso55s69
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: ../../../../../../devices/LPC55S69/arm/keil_lib_power_cm33_core0.lib --remove --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x8000"
  group source
    ../: fsl_sss_ftr.h gcpJWTDemo.c gcpJWTDemo.h gcpJWTDemo_Main_lwip.c gcpJwtTask_lwip.c gcpNTPGetEpoch_lwip.c gcpPubSub.c gcp_client_credential_keys.h gcp_default_root_certificates.h gcp_iot_config.h FreeRTOSConfig.h
  group board
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/LPC55S69/drivers/: fsl_casper.c fsl_casper.h fsl_hashcrypt.c fsl_hashcrypt.h fsl_rng.c fsl_rng.h fsl_i2c.c fsl_i2c.h fsl_spi.c fsl_spi.h fsl_puf.c fsl_puf.h fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_iocon.h fsl_gpio.c fsl_gpio.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_spi_dma.c fsl_spi_dma.h fsl_dma.c fsl_dma.h fsl_pint.c fsl_pint.h fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h
  group se_hostlib-demos-ksdk-common
    ../../../../../../middleware/se_hostlib/demos/ksdk/common/: aws_shadow_config.h aws_wifi_config.h wifi_config.h aws_clientcredential.h aws_clientcredential_keys.h aws_demo_config.h aws_pkcs11_config.h iot_config.h iot_config_common.h iot_logging_task.h iot_pkcs11_config.h ledHandler.c
  group mbedtls-include-mbedtls
    ../../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls-library
    ../../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls-port-ksdk
    ../../../../../../middleware/mbedtls/port/ksdk/: aes_alt.c aes_alt.h des_alt.c des_alt.h ecp_alt.c ecp_alt.h ecp_alt_ksdk.c ecp_curves_alt.c ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h
  group device
    ../../../../../../devices/LPC55S69/: LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h fsl_device_registers.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group startup
    ../../../../../../devices/LPC55S69/arm/: startup_LPC55S69_cm33_core0.S
  group utilities
    ../../../../../../devices/LPC55S69/utilities/: fsl_assert.c
    ../../../../../../devices/LPC55S69/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group component-uart
    ../../../../../../components/uart/: uart.h usart_adapter.c
  group component-serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
  group wifi_qca-port-boards-lpcxpresso55s69-freertos-silex2401
    ../../../../../../middleware/wifi_qca/port/boards/lpcxpresso55s69/freertos/silex2401/: wifi_shield_silex2401.h
  group wifi_qca-port-boards-lpcxpresso55s69-freertos
    ../../../../../../middleware/wifi_qca/port/boards/lpcxpresso55s69/freertos/: wifi_shield.c wifi_shield.h
  group wifi_qca-port-env-freertos
    ../../../../../../middleware/wifi_qca/port/env/freertos/: wifi_env.c wifi_env.h wifi_env_port.h wifi_port.h
  group freertos-freertos_kernel
    ../../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos-freertos_kernel-include
    ../../../../../../rtos/freertos/freertos_kernel/include/: FreeRTOS.h StackMacros.h atomic.h croutine.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos-freertos_kernel-portable-MemMang
    ../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos-freertos_kernel-portable
    ../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group wifi_qca
    ../../../../../../middleware/wifi_qca/: ChangeLogKSDK.txt atheros_stack_offload.h atheros_wifi.h atheros_wifi_api.h atheros_wifi_internal.h license.txt qcom_api.h
  group wifi_qca-common_src-api_interface
    ../../../../../../middleware/wifi_qca/common_src/api_interface/: api_init.c api_ioctl.c api_txrx.c api_wmi_rx.c
  group wifi_qca-common_src-bmi
    ../../../../../../middleware/wifi_qca/common_src/bmi/: bmi.c
  group wifi_qca-common_src-driver
    ../../../../../../middleware/wifi_qca/common_src/driver/: driver_diag.c driver_init.c driver_main.c driver_netbuf.c driver_txrx.c
  group wifi_qca-common_src-hcd
    ../../../../../../middleware/wifi_qca/common_src/hcd/: hcd_api.h spi_hcd.c
  group wifi_qca-common_src-htc
    ../../../../../../middleware/wifi_qca/common_src/htc/: htc.c
  group wifi_qca-common_src-hw_interface
    ../../../../../../middleware/wifi_qca/common_src/hw_interface/: hw_api.c
  group wifi_qca-common_src-include
    ../../../../../../middleware/wifi_qca/common_src/include/: a_debug.h a_drv.h a_drv_api.h aggr_recv_api.h bmi.h common_api.h dbglog_api.h driver_cxt.h dset.h dset_api.h hif_internal.h htc_api.h ieee80211.h netbuf.h spi_hcd_if.h wlan_api.h wmi_api.h
  group wifi_qca-common_src-qapi
    ../../../../../../middleware/wifi_qca/common_src/qapi/: qcom_api.c qcom_dns.c qcom_legacy.c
  group wifi_qca-common_src-reorder
    ../../../../../../middleware/wifi_qca/common_src/reorder/: rcv_aggr.c
  group wifi_qca-common_src-stack_common
    ../../../../../../middleware/wifi_qca/common_src/stack_common/: api_stack_offload.c common_stack_offload.h
  group wifi_qca-common_src-storerecall
    ../../../../../../middleware/wifi_qca/common_src/storerecall/: dset.c dset_api.c storerecall.c
  group wifi_qca-common_src-util
    ../../../../../../middleware/wifi_qca/common_src/util/: util.c
  group wifi_qca-common_src-wmi
    ../../../../../../middleware/wifi_qca/common_src/wmi/: wmi.c wmi_host.h
  group wifi_qca-custom_src-api_interface
    ../../../../../../middleware/wifi_qca/custom_src/api_interface/: cust_api_init.c cust_api_ioctl.c cust_api_txrx.c cust_api_wmi_rx.c
  group wifi_qca-custom_src-driver
    ../../../../../../middleware/wifi_qca/custom_src/driver/: cust_driver_main.c cust_driver_netbuf.c
  group wifi_qca-custom_src-hw_interface
    ../../../../../../middleware/wifi_qca/custom_src/hw_interface/: cust_spi_hcd.c
  group wifi_qca-custom_src-include
    ../../../../../../middleware/wifi_qca/custom_src/include/: a_config.h a_osapi.h a_types.h cust_netbuf.h custom_wlan_api.h wlan_config.h
  group wifi_qca-custom_src-qapi
    ../../../../../../middleware/wifi_qca/custom_src/qapi/: custom_qcom_api.c
  group wifi_qca-custom_src-stack_custom
    ../../../../../../middleware/wifi_qca/custom_src/stack_custom/: cust_api_stack_offload.c cust_api_stack_txrx.c custom_stack_offload.h qca_structs.h
  group wifi_qca-include-AR6002
    ../../../../../../middleware/wifi_qca/include/AR6002/: AR6K_version.h
  group wifi_qca-include-AR6002-hw2.0-hw
    ../../../../../../middleware/wifi_qca/include/AR6002/hw2.0/hw/: hw20_apb_map.h hw20_gpio_reg.h hw20_mbox_host_reg.h hw20_mbox_reg.h hw20_rtc_reg.h hw20_si_reg.h hw20_uart_reg.h hw20_vmc_reg.h
  group wifi_qca-include-AR6002-hw4.0-hw
    ../../../../../../middleware/wifi_qca/include/AR6002/hw4.0/hw/: hw40_rtc_reg.h hw40_rtc_wlan_reg.h
  group wifi_qca-include
    ../../../../../../middleware/wifi_qca/include/: athdefs.h bmi_msg.h dbglog.h dbglog_id.h htc.h htc_services.h p2p.h pkt_log.h pmu.h targaddrs.h wlan_defs.h wmi.h
  group wifi_qca-port
    ../../../../../../middleware/wifi_qca/port/: wifi_common.h wifi_shield_common.h
  group wifi_qca-port-drivers-flexcomm_freertos
    ../../../../../../middleware/wifi_qca/port/drivers/flexcomm_freertos/: wifi_spi.c wifi_spi.h
  group freertos-vendors-nxp-wifi-qca_400x
    ../../../../../../rtos/freertos/vendors/nxp/wifi/qca_400x/: iot_wifi.c
  group freertos-libraries-abstractions-wifi-include
    ../../../../../../rtos/freertos/libraries/abstractions/wifi/include/: iot_wifi.h
  group drivers-freertos
    ../../../../../../devices/LPC55S69/drivers/: fsl_i2c_freertos.c fsl_i2c_freertos.h
  group freertos-freertos_kernel-portable-GCC-ARM_CM33_NTZ-non_secure
    ../../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c portasm.h portmacro.h
  group freertos-vendors-nxp-secure_sockets-wifi_qca
    ../../../../../../rtos/freertos/vendors/nxp/secure_sockets/wifi_qca/: iot_secure_sockets.c
  group freertos-libraries-abstractions-secure_sockets-include
    ../../../../../../rtos/freertos/libraries/abstractions/secure_sockets/include/: iot_secure_sockets.h iot_secure_sockets_config_defaults.h iot_secure_sockets_wrapper_metrics.h
  group se_hostlib-hostlib-hostLib-inc
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/inc/: Applet_SE050_Ver.h HLSEAPI.h HLSEComm.h HLSECrypto.h HLSEMisc.h HLSEObjects.h HLSETypes.h PlugAndTrust_HostLib_Ver.h PlugAndTrust_Pkg_Ver.h SE_HAL_Lib.h a71ch_api.h a71ch_util.h a71cl_api.h a71cl_util.h ax_api.h ax_common.h ax_common_a71ch.h ax_common_a71cl.h ax_common_private.h ax_scp.h ax_scp_private.h ax_sss_scp.h ax_util.h ledHandler.h nxEnsure.h nxScp03_Apis.h nxScp03_Const.h nxScp03_Types.h scp.h se05x_const.h se05x_ecc_curves.h se05x_ecc_curves_inc.h se05x_ecc_curves_values.h se05x_enums.h se05x_ftr.h se05x_tlv.h sm_const.h ledHandler.h
  group se_hostlib-hostlib-hostLib-se05x-src
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/se05x/src/: se05x_ECC_curves.c se05x_mw.c se05x_tlv.c
  group se_hostlib-sss-inc
    ../../../../../../middleware/se_hostlib/sss/inc/: fsl_sscp.h fsl_sscp_a71ch.h fsl_sscp_a71cl.h fsl_sscp_commands.h fsl_sscp_mu.h fsl_sss_api.h fsl_sss_api_ver.h fsl_sss_config.h fsl_sss_ftr_default.h fsl_sss_keyid_map.h fsl_sss_lpc55s_apis.h fsl_sss_lpc55s_types.h fsl_sss_mbedtls_apis.h fsl_sss_mbedtls_types.h fsl_sss_openssl_apis.h fsl_sss_openssl_types.h fsl_sss_policy.h fsl_sss_se05x_apis.h fsl_sss_se05x_policy.h fsl_sss_se05x_scp03.h fsl_sss_se05x_types.h fsl_sss_sscp.h fsl_sss_sscp_config.h fsl_sss_user_apis.h fsl_sss_user_types.h fsl_sss_util_asn1_der.h fsl_sss_util_rsa_sign_utils.h
  group se_hostlib-sss-port-ksdk
    ../../../../../../middleware/se_hostlib/sss/port/ksdk/: fsl_sss_types.h
  group se_hostlib-sss-src
    ../../../../../../middleware/se_hostlib/sss/src/: fsl_sss_apis.c fsl_sss_util_asn1_der.c fsl_sss_util_rsa_sign_utils.c
  group se_hostlib-sss-src-se05x
    ../../../../../../middleware/se_hostlib/sss/src/se05x/: fsl_sss_se05x_apis.c fsl_sss_se05x_eckey.c fsl_sss_se05x_mw.c fsl_sss_se05x_policy.c fsl_sss_se05x_scp03.c
  group se_hostlib-hostlib-hostLib-platform-inc
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/platform/inc/: ax_reset.h i2c_a7.h se05x_apis.h se_pit_config.h se_reset_config.h sm_printf.h sm_timer.h
  group se_hostlib-hostlib-hostLib-platform-ksdk
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/platform/ksdk/: ax_reset.c i2c_frdm.c i2c_imxrt10xx.c i2c_lpc54xxx.c i2c_lpc55sxx.c se05x_reset.c timer_kinetis.c timer_kinetis_bm.c timer_kinetis_freertos.c
  group se_hostlib-hostlib-hostLib-libCommon-smCom-T1oI2C
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/T1oI2C/: phEseStatus.h phEseTypes.h phNxpEsePal_i2c.c phNxpEsePal_i2c.h phNxpEseProto7816_3.c phNxpEseProto7816_3.h phNxpEse_Api.c phNxpEse_Api.h phNxpEse_Internal.h
  group se_hostlib-hostlib-hostLib-libCommon-smCom
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/: apduComm.h sci2c_cfg.h smCom.c smCom.h smComT1oI2C.c smComT1oI2C.h
  group se_hostlib-hostlib-hostLib-libCommon-infra
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/infra/: a71_debug.h app_boot.h app_boot_nfc.h global_platf.c global_platf.h nxLog.c nxLog.h nxLog_App.h nxLog_DefaultConfig.h nxLog_UseCases.h nxLog_VCOM.h nxLog_hostLib.h nxLog_mbedtls.h nxLog_scp.h nxLog_smCom.h nxLog_sscp.h nxLog_sss.h sm_apdu.c sm_apdu.h sm_api.h sm_connect.c sm_demo_utils.h sm_errors.c sm_errors.h sm_printf.c sm_types.h sm_demo_utils.c sm_demo_utils_rtos.c
  group se_hostlib-sss-ex-inc
    ../../../../../../middleware/se_hostlib/sss/ex/inc/: ex_a71ch_scp03.h ex_scp03_puf.h ex_sss.h ex_sss_auth.h ex_sss_boot.h ex_sss_main_freeRTOS_inc.h ex_sss_main_inc.h ex_sss_main_inc_frdmk64f.h ex_sss_main_inc_imx_rt.h ex_sss_main_inc_ksdk.h ex_sss_main_inc_linux.h ex_sss_main_inc_lpcxpresso55s.h ex_sss_objid.h ex_sss_ports.h ex_sss_scp03_keys.h ex_sss_tp_scp03_keys.h
  group se_hostlib-sss-ex-src
    ../../../../../../middleware/se_hostlib/sss/ex/src/: ex_sss_boot.c ex_sss_boot_connectstring.c ex_sss_boot_int.h ex_sss_se05x.c ex_sss_se05x_auth.c
  group se_hostlib-hostlib-hostLib-se05x_03_xx_xx
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/se05x_03_xx_xx/: se05x_APDU.c se05x_APDU.h se05x_APDU_apis.h se05x_APDU_impl.h
  group se_hostlib-hostlib-hostLib-libCommon-nxScp
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/nxScp/: nxScp03_Com.c
  group se_hostlib-hostlib-hostLib-libCommon-scp
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/scp/: scp.c
  group se_hostlib-demos-ksdk-common-boards-lpcxpresso55s69-se_hostlib_examples-cloud_demo
    ../../../../../../middleware/se_hostlib/demos/ksdk/common/boards/lpcxpresso55s69/se_hostlib_examples/cloud_demo/: pin_mux.c pin_mux.h
  group se_hostlib-demos-ksdk-common-freertos
    ../../../../../../middleware/se_hostlib/demos/ksdk/common/freertos/: FreeRTOSConfig.c
  group se_hostlib-demos-ksdk-common-freertos-boards-lpcxpresso55s69
    ../../../../../../middleware/se_hostlib/demos/ksdk/common/freertos/boards/lpcxpresso55s69/: FreeRTOSIPConfig.h app.h aws_bufferpool_config.h aws_mqtt_config.h aws_secure_sockets_config.h iot_mqtt_agent_config.h
  group se_hostlib-demos-ksdk-common-https_client
    ../../../../../../middleware/se_hostlib/demos/ksdk/common/https_client/: httpsclient.h
  group se_hostlib-hostlib-hostLib-tstUtil
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/tstUtil/: tstHostCrypto.h
  group se_hostlib-sss-plugin-pkcs11
    ../../../../../../middleware/se_hostlib/sss/plugin/pkcs11/: aws_pkcs11_pal.c pkcs11_mbedtls_utils.c pkcs11_mbedtls_utils.h
  group freertos-libraries-abstractions-pkcs11-mbedtls
    ../../../../../../rtos/freertos/libraries/abstractions/pkcs11/mbedtls/: threading_alt.h
  group freertos-libraries-abstractions-platform-freertos-include-platform
    ../../../../../../rtos/freertos/libraries/abstractions/platform/freertos/include/platform/: iot_network_ble.h iot_network_freertos.h iot_platform_types_freertos.h
  group freertos-libraries-abstractions-platform-freertos
    ../../../../../../rtos/freertos/libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_metrics.c iot_network_freertos.c iot_threads_freertos.c
  group freertos-libraries-abstractions-platform-include-platform
    ../../../../../../rtos/freertos/libraries/abstractions/platform/include/platform/: iot_clock.h iot_metrics.h iot_network.h iot_threads.h
  group freertos-libraries-abstractions-platform-include-types
    ../../../../../../rtos/freertos/libraries/abstractions/platform/include/types/: iot_platform_types.h
  group freertos-libraries-freertos_plus-standard-tls-include
    ../../../../../../rtos/freertos/libraries/freertos_plus/standard/tls/include/: iot_tls.h
  group freertos-libraries-freertos_plus-standard-tls-src
    ../../../../../../rtos/freertos/libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group freertos-libraries-freertos_plus-standard-pkcs11-include
    ../../../../../../rtos/freertos/libraries/freertos_plus/standard/pkcs11/include/: iot_pkcs11.h
  group freertos-libraries-freertos_plus-standard-pkcs11-src
    ../../../../../../rtos/freertos/libraries/freertos_plus/standard/pkcs11/src/: iot_pkcs11.c
  group freertos-libraries-freertos_plus-standard-crypto-include
    ../../../../../../rtos/freertos/libraries/freertos_plus/standard/crypto/include/: iot_crypto.h
  group freertos-libraries-freertos_plus-standard-crypto-src
    ../../../../../../rtos/freertos/libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group freertos-libraries-freertos_plus-standard-utils-include
    ../../../../../../rtos/freertos/libraries/freertos_plus/standard/utils/include/: iot_pki_utils.h iot_system_init.h
  group freertos-libraries-freertos_plus-standard-utils-src
    ../../../../../../rtos/freertos/libraries/freertos_plus/standard/utils/src/: iot_pki_utils.c iot_system_init.c
  group freertos-libraries-c_sdk-standard-common-include
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/: iot_appversion32.h iot_atomic.h iot_init.h iot_linear_containers.h iot_logging_setup.h iot_logging_task.h iot_taskpool.h
  group freertos-libraries-c_sdk-standard-common-include-private
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/private/: iot_default_root_certificates.h iot_doubly_linked_list.h iot_error.h iot_lib_init.h iot_logging.h iot_static_memory.h iot_taskpool_internal.h
  group freertos-libraries-c_sdk-standard-common-include-types
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/types/: iot_network_types.h iot_taskpool_types.h
  group freertos-libraries-c_sdk-standard-common
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/common/: iot_device_metrics.c iot_init.c iot_static_memory_common.c
  group freertos-libraries-c_sdk-standard-common-logging
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/common/logging/: iot_logging.c iot_logging_task_dynamic_buffers.c
  group freertos-libraries-c_sdk-standard-common-taskpool
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group freertos-libraries-c_sdk-standard-mqtt-include
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/include/: iot_mqtt.h iot_mqtt_agent.h iot_mqtt_agent_config_defaults.h iot_mqtt_config_defaults.h iot_mqtt_lib.h
  group freertos-libraries-c_sdk-standard-mqtt-include-types
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/include/types/: iot_mqtt_types.h
  group freertos-libraries-c_sdk-standard-mqtt-src
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/src/: iot_mqtt_agent.c iot_mqtt_api.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_serialize.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_validate.c
  group freertos-libraries-c_sdk-standard-mqtt-src-private
    ../../../../../../rtos/freertos/libraries/c_sdk/standard/mqtt/src/private/: iot_mqtt_internal.h
  group freertos-libraries-3rdparty-pkcs11
    ../../../../../../rtos/freertos/libraries/3rdparty/pkcs11/: CONTRIBUTING.md LICENSE.md README.md pkcs11.h pkcs11f.h pkcs11t.h
  group freertos-libraries-3rdparty-jsmn
    ../../../../../../rtos/freertos/libraries/3rdparty/jsmn/: jsmn.c jsmn.h
  group se_hostlib-sss-plugin-mbedtls
    ../../../../../../middleware/se_hostlib/sss/plugin/mbedtls/: ecdh_alt_ax.c ecp_alt_sss.c sss_mbedtls.c sss_mbedtls_rsa.c ecp_alt.h rsa_alt.h sss_mbedtls.h sss_mbedtls_evkbimxrt1050_config.h sss_mbedtls_frdmk64f_config.h sss_mbedtls_frdmkw41z_config.h sss_mbedtls_lpcxpresso55s69_config.h sss_mbedtls_x86_config.h
  group se_hostlib-hostlib-hostLib-mbedtls-inc
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/mbedtls/inc/: a71ch_mbedtls_evkbimxrt1050_config.h a71ch_mbedtls_evkmimxrt1050_config.h a71ch_mbedtls_frdm_config.h a71ch_mbedtls_frdmk64f_config.h a71ch_mbedtls_frdmk82f_config.h a71ch_mbedtls_frdmkw41z_config.h a71ch_mbedtls_lpc54018iotmodule_config.h a71ch_mbedtls_lpcxpresso54018_config.h a71ch_mbedtls_lpcxpresso55s69_config.h a71ch_mbedtls_pi_config.h a71ch_mbedtls_x86_config.h ax_mbedtls.h ecp_alt.h
  group se_hostlib-hostlib-hostLib-mbedtls-src
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/mbedtls/src/: ecdh_alt.c rsa_alt.c
  group se_hostlib-sss-src-mbedtls
    ../../../../../../middleware/se_hostlib/sss/src/mbedtls/: fsl_sss_mbedtls_apis.c
target se_SE05x_cloud_gcp release (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: se_SE05x_cloud_gcp.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_LPC55S69JBD100_cm33_core0, LPC_55x=1, GCP_IOT, SSS_HAVE_GCP, PRINTF_ADVANCED_ENABLE=1, LPC_WIFI, WIFISHIELD_IS=WIFISHIELD_IS_SILEX2401, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS, A_LITTLE_ENDIAN, SDK_DEBUGCONSOLE_UART, T1oI2C, T1oI2C_UM11225, SSS_USE_FTR_FILE, NO_SECURE_CHANNEL_SUPPORT, MBEDTLS, SDK_OS_FREE_RTOS, USE_RTOS, mqttconfigENABLE_METRICS=0, MBEDTLS_CONFIG_FILE='\"sss_mbedtls_frdmk64f_config.h\"', SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: as above
