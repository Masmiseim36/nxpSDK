# Keil uVision project se_hostlib_vcomSE050.uvprojx, settings and files
target se_hostlib_vcomSE050 debug (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: se_hostlib_vcomSE050.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_LPC55S69JBD100_cm33_core0, LPC_55x=1, SDK_DEBUGCONSOLE_UART, USB_STACK_BM, USB_ISR_REDIRECT, PRINTF_ADVANCED_ENABLE=1, SERIAL_PORT_TYPE_USBCDC=1, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, USB_DEVICE_CONFIG_CDC_ACM=1, MBEDTLS_CONFIG_FILE='\"sss_mbedtls_frdmk64f_config.h\"', MBEDTLS, SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC, SERIAL_PORT_TYPE_UART=1, T1oI2C, T1oI2C_UM11225, SSS_USE_FTR_FILE, NO_SECURE_CHANNEL_SUPPORT
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../se_hostlib_vcomSE050/cm33_core0;..;../..;../../../../../../middleware/se_hostlib/hostlib/hostLib/vcom/ksdk;../../../../../../middleware/se_hostlib/demos/ksdk/se050/default;../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom;../../../../../../middleware/se_hostlib/sss/inc;../../../../../../middleware/se_hostlib/sss/port/ksdk;../../../../../../middleware/mbedtls/include/mbedtls;../../../../../../middleware/se_hostlib/hostlib/hostLib/se05x_03_xx_xx;../../../../../../middleware/se_hostlib/sss/ex/inc;../../../mainA71CH;../../../../../../middleware/se_hostlib/sss/plugin/mbedtls;../../../../../../middleware/se_hostlib/hostlib/hostLib/tstUtil;../../../../../../middleware/se_hostlib/hostlib/hostLib/mbedtls/inc;../../../../../../middleware/se_hostlib/demos/ksdk/common;../../../../../../middleware/se_hostlib/hostlib/hostLib/platform/inc;../../../../../../middleware/se_hostlib/demos/ksdk/common/boards/lpcxpresso55s69/se_hostlib_examples/cloud_demo;../../../../../../middleware/usb/include;../../../..;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/LPC55S69;../../../../../../middleware/mbedtls/include;../../../../../../middleware/mbedtls/port/ksdk;../../../../../../devices/LPC55S69/drivers;../../../../../../components/osa;../../../../../../middleware/usb/device;../../../../../../components/serial_manager/usb_cdc_adapter;../../../../../../devices/LPC55S69/utilities/str;../../../../../../devices/LPC55S69/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../middleware/usb/output/source/device/class;../../../../../../middleware/usb/output/source/device;../../../../../../middleware/se_hostlib;../../../../../../middleware/se_hostlib/hostlib/hostLib/inc;../../../../../../middleware/se_hostlib/platform;../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/T1oI2C;../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/infra;../../../../../../devices/LPC55S69/utilities
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: ../../../../../../devices/LPC55S69/arm/keil_lib_power_cm33_core0.lib --remove --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x8000"
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source
    ../: fsl_sss_ftr.h smComT1oI2C.h smComSCI2C.h vcom2i2c.c vcom2i2c.h virtual_com.c virtual_com.h se_pit_config.c
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/LPC55S69/drivers/: fsl_casper.c fsl_casper.h fsl_hashcrypt.c fsl_hashcrypt.h fsl_rng.c fsl_rng.h fsl_i2c.c fsl_i2c.h fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_iocon.h fsl_gpio.c fsl_gpio.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h
  group usb-device-include
    ../../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group usb-device-source
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h usb_device_dci.h
    ../../../../../../middleware/usb/output/source/device/: usb_device_ch9.c usb_device_ch9.h
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group usb-device-source-lpcip3511
    ../../../../../../middleware/usb/device/: usb_device_lpcip3511.c usb_device_lpcip3511.h
  group component-serial_manager
    ../../../../../../components/serial_manager/: serial_port_usb.c serial_port_usb.h serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-serial_manager-usb_cdc_adapter
    ../../../../../../components/serial_manager/usb_cdc_adapter/: usb_device_descriptor.c usb_device_descriptor.h
    ../: usb_device_config.h
  group se_hostlib-sss-plugin-mbedtls
    ../../../../../../middleware/se_hostlib/sss/plugin/mbedtls/: ecdh_alt_ax.c ecp_alt_sss.c sss_mbedtls.c sss_mbedtls_rsa.c ecp_alt.h rsa_alt.h sss_mbedtls.h sss_mbedtls_evkbimxrt1050_config.h sss_mbedtls_frdmk64f_config.h sss_mbedtls_frdmkw41z_config.h sss_mbedtls_lpcxpresso55s69_config.h sss_mbedtls_x86_config.h
  group mbedtls-include-mbedtls
    ../../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls-library
    ../../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls-port-ksdk
    ../../../../../../middleware/mbedtls/port/ksdk/: aes_alt.c aes_alt.h des_alt.c des_alt.h ecp_alt.c ecp_alt.h ecp_alt_ksdk.c ecp_curves_alt.c ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h
  group device
    ../../../../../../devices/LPC55S69/: LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h fsl_device_registers.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group startup
    ../../../../../../devices/LPC55S69/arm/: startup_LPC55S69_cm33_core0.S
  group utilities
    ../../../../../../devices/LPC55S69/utilities/: fsl_assert.c
    ../../../../../../devices/LPC55S69/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group component-uart
    ../../../../../../components/uart/: uart.h usart_adapter.c
  group component-lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
  group usb-include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group usb-device-class-cdc
    ../../../../../../middleware/usb/output/source/device/class/: usb_device_cdc_acm.c usb_device_cdc_acm.h
  group usb-device-class
    ../../../../../../middleware/usb/output/source/device/class/: usb_device_class.c usb_device_class.h
  group se_hostlib-hostlib-hostLib-inc
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/inc/: Applet_SE050_Ver.h HLSEAPI.h HLSEComm.h HLSECrypto.h HLSEMisc.h HLSEObjects.h HLSETypes.h PlugAndTrust_HostLib_Ver.h PlugAndTrust_Pkg_Ver.h SE_HAL_Lib.h a71ch_api.h a71ch_util.h a71cl_api.h a71cl_util.h ax_api.h ax_common.h ax_common_a71ch.h ax_common_a71cl.h ax_common_private.h ax_scp.h ax_scp_private.h ax_sss_scp.h ax_util.h ledHandler.h nxEnsure.h nxScp03_Apis.h nxScp03_Const.h nxScp03_Types.h scp.h se05x_const.h se05x_ecc_curves.h se05x_ecc_curves_inc.h se05x_ecc_curves_values.h se05x_enums.h se05x_ftr.h se05x_tlv.h sm_const.h
  group se_hostlib-hostlib-hostLib-se05x-src
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/se05x/src/: se05x_ECC_curves.c se05x_mw.c se05x_tlv.c
  group se_hostlib-sss-inc
    ../../../../../../middleware/se_hostlib/sss/inc/: fsl_sscp.h fsl_sscp_a71ch.h fsl_sscp_a71cl.h fsl_sscp_commands.h fsl_sscp_mu.h fsl_sss_api.h fsl_sss_api_ver.h fsl_sss_config.h fsl_sss_ftr_default.h fsl_sss_keyid_map.h fsl_sss_lpc55s_apis.h fsl_sss_lpc55s_types.h fsl_sss_mbedtls_apis.h fsl_sss_mbedtls_types.h fsl_sss_openssl_apis.h fsl_sss_openssl_types.h fsl_sss_policy.h fsl_sss_se05x_apis.h fsl_sss_se05x_policy.h fsl_sss_se05x_scp03.h fsl_sss_se05x_types.h fsl_sss_sscp.h fsl_sss_sscp_config.h fsl_sss_user_apis.h fsl_sss_user_types.h fsl_sss_util_asn1_der.h fsl_sss_util_rsa_sign_utils.h
  group se_hostlib-sss-port-ksdk
    ../../../../../../middleware/se_hostlib/sss/port/ksdk/: fsl_sss_types.h
  group se_hostlib-sss-src
    ../../../../../../middleware/se_hostlib/sss/src/: fsl_sss_apis.c fsl_sss_util_asn1_der.c fsl_sss_util_rsa_sign_utils.c
  group se_hostlib-sss-src-se05x
    ../../../../../../middleware/se_hostlib/sss/src/se05x/: fsl_sss_se05x_apis.c fsl_sss_se05x_eckey.c fsl_sss_se05x_mw.c fsl_sss_se05x_policy.c fsl_sss_se05x_scp03.c
  group se_hostlib-hostlib-hostLib-platform-inc
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/platform/inc/: ax_reset.h i2c_a7.h se05x_apis.h se_pit_config.h se_reset_config.h sm_printf.h sm_timer.h
  group se_hostlib-hostlib-hostLib-platform-ksdk
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/platform/ksdk/: ax_reset.c i2c_frdm.c i2c_imxrt10xx.c i2c_lpc54xxx.c i2c_lpc55sxx.c se05x_reset.c timer_kinetis.c timer_kinetis_bm.c timer_kinetis_freertos.c
  group se_hostlib-hostlib-hostLib-libCommon-smCom-T1oI2C
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/T1oI2C/: phEseStatus.h phEseTypes.h phNxpEsePal_i2c.c phNxpEsePal_i2c.h phNxpEseProto7816_3.c phNxpEseProto7816_3.h phNxpEse_Api.c phNxpEse_Api.h phNxpEse_Internal.h
  group se_hostlib-hostlib-hostLib-libCommon-smCom
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/: apduComm.h sci2c_cfg.h smCom.c smCom.h smComT1oI2C.c smComT1oI2C.h
  group se_hostlib-hostlib-hostLib-libCommon-infra
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/infra/: a71_debug.h app_boot.h app_boot_nfc.h global_platf.c global_platf.h nxLog.c nxLog.h nxLog_App.h nxLog_DefaultConfig.h nxLog_UseCases.h nxLog_VCOM.h nxLog_hostLib.h nxLog_mbedtls.h nxLog_scp.h nxLog_smCom.h nxLog_sscp.h nxLog_sss.h sm_apdu.c sm_apdu.h sm_api.h sm_connect.c sm_demo_utils.h sm_errors.c sm_errors.h sm_printf.c sm_types.h
  group se_hostlib-sss-ex-inc
    ../../../../../../middleware/se_hostlib/sss/ex/inc/: ex_a71ch_scp03.h ex_scp03_puf.h ex_sss.h ex_sss_auth.h ex_sss_boot.h ex_sss_main_freeRTOS_inc.h ex_sss_main_inc.h ex_sss_main_inc_frdmk64f.h ex_sss_main_inc_imx_rt.h ex_sss_main_inc_ksdk.h ex_sss_main_inc_linux.h ex_sss_main_inc_lpcxpresso55s.h ex_sss_objid.h ex_sss_ports.h ex_sss_scp03_keys.h ex_sss_tp_scp03_keys.h
  group se_hostlib-sss-ex-src
    ../../../../../../middleware/se_hostlib/sss/ex/src/: ex_sss_boot.c ex_sss_boot_connectstring.c ex_sss_boot_int.h ex_sss_se05x.c ex_sss_se05x_auth.c
  group se_hostlib-hostlib-hostLib-se05x_03_xx_xx
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/se05x_03_xx_xx/: se05x_APDU.c se05x_APDU.h se05x_APDU_apis.h se05x_APDU_impl.h
  group se_hostlib-hostlib-hostLib-libCommon-nxScp
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/nxScp/: nxScp03_Com.c
  group se_hostlib-hostlib-hostLib-libCommon-scp
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/scp/: scp.c
  group se_hostlib-hostlib-hostLib-mbedtls-inc
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/mbedtls/inc/: a71ch_mbedtls_evkbimxrt1050_config.h a71ch_mbedtls_evkmimxrt1050_config.h a71ch_mbedtls_frdm_config.h a71ch_mbedtls_frdmk64f_config.h a71ch_mbedtls_frdmk82f_config.h a71ch_mbedtls_frdmkw41z_config.h a71ch_mbedtls_lpc54018iotmodule_config.h a71ch_mbedtls_lpcxpresso54018_config.h a71ch_mbedtls_lpcxpresso55s69_config.h a71ch_mbedtls_pi_config.h a71ch_mbedtls_x86_config.h ax_mbedtls.h ecp_alt.h
  group se_hostlib-hostlib-hostLib-mbedtls-src
    ../../../../../../middleware/se_hostlib/hostlib/hostLib/mbedtls/src/: ecdh_alt.c rsa_alt.c
  group se_hostlib-sss-src-mbedtls
    ../../../../../../middleware/se_hostlib/sss/src/mbedtls/: fsl_sss_mbedtls_apis.c
target se_hostlib_vcomSE050 release (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: se_hostlib_vcomSE050.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_LPC55S69JBD100_cm33_core0, LPC_55x=1, SDK_DEBUGCONSOLE_UART, USB_STACK_BM, USB_ISR_REDIRECT, PRINTF_ADVANCED_ENABLE=1, SERIAL_PORT_TYPE_USBCDC=1, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, USB_DEVICE_CONFIG_CDC_ACM=1, MBEDTLS_CONFIG_FILE='\"sss_mbedtls_frdmk64f_config.h\"', MBEDTLS, SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC, SERIAL_PORT_TYPE_UART=1, T1oI2C, T1oI2C_UM11225, SSS_USE_FTR_FILE, NO_SECURE_CHANNEL_SUPPORT
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: as above
