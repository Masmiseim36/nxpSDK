# Keil uVision project tfm_demo_ns.uvprojx, settings and files
target tfm_demo_ns debug (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tfm_demo_ns.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_LPC55S69JBD100_cm33_core0, TFM_LVL=2, __DOMAIN_NS=1, DOMAIN_NS=1, TFM_PARTITION_AUDIT_LOG, TFM_PARTITION_PLATFORM, TFM_PARTITION_SECURE_STORAGE, TFM_PARTITION_INTERNAL_TRUSTED_STORAGE, TFM_PARTITION_CRYPTO, TFM_PARTITION_INITIAL_ATTESTATION, TFM_PSA_API, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../tfm_demo_s;../../../tfm_demo_ns;../../../../..;../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../devices/LPC55S69;../../../tfm_demo_s;../../../../../../../devices/LPC55S69/drivers;../../../../../../../middleware/tfm;../../../../../../../middleware/tfm/interface/include;../../../../../../../CMSIS/RTOS2/Include;../../../../../../../middleware/tfm/app;../../../../../../../middleware/tfm/platform/include;../../../../../../../middleware/tfm/platform/ext/driver;../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69;../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/Device/Config;../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/Device/Include;../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/partition;../../../../../../../middleware/tfm/secure_fw/core;../../../../../../../middleware/tfm/secure_fw/core/include;../../../../../../../middleware/tfm/secure_fw/include;../../../../../../../middleware/tfm/secure_fw/core/arch/include;../../../../../../../middleware/tfm/platform/ext/target/nxp/common/os/rtx;../../../../../../../devices/LPC55S69/utilities/str;../../../../../../../devices/LPC55S69/utilities/debug_console;../../../../../../../components/uart;../../../../../../../components/serial_manager;../../../../../../../components/lists;../../../../../../../devices/LPC55S69/utilities
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/Device/Source/armclang/LPC55S69_cm33_core0_ns.sct
  link misc: ../../tfm_demo_s/mdk/debug/tfm_demo_s_CMSE_lib.o ../../../../../../../CMSIS/RTOS2/RTX/Library/ARM/RTX_V8MMFN.lib ../../../../../../../devices/LPC55S69/arm/keil_lib_power_cm33_core0.lib --remove
  group startup
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/Device/Source/armclang/: startup_LPC55S69_cm33_core0_ns.S
  group source
    ../../../../../../../middleware/tfm/app/: main_ns.c tfm_integ_test.h
  group board
    ../: pin_mux.c pin_mux.h hardware_init.c app.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/LPC55S69/drivers/: fsl_iocon.h fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_power.c fsl_power.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_reset.c fsl_reset.h
  group RTOS2-Include
    ../../../../../../../CMSIS/RTOS2/Include/: cmsis_os2.h
  group tfm-app
    ../../../../../../../middleware/tfm/app/: os_wrapper_cmsis_rtos_v2.c uart_stdout.h
  group tfm-bl2-include
    ../../../../../../../middleware/tfm/bl2/include/: tfm_boot_status.h
  group tfm-interface-include-log
    ../../../../../../../middleware/tfm/interface/include/log/: tfm_assert.h tfm_log.h tfm_log_raw.h
  group tfm-interface-include-os_wrapper
    ../../../../../../../middleware/tfm/interface/include/os_wrapper/: common.h mutex.h semaphore.h thread.h
  group tfm-interface-include-psa
    ../../../../../../../middleware/tfm/interface/include/psa/: client.h crypto.h crypto_compat.h crypto_extra.h crypto_platform.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h error.h initial_attestation.h internal_trusted_storage.h lifecycle.h protected_storage.h service.h storage_common.h
  group tfm-interface-include
    ../../../../../../../middleware/tfm/interface/include/: tfm_api.h tfm_crypto_defs.h tfm_its_defs.h tfm_mailbox.h tfm_ns_interface.h tfm_ns_mailbox.h tfm_ns_svc.h tfm_nspm_api.h tfm_nspm_svc_handler.h tfm_platform_api.h tfm_sst_defs.h tfm_veneers.h
  group tfm-interface-src-log
    ../../../../../../../middleware/tfm/interface/src/log/: tfm_log_raw.c
  group tfm-interface-src
    ../../../../../../../middleware/tfm/interface/src/: tfm_ns_interface.c tfm_crypto_ipc_api.c tfm_initial_attestation_ipc_api.c tfm_its_ipc_api.c tfm_platform_ipc_api.c tfm_psa_ns_api.c tfm_sst_ipc_api.c
  group tfm-platform-ext-common
    ../../../../../../../middleware/tfm/platform/ext/common/: uart_stdout.h
  group tfm-platform-ext-driver
    ../../../../../../../middleware/tfm/platform/ext/driver/: Driver_Common.h Driver_USART.h
  group tfm-platform-ext-target-nxp-common-CMSIS_Driver
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/common/CMSIS_Driver/: Driver_USART.c
  group tfm-platform-ext-target-nxp-lpcxpresso55s69-Device-Config
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/Device/Config/: device_cfg.h
  group tfm-platform-ext-target-nxp-lpcxpresso55s69-Device-Include
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/Device/Include/: cmsis.h device_definition.h platform_base_address.h platform_irq.h platform_regs.h
  group tfm-platform-ext-target-nxp-lpcxpresso55s69-partition
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/partition/: flash_layout.h region_defs.h
  group tfm-platform-ext-target-nxp-lpcxpresso55s69
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/: target_cfg.h tfm_peripherals_def.h
  group tfm-platform-include
    ../../../../../../../middleware/tfm/platform/include/: tfm_hal_device_header.h tfm_plat_boot_seed.h tfm_plat_crypto_keys.h tfm_plat_defs.h tfm_plat_device_id.h tfm_plat_ns.h tfm_plat_test.h
  group tfm-secure_fw-core-arch-include
    ../../../../../../../middleware/tfm/secure_fw/core/arch/include/: tfm_arch.h tfm_arch_v8m.h
  group tfm-secure_fw-core-include
    ../../../../../../../middleware/tfm/secure_fw/core/include/: secure_utilities.h tfm_core.h tfm_utils.h
  group tfm-secure_fw-include-core
    ../../../../../../../middleware/tfm/secure_fw/include/core/: tfm_core_svc.h
  group tfm-interface-include-psa_manifest
    ../../../../../../../middleware/tfm/interface/include/psa_manifest/: sid.h
  group tfm-platform-ext-target-nxp-common-os-rtx
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/common/os/rtx/: RTX_Config.c RTX_Config.h rtx_lib.c rtx_os.h
  group device
    ../../../../../../../devices/LPC55S69/: LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h fsl_device_registers.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group utilities
    ../../../../../../../devices/LPC55S69/utilities/: fsl_assert.c
    ../../../../../../../devices/LPC55S69/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group component-uart
    ../../../../../../../components/uart/: uart.h usart_adapter.c
  group component-serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
target tfm_demo_ns release (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tfm_demo_ns.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_LPC55S69JBD100_cm33_core0, TFM_LVL=2, __DOMAIN_NS=1, DOMAIN_NS=1, TFM_PARTITION_AUDIT_LOG, TFM_PARTITION_PLATFORM, TFM_PARTITION_SECURE_STORAGE, TFM_PARTITION_INTERNAL_TRUSTED_STORAGE, TFM_PARTITION_CRYPTO, TFM_PARTITION_INITIAL_ATTESTATION, TFM_PSA_API, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: as above
  link misc: ../../tfm_demo_s/mdk/release/tfm_demo_s_CMSE_lib.o ../../../../../../../CMSIS/RTOS2/RTX/Library/ARM/RTX_V8MMFN.lib ../../../../../../../devices/LPC55S69/arm/keil_lib_power_cm33_core0.lib --remove
