# Keil uVision project tfm_psatest_ns.uvprojx, settings and files
target tfm_psatest_ns debug (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tfm_psatest_ns.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_LPC55S69JBD100_cm33_core0, TFM_LVL=2, PSA_API_TEST_NS=1, __DOMAIN_NS=1, DOMAIN_NS=1, TFM_PARTITION_PLATFORM, TFM_PARTITION_SECURE_STORAGE, TFM_PARTITION_INTERNAL_TRUSTED_STORAGE, TFM_PARTITION_CRYPTO, TFM_PARTITION_INITIAL_ATTESTATION, TFM_PSA_API, INITIAL_ATTESTATION, CRYPTO, PROTECTED_STORAGE, PS_TEST, SERIAL_PORT_TYPE_UART=1
  c misc: -Wno-disabled-macro-expansion  -Wno-shift-sign-overflow  -Wno-used-but-marked-unused  -Wno-assign-enum  -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../tfm_psatest_s;../../../tfm_psatest_ns;../../../../..;../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../devices/LPC55S69;../../../tfm_psatest_s;../../../../../../../devices/LPC55S69/drivers;../../../../../../../middleware/tfm;../../../../../../../middleware/tfm/interface/include;../../../../../../../CMSIS/RTOS2/Include;../../../../../../../middleware/tfm/app;../../../../../../../middleware/tfm/platform/include;../../../../../../../middleware/tfm/platform/ext/driver;../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69;../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/Device/Config;../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/Device/Include;../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/partition;../../../../../../../middleware/tfm/secure_fw/core;../../../../../../../middleware/tfm/secure_fw/core/include;../../../../../../../middleware/tfm/secure_fw/include;../../../../../../../middleware/tfm/secure_fw/core/arch/include;../../../../../../../middleware/tfm/platform/ext/target/nxp/common/os/rtx;../../../../../../../middleware/psa-arch-tests/api-tests/val/common;../../../../../../../middleware/psa-arch-tests/api-tests/val/nspe;../../../../../../../middleware/psa-arch-tests/api-tests/platform/targets/tgt_dev_apis_tfm_nxp/nspe/common;../../../../../../../middleware/psa-arch-tests/api-tests/platform/targets/tgt_dev_apis_tfm_nxp/nspe/crypto;../../../../../../../middleware/psa-arch-tests/api-tests/platform/drivers/nvmem;../../../../../../../middleware/psa-arch-tests/api-tests/val;../../../../../../../middleware/tfm/lib/ext/qcbor/inc;../../../../../../../middleware/tfm/lib/ext/qcbor/util;../../../../../../../middleware/tfm/lib/ext/t_cose/inc;../../../../../../../middleware/tfm/secure_fw/services/initial_attestation;../../../../../../../devices/LPC55S69/utilities/str;../../../../../../../devices/LPC55S69/utilities/debug_console;../../../../../../../components/uart;../../../../../../../components/serial_manager;../../../../../../../components/lists;../../../../../../../devices/LPC55S69/utilities
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/Device/Source/armclang/LPC55S69_cm33_core0_ns.sct
  link misc: ../../tfm_psatest_s/mdk/debug/tfm_psatest_s_CMSE_lib.o ../../../../../../../CMSIS/RTOS2/RTX/Library/ARM/RTX_V8MMFN.lib ../../../../../../../devices/LPC55S69/arm/keil_lib_power_cm33_core0.lib --remove
  group startup
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/Device/Source/armclang/: startup_LPC55S69_cm33_core0_ns.S
  group source
    ../../../../../../../middleware/tfm/app/: main_ns.c
  group tfm-app
    ../../../../../../../middleware/tfm/app/: tfm_integ_test.h psa_api_test.c psa_api_test.h os_wrapper_cmsis_rtos_v2.c uart_stdout.h
  group board
    ../: pin_mux.c pin_mux.h hardware_init.c app.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/LPC55S69/drivers/: fsl_rng.c fsl_rng.h fsl_iap.c fsl_iap.h fsl_iap_ffr.h fsl_iap_kbp.h fsl_iap_skboot_authenticate.h fsl_iocon.h fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_power.c fsl_power.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_reset.c fsl_reset.h
  group RTOS2-Include
    ../../../../../../../CMSIS/RTOS2/Include/: cmsis_os2.h
  group tfm-bl2-include
    ../../../../../../../middleware/tfm/bl2/include/: tfm_boot_status.h
  group tfm-interface-include-log
    ../../../../../../../middleware/tfm/interface/include/log/: tfm_assert.h tfm_log.h tfm_log_raw.h
  group tfm-interface-include-os_wrapper
    ../../../../../../../middleware/tfm/interface/include/os_wrapper/: common.h mutex.h semaphore.h thread.h
  group tfm-interface-include-psa
    ../../../../../../../middleware/tfm/interface/include/psa/: client.h crypto.h crypto_compat.h crypto_extra.h crypto_platform.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h error.h initial_attestation.h internal_trusted_storage.h lifecycle.h protected_storage.h service.h storage_common.h
  group tfm-interface-include
    ../../../../../../../middleware/tfm/interface/include/: tfm_api.h tfm_crypto_defs.h tfm_its_defs.h tfm_mailbox.h tfm_ns_interface.h tfm_ns_mailbox.h tfm_ns_svc.h tfm_nspm_api.h tfm_nspm_svc_handler.h tfm_platform_api.h tfm_sst_defs.h tfm_veneers.h
  group tfm-interface-src-log
    ../../../../../../../middleware/tfm/interface/src/log/: tfm_log_raw.c
  group tfm-interface-src
    ../../../../../../../middleware/tfm/interface/src/: tfm_ns_interface.c tfm_crypto_ipc_api.c tfm_initial_attestation_ipc_api.c tfm_its_ipc_api.c tfm_platform_ipc_api.c tfm_psa_ns_api.c tfm_sst_ipc_api.c
  group tfm-platform-ext-common
    ../../../../../../../middleware/tfm/platform/ext/common/: uart_stdout.h
  group tfm-platform-ext-driver
    ../../../../../../../middleware/tfm/platform/ext/driver/: Driver_Common.h Driver_USART.h
  group tfm-platform-ext-target-nxp-common-CMSIS_Driver
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/common/CMSIS_Driver/: Driver_USART.c
  group tfm-platform-ext-target-nxp-lpcxpresso55s69-Device-Config
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/Device/Config/: device_cfg.h
  group tfm-platform-ext-target-nxp-lpcxpresso55s69-Device-Include
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/Device/Include/: cmsis.h device_definition.h platform_base_address.h platform_irq.h platform_regs.h
  group tfm-platform-ext-target-nxp-lpcxpresso55s69-partition
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/partition/: flash_layout.h region_defs.h
  group tfm-platform-ext-target-nxp-lpcxpresso55s69
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/: target_cfg.h tfm_peripherals_def.h
  group tfm-platform-include
    ../../../../../../../middleware/tfm/platform/include/: tfm_hal_device_header.h tfm_plat_boot_seed.h tfm_plat_crypto_keys.h tfm_plat_defs.h tfm_plat_device_id.h tfm_plat_ns.h tfm_plat_test.h
  group tfm-secure_fw-core-arch-include
    ../../../../../../../middleware/tfm/secure_fw/core/arch/include/: tfm_arch.h tfm_arch_v8m.h
  group tfm-secure_fw-core-include
    ../../../../../../../middleware/tfm/secure_fw/core/include/: secure_utilities.h tfm_core.h tfm_utils.h
  group tfm-secure_fw-include-core
    ../../../../../../../middleware/tfm/secure_fw/include/core/: tfm_core_svc.h
  group tfm-platform-ext-target-nxp-common-os-rtx
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/common/os/rtx/: RTX_Config.c RTX_Config.h rtx_lib.c rtx_os.h
  group tfm-interface-include-psa_manifest
    ../../../../../../../middleware/tfm/interface/include/psa_manifest/: sid.h
  group psa-arch-tests-api-tests-platform-drivers-nvmem
    ../../../../../../../middleware/psa-arch-tests/api-tests/platform/drivers/nvmem/: pal_nvmem.c pal_nvmem.h
  group psa-arch-tests-api-tests-platform-targets-tgt_dev_apis_tfm_nxp-nspe-common
    ../../../../../../../middleware/psa-arch-tests/api-tests/platform/targets/tgt_dev_apis_tfm_nxp/nspe/common/: pal_client_api_empty_intf.c pal_client_api_intf.h pal_common.h pal_config.h pal_driver_ns_intf.c target_database.c target_database.h
  group psa-arch-tests-api-tests-platform-targets-tgt_dev_apis_tfm_nxp-nspe-crypto
    ../../../../../../../middleware/psa-arch-tests/api-tests/platform/targets/tgt_dev_apis_tfm_nxp/nspe/crypto/: pal_crypto_config.h pal_crypto_config.h pal_crypto_config_check.h pal_crypto_intf.c pal_crypto_intf.h
  group psa-arch-tests-api-tests-val-common
    ../../../../../../../middleware/psa-arch-tests/api-tests/val/common/: val.h val_client_defs.h val_target.c val_target.h
  group psa-arch-tests-api-tests-val-nspe
    ../../../../../../../middleware/psa-arch-tests/api-tests/val/nspe/: pal_interfaces_ns.h val_attestation.c val_attestation.h val_crypto.c val_crypto.h val_dispatcher.c val_dispatcher.h val_entry.c val_entry.h val_framework.c val_framework.h val_interfaces.c val_interfaces.h val_internal_trusted_storage.c val_internal_trusted_storage.h val_peripherals.c val_peripherals.h val_protected_storage.c val_protected_storage.h
  group psa-arch-tests-api-tests-val
    ../../../../../../../middleware/psa-arch-tests/api-tests/val/: test_entry_fn_declare_list.inc test_entry_list.inc
  group psa-arch-tests-api-tests-dev_apis-initial_attestation-test_a001
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/initial_attestation/test_a001/: test_a001.c test_a001.h test_data.h test_entry_a001.c
  group psa-arch-tests-api-tests-platform-targets-tgt_dev_apis_tfm_nxp-nspe-initial_attestation
    ../../../../../../../middleware/psa-arch-tests/api-tests/platform/targets/tgt_dev_apis_tfm_nxp/nspe/initial_attestation/: pal_attestation_crypto.c pal_attestation_crypto.h pal_attestation_eat.h pal_attestation_intf.c pal_attestation_intf.h
  group tfm-lib-ext-qcbor-inc
    ../../../../../../../middleware/tfm/lib/ext/qcbor/inc/: UsefulBuf.h q_useful_buf.h qcbor.h
  group tfm-lib-ext-qcbor-src
    ../../../../../../../middleware/tfm/lib/ext/qcbor/src/: UsefulBuf.c ieee754.c ieee754.h qcbor_decode.c qcbor_encode.c
  group tfm-lib-ext-qcbor-util
    ../../../../../../../middleware/tfm/lib/ext/qcbor/util/: qcbor_util.c qcbor_util.h
  group tfm-lib-ext-t_cose-inc
    ../../../../../../../middleware/tfm/lib/ext/t_cose/inc/: t_cose_common.h t_cose_sign1_sign.h
  group tfm-secure_fw-services-initial_attestation
    ../../../../../../../middleware/tfm/secure_fw/services/initial_attestation/: attest_token.h
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c001
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c001/: test_c001.c test_c001.h test_entry_c001.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c002
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c002/: test_c002.c test_c002.h test_data.h test_entry_c002.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c003
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c003/: test_c003.c test_c003.h test_data.h test_entry_c003.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c004
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c004/: test_c004.c test_c004.h test_data.h test_entry_c004.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c005
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c005/: test_c005.c test_c005.h test_data.h test_entry_c005.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c006
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c006/: test_c006.c test_c006.h test_data.h test_entry_c006.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c007
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c007/: test_c007.c test_c007.h test_data.h test_entry_c007.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c008
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c008/: test_c008.c test_c008.h test_data.h test_entry_c008.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c009
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c009/: test_c009.c test_c009.h test_data.h test_entry_c009.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c010
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c010/: test_c010.c test_c010.h test_data.h test_entry_c010.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c011
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c011/: test_c011.c test_c011.h test_data.h test_entry_c011.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c012
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c012/: test_c012.c test_c012.h test_data.h test_entry_c012.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c013
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c013/: test_c013.c test_c013.h test_data.h test_entry_c013.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c014
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c014/: test_c014.c test_c014.h test_data.h test_entry_c014.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c015
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c015/: test_c015.c test_c015.h test_data.h test_entry_c015.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c016
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c016/: test_c016.c test_c016.h test_data.h test_entry_c016.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c017
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c017/: test_c017.c test_c017.h test_data.h test_entry_c017.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c018
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c018/: test_c018.c test_c018.h test_data.h test_entry_c018.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c019
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c019/: test_c019.c test_c019.h test_data.h test_entry_c019.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c020
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c020/: test_c020.c test_c020.h test_data.h test_entry_c020.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c021
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c021/: test_c021.c test_c021.h test_data.h test_entry_c021.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c022
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c022/: test_c022.c test_c022.h test_data.h test_entry_c022.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c023
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c023/: test_c023.c test_c023.h test_data.h test_entry_c023.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c024
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c024/: test_c024.c test_c024.h test_data.h test_entry_c024.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c025
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c025/: test_c025.c test_c025.h test_data.h test_entry_c025.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c026
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c026/: test_c026.c test_c026.h test_data.h test_entry_c026.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c027
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c027/: test_c027.c test_c027.h test_data.h test_entry_c027.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c028
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c028/: test_c028.c test_c028.h test_data.h test_entry_c028.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c029
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c029/: test_c029.c test_c029.h test_data.h test_entry_c029.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c030
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c030/: test_c030.c test_c030.h test_data.h test_entry_c030.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c031
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c031/: test_c031.c test_c031.h test_data.h test_entry_c031.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c032
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c032/: test_c032.c test_c032.h test_data.h test_entry_c032.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c033
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c033/: test_c033.c test_c033.h test_data.h test_entry_c033.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c034
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c034/: test_c034.c test_c034.h test_data.h test_entry_c034.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c035
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c035/: test_c035.c test_c035.h test_data.h test_entry_c035.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c036
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c036/: test_c036.c test_c036.h test_data.h test_entry_c036.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c037
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c037/: test_c037.c test_c037.h test_data.h test_entry_c037.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c038
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c038/: test_c038.c test_c038.h test_data.h test_entry_c038.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c039
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c039/: test_c039.c test_c039.h test_data.h test_entry_c039.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c040
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c040/: test_c040.c test_c040.h test_data.h test_entry_c040.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c041
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c041/: test_c041.c test_c041.h test_data.h test_entry_c041.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c042
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c042/: test_c042.c test_c042.h test_data.h test_entry_c042.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c043
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c043/: test_c043.c test_c043.h test_data.h test_entry_c043.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c044
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c044/: test_c044.c test_c044.h test_data.h test_entry_c044.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c045
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c045/: test_c045.c test_c045.h test_data.h test_entry_c045.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c046
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c046/: test_c046.c test_c046.h test_data.h test_entry_c046.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c047
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c047/: test_c047.c test_c047.h test_data.h test_entry_c047.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c048
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c048/: test_c048.c test_c048.h test_data.h test_entry_c048.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c049
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c049/: test_c049.c test_c049.h test_data.h test_entry_c049.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c050
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c050/: test_c050.c test_c050.h test_data.h test_entry_c050.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c051
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c051/: test_c051.c test_c051.h test_data.h test_entry_c051.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c052
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c052/: test_c052.c test_c052.h test_data.h test_entry_c052.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c053
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c053/: test_c053.c test_c053.h test_data.h test_entry_c053.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c054
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c054/: test_c054.c test_c054.h test_data.h test_entry_c054.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c055
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c055/: test_c055.c test_c055.h test_data.h test_entry_c055.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c056
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c056/: test_c056.c test_c056.h test_data.h test_entry_c056.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c057
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c057/: test_c057.c test_c057.h test_data.h test_entry_c057.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c058
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c058/: test_c058.c test_c058.h test_data.h test_entry_c058.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c059
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c059/: test_c059.c test_c059.h test_data.h test_entry_c059.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c060
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c060/: test_c060.c test_c060.h test_data.h test_entry_c060.c
  group psa-arch-tests-api-tests-dev_apis-crypto-test_c061
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/crypto/test_c061/: test_c061.c test_c061.h test_data.h test_entry_c061.c
  group psa-arch-tests-api-tests-dev_apis-internal_trusted_storage-test_s001
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/internal_trusted_storage/test_s001/: test_entry_s001.c test_ps_data.h test_s001.c test_s001.h
  group psa-arch-tests-api-tests-dev_apis-internal_trusted_storage-test_s002
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/internal_trusted_storage/test_s002/: test_entry_s002.c test_ps_data.h test_s002.c test_s002.h
  group psa-arch-tests-api-tests-dev_apis-internal_trusted_storage-test_s003
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/internal_trusted_storage/test_s003/: test_entry_s003.c test_ps_data.h test_s003.c test_s003.h
  group psa-arch-tests-api-tests-dev_apis-internal_trusted_storage-test_s004
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/internal_trusted_storage/test_s004/: test_entry_s004.c test_ps_data.h test_s004.c test_s004.h
  group psa-arch-tests-api-tests-dev_apis-internal_trusted_storage-test_s005
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/internal_trusted_storage/test_s005/: test_entry_s005.c test_ps_data.h test_s005.c test_s005.h
  group psa-arch-tests-api-tests-dev_apis-internal_trusted_storage-test_s006
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/internal_trusted_storage/test_s006/: test_entry_s006.c test_ps_data.h test_s006.c test_s006.h
  group psa-arch-tests-api-tests-dev_apis-internal_trusted_storage-test_s007
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/internal_trusted_storage/test_s007/: test_entry_s007.c test_ps_data.h test_s007.c test_s007.h
  group psa-arch-tests-api-tests-dev_apis-internal_trusted_storage-test_s008
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/internal_trusted_storage/test_s008/: test_entry_s008.c test_ps_data.h test_s008.c test_s008.h
  group psa-arch-tests-api-tests-dev_apis-internal_trusted_storage-test_s009
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/internal_trusted_storage/test_s009/: test_entry_s009.c test_ps_data.h test_s009.c test_s009.h
  group psa-arch-tests-api-tests-dev_apis-internal_trusted_storage-test_s010
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/internal_trusted_storage/test_s010/: test_entry_s010.c test_ps_data.h test_s010.c test_s010.h
  group psa-arch-tests-api-tests-dev_apis-protected_storage-test_p011
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/protected_storage/test_p011/: test_entry_p011.c test_p011.c test_p011.h test_ps_data.h
  group psa-arch-tests-api-tests-dev_apis-protected_storage-test_p012
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/protected_storage/test_p012/: test_entry_p012.c test_p012.c test_p012.h test_ps_data.h
  group psa-arch-tests-api-tests-dev_apis-protected_storage-test_p013
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/protected_storage/test_p013/: test_entry_p013.c test_p013.c test_p013.h test_ps_data.h
  group psa-arch-tests-api-tests-dev_apis-protected_storage-test_p014
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/protected_storage/test_p014/: test_entry_p014.c test_p014.c test_p014.h test_ps_data.h
  group psa-arch-tests-api-tests-dev_apis-protected_storage-test_p015
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/protected_storage/test_p015/: test_entry_p015.c test_p015.c test_p015.h test_ps_data.h
  group psa-arch-tests-api-tests-dev_apis-protected_storage-test_p016
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/protected_storage/test_p016/: test_entry_p016.c test_p016.c test_p016.h test_ps_data.h
  group psa-arch-tests-api-tests-dev_apis-protected_storage-test_p017
    ../../../../../../../middleware/psa-arch-tests/api-tests/dev_apis/protected_storage/test_p017/: test_entry_p017.c test_p017.c test_p017.h test_ps_data.h
  group psa-arch-tests-api-tests-platform-targets-tgt_dev_apis_tfm_nxp-nspe-protected_storage
    ../../../../../../../middleware/psa-arch-tests/api-tests/platform/targets/tgt_dev_apis_tfm_nxp/nspe/protected_storage/: pal_protected_storage_intf.c pal_protected_storage_intf.h
  group device
    ../../../../../../../devices/LPC55S69/: LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h fsl_device_registers.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group utilities
    ../../../../../../../devices/LPC55S69/utilities/: fsl_assert.c
    ../../../../../../../devices/LPC55S69/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group component-uart
    ../../../../../../../components/uart/: uart.h usart_adapter.c
  group component-serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
target tfm_psatest_ns release (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tfm_psatest_ns.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_LPC55S69JBD100_cm33_core0, TFM_LVL=2, PSA_API_TEST_NS=1, __DOMAIN_NS=1, DOMAIN_NS=1, TFM_PARTITION_PLATFORM, TFM_PARTITION_SECURE_STORAGE, TFM_PARTITION_INTERNAL_TRUSTED_STORAGE, TFM_PARTITION_CRYPTO, TFM_PARTITION_INITIAL_ATTESTATION, TFM_PSA_API, INITIAL_ATTESTATION, CRYPTO, PROTECTED_STORAGE, PS_TEST, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: as above
  link misc: ../../tfm_psatest_s/mdk/release/tfm_psatest_s_CMSE_lib.o ../../../../../../../CMSIS/RTOS2/RTX/Library/ARM/RTX_V8MMFN.lib ../../../../../../../devices/LPC55S69/arm/keil_lib_power_cm33_core0.lib --remove
