# Keil uVision project tfm_regression_ns.uvprojx, settings and files
target tfm_regression_ns debug (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tfm_regression_ns.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_LPC55S69JBD100_cm33_core0, TFM_LVL=2, __DOMAIN_NS=1, DOMAIN_NS=1, TFM_PARTITION_PLATFORM, TFM_PARTITION_SECURE_STORAGE, TFM_PARTITION_INTERNAL_TRUSTED_STORAGE, TFM_PARTITION_CRYPTO, TFM_PARTITION_INITIAL_ATTESTATION, TEST_FRAMEWORK_NS, SERVICES_TEST_NS, TEST_FRAMEWORK_S, TFM_PARTITION_TEST_SECURE_SERVICES, ENABLE_SECURE_STORAGE_SERVICE_TESTS, ENABLE_INTERNAL_TRUSTED_STORAGE_SERVICE_TESTS, ENABLE_ATTESTATION_SERVICE_TESTS, T_COSE_USE_PSA_CRYPTO, ENABLE_CRYPTO_SERVICE_TESTS, ENABLE_QCBOR_TESTS, CORE_TEST_POSITIVE, TFM_ENABLE_PERIPH_ACCESS_TEST, TFM_ENABLE_IRQ_TEST, TFM_PARTITION_TEST_CORE, ENABLE_PLATFORM_SERVICE_TESTS, ENABLE_T_COSE_TESTS, T_COSE_DISABLE_ES384, T_COSE_DISABLE_ES512, T_COSE_DISABLE_SIGN_VERIFY_TESTS, T_COSE_USE_PSA_CRYPTO_FROM_TFM, TFM_PARTITION_TEST_CORE_IPC, ENABLE_IPC_TEST, TFM_PSA_API, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../tfm_regression_s;../../../tfm_regression_ns;../../../../..;../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../devices/LPC55S69;../../../tfm_regression_s;../../../../../../../devices/LPC55S69/drivers;../../../../../../../middleware/tfm;../../../../../../../middleware/tfm/interface/include;../../../../../../../CMSIS/RTOS2/Include;../../../../../../../middleware/tfm/app;../../../../../../../middleware/tfm/platform/include;../../../../../../../middleware/tfm/platform/ext/driver;../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69;../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/Device/Config;../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/Device/Include;../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/partition;../../../../../../../middleware/tfm/secure_fw/core;../../../../../../../middleware/tfm/secure_fw/core/include;../../../../../../../middleware/tfm/secure_fw/include;../../../../../../../middleware/tfm/secure_fw/core/arch/include;../../../../../../../middleware/tfm/platform/ext/target/nxp/common/os/rtx;../../../../../../../middleware/tfm/lib/ext/qcbor/test;../../../../../../../middleware/tfm/lib/ext/qcbor/inc;../../../../../../../middleware/tfm/lib/ext/qcbor/util;../../../../../../../middleware/tfm/lib/ext/t_cose/inc;../../../../../../../middleware/tfm/lib/ext/t_cose/src;../../../../../../../middleware/tfm/secure_fw/services/initial_attestation;../../../../../../../middleware/tfm/test/suites/attestation;../../../../../../../middleware/tfm/test/suites/platform;../../../../../../../middleware/tfm/test/suites/t_cose;../../../../../../../devices/LPC55S69/utilities/str;../../../../../../../devices/LPC55S69/utilities/debug_console;../../../../../../../components/uart;../../../../../../../components/serial_manager;../../../../../../../components/lists;../../../../../../../devices/LPC55S69/utilities
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/Device/Source/armclang/LPC55S69_cm33_core0_ns.sct
  link misc: ../../tfm_regression_s/mdk/debug/tfm_regression_s_CMSE_lib.o ../../../../../../../CMSIS/RTOS2/RTX/Library/ARM/RTX_V8MMFN.lib ../../../../../../../devices/LPC55S69/arm/keil_lib_power_cm33_core0.lib --remove
  group startup
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/Device/Source/armclang/: startup_LPC55S69_cm33_core0_ns.S
  group source
    ../../../../../../../middleware/tfm/app/: main_ns.c
  group tfm-app
    ../../../../../../../middleware/tfm/app/: tfm_integ_test.c tfm_integ_test.h os_wrapper_cmsis_rtos_v2.c uart_stdout.h
  group board
    ../: pin_mux.c pin_mux.h hardware_init.c app.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/LPC55S69/drivers/: fsl_ctimer.c fsl_ctimer.h fsl_iocon.h fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_power.c fsl_power.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_reset.c fsl_reset.h
  group RTOS2-Include
    ../../../../../../../CMSIS/RTOS2/Include/: cmsis_os2.h
  group tfm-bl2-include
    ../../../../../../../middleware/tfm/bl2/include/: tfm_boot_status.h
  group tfm-interface-include-log
    ../../../../../../../middleware/tfm/interface/include/log/: tfm_assert.h tfm_log.h tfm_log_raw.h
  group tfm-interface-include-os_wrapper
    ../../../../../../../middleware/tfm/interface/include/os_wrapper/: common.h mutex.h semaphore.h thread.h
  group tfm-interface-include-psa
    ../../../../../../../middleware/tfm/interface/include/psa/: client.h crypto.h crypto_compat.h crypto_extra.h crypto_platform.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h error.h initial_attestation.h internal_trusted_storage.h lifecycle.h protected_storage.h service.h storage_common.h
  group tfm-interface-include
    ../../../../../../../middleware/tfm/interface/include/: tfm_api.h tfm_crypto_defs.h tfm_its_defs.h tfm_mailbox.h tfm_ns_interface.h tfm_ns_mailbox.h tfm_ns_svc.h tfm_nspm_api.h tfm_nspm_svc_handler.h tfm_platform_api.h tfm_sst_defs.h tfm_veneers.h
  group tfm-interface-src-log
    ../../../../../../../middleware/tfm/interface/src/log/: tfm_log_raw.c
  group tfm-interface-src
    ../../../../../../../middleware/tfm/interface/src/: tfm_ns_interface.c tfm_crypto_ipc_api.c tfm_initial_attestation_ipc_api.c tfm_its_ipc_api.c tfm_platform_ipc_api.c tfm_psa_ns_api.c tfm_sst_ipc_api.c
  group tfm-platform-ext-common
    ../../../../../../../middleware/tfm/platform/ext/common/: uart_stdout.h
  group tfm-platform-ext-driver
    ../../../../../../../middleware/tfm/platform/ext/driver/: Driver_Common.h Driver_USART.h
  group tfm-platform-ext-target-nxp-common-CMSIS_Driver
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/common/CMSIS_Driver/: Driver_USART.c
  group tfm-platform-ext-target-nxp-lpcxpresso55s69-Device-Config
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/Device/Config/: device_cfg.h
  group tfm-platform-ext-target-nxp-lpcxpresso55s69-Device-Include
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/Device/Include/: cmsis.h device_definition.h platform_base_address.h platform_irq.h platform_regs.h
  group tfm-platform-ext-target-nxp-lpcxpresso55s69-partition
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/partition/: flash_layout.h region_defs.h
  group tfm-platform-ext-target-nxp-lpcxpresso55s69
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/: target_cfg.h tfm_peripherals_def.h plat_test.c
  group tfm-platform-include
    ../../../../../../../middleware/tfm/platform/include/: tfm_hal_device_header.h tfm_plat_boot_seed.h tfm_plat_crypto_keys.h tfm_plat_defs.h tfm_plat_device_id.h tfm_plat_ns.h tfm_plat_test.h
  group tfm-secure_fw-core-arch-include
    ../../../../../../../middleware/tfm/secure_fw/core/arch/include/: tfm_arch.h tfm_arch_v8m.h
  group tfm-secure_fw-core-include
    ../../../../../../../middleware/tfm/secure_fw/core/include/: secure_utilities.h tfm_core.h tfm_utils.h tfm_memory_utils.h
  group tfm-secure_fw-include-core
    ../../../../../../../middleware/tfm/secure_fw/include/core/: tfm_core_svc.h
  group tfm-platform-ext-target-nxp-common-os-rtx
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/common/os/rtx/: RTX_Config.c RTX_Config.h rtx_lib.c rtx_os.h
  group tfm-test-framework
    ../../../../../../../middleware/tfm/test/framework/: non_secure_suites.c test_framework.c test_framework.h test_framework_helpers.c test_framework_helpers.h test_framework_integ_test.h test_framework_integ_test_helper.c test_framework_integ_test_helper.h
  group tfm-test-suites-audit-non_secure
    ../../../../../../../middleware/tfm/test/suites/audit/non_secure/: audit_ns_tests.h
  group tfm-test-suites-core-non_secure
    ../../../../../../../middleware/tfm/test/suites/core/non_secure/: core_ns_tests.h core_ns_positive_testsuite.c core_test_api.c core_test_api.h
  group tfm-test-suites-ipc-non_secure
    ../../../../../../../middleware/tfm/test/suites/ipc/non_secure/: ipc_ns_tests.h ipc_ns_interface_testsuite.c ipc_ns_tests.h
  group tfm-test-suites-multi_core-non_secure
    ../../../../../../../middleware/tfm/test/suites/multi_core/non_secure/: multi_core_ns_test.h
  group tfm-test-suites-platform-non_secure
    ../../../../../../../middleware/tfm/test/suites/platform/non_secure/: platform_ns_tests.h platform_ns_interface_testsuite.c platform_ns_tests.h
  group tfm-test-suites-qcbor-non_secure
    ../../../../../../../middleware/tfm/test/suites/qcbor/non_secure/: qcbor_ns_tests.h qcbor_ns_tests.h qcbor_ns_testsuite.c
  group tfm-test-suites-sst-non_secure
    ../../../../../../../middleware/tfm/test/suites/sst/non_secure/: sst_ns_tests.h ns_test_helpers.c ns_test_helpers.h psa_ps_ns_interface_testsuite.c sst_ns_tests.h
  group tfm-test-suites-t_cose-non_secure
    ../../../../../../../middleware/tfm/test/suites/t_cose/non_secure/: t_cose_ns_tests.h t_cose_ns_tests.h t_cose_ns_testsuite.c
  group tfm-test-test_services-tfm_secure_client_service
    ../../../../../../../middleware/tfm/test/test_services/tfm_secure_client_service/: tfm_secure_client_service_api.c tfm_secure_client_service_api.h
  group tfm-test-suites-its
    ../../../../../../../middleware/tfm/test/suites/its/: its_tests_common.c its_tests_common.h
  group tfm-test-suites-its-non_secure
    ../../../../../../../middleware/tfm/test/suites/its/non_secure/: its_ns_tests.h psa_its_ns_interface_testsuite.c
  group tfm-lib-ext-qcbor-inc
    ../../../../../../../middleware/tfm/lib/ext/qcbor/inc/: UsefulBuf.h q_useful_buf.h qcbor.h
  group tfm-lib-ext-qcbor-src
    ../../../../../../../middleware/tfm/lib/ext/qcbor/src/: UsefulBuf.c ieee754.c ieee754.h qcbor_decode.c qcbor_encode.c
  group tfm-lib-ext-qcbor-test
    ../../../../../../../middleware/tfm/lib/ext/qcbor/test/: UsefulBuf_Tests.c UsefulBuf_Tests.h float_tests.c float_tests.h half_to_double_from_rfc7049.c half_to_double_from_rfc7049.h not_well_formed_cbor.h qcbor_decode_tests.c qcbor_decode_tests.h qcbor_encode_tests.c qcbor_encode_tests.h run_tests.c run_tests.h
  group tfm-lib-ext-qcbor-util
    ../../../../../../../middleware/tfm/lib/ext/qcbor/util/: qcbor_util.c qcbor_util.h
  group tfm-lib-ext-t_cose-crypto_adapters
    ../../../../../../../middleware/tfm/lib/ext/t_cose/crypto_adapters/: t_cose_psa_crypto.c
  group tfm-lib-ext-t_cose-inc
    ../../../../../../../middleware/tfm/lib/ext/t_cose/inc/: q_useful_buf.h t_cose_common.h t_cose_sign1_sign.h t_cose_sign1_verify.h
  group tfm-lib-ext-t_cose-src
    ../../../../../../../middleware/tfm/lib/ext/t_cose/src/: t_cose_crypto.h t_cose_parameters.c t_cose_parameters.h t_cose_sign1_sign.c t_cose_sign1_verify.c t_cose_standard_constants.h t_cose_util.c t_cose_util.h
  group tfm-platform-ext-common-template
    ../../../../../../../middleware/tfm/platform/ext/common/template/: crypto_keys.c tfm_initial_attestation_key_material.c
  group tfm-secure_fw-services-initial_attestation
    ../../../../../../../middleware/tfm/secure_fw/services/initial_attestation/: attest_eat_defines.h attest_token.h attestation.h attestation_key.c attestation_key.h tfm_client.h
  group tfm-test-suites-attestation
    ../../../../../../../middleware/tfm/test/suites/attestation/: attest_public_key.c attest_public_key.h attest_token_decode.c attest_token_decode.h attest_token_test.c attest_token_test.h attest_token_test_values.h attestation_tests_common.h
  group tfm-test-suites-attestation-non_secure
    ../../../../../../../middleware/tfm/test/suites/attestation/non_secure/: attestation_ns_interface_testsuite.c attestation_ns_tests.h
  group tfm-test-suites-crypto
    ../../../../../../../middleware/tfm/test/suites/crypto/: crypto_tests_common.c crypto_tests_common.h
  group tfm-test-suites-crypto-non_secure
    ../../../../../../../middleware/tfm/test/suites/crypto/non_secure/: crypto_ns_interface_testsuite.c crypto_ns_tests.h
  group tfm-test-test_services-tfm_core_test
    ../../../../../../../middleware/tfm/test/test_services/tfm_core_test/: core_test_defs.h
  group tfm-test-suites-platform
    ../../../../../../../middleware/tfm/test/suites/platform/: platform_tests_common.c platform_tests_common.h
  group tfm-lib-ext-t_cose-test
    ../../../../../../../middleware/tfm/lib/ext/t_cose/test/: run_tests.c run_tests.h t_cose_make_psa_test_key.c t_cose_make_test_messages.c t_cose_make_test_messages.h t_cose_make_test_pub_key.h t_cose_sign_verify_test.c t_cose_sign_verify_test.h t_cose_test.c t_cose_test.h
  group tfm-interface-include-psa_manifest
    ../../../../../../../middleware/tfm/interface/include/psa_manifest/: sid.h
  group device
    ../../../../../../../devices/LPC55S69/: LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h fsl_device_registers.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group utilities
    ../../../../../../../devices/LPC55S69/utilities/: fsl_assert.c
    ../../../../../../../devices/LPC55S69/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group component-uart
    ../../../../../../../components/uart/: uart.h usart_adapter.c
  group component-serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
target tfm_regression_ns release (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tfm_regression_ns.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_LPC55S69JBD100_cm33_core0, TFM_LVL=2, __DOMAIN_NS=1, DOMAIN_NS=1, TFM_PARTITION_PLATFORM, TFM_PARTITION_SECURE_STORAGE, TFM_PARTITION_INTERNAL_TRUSTED_STORAGE, TFM_PARTITION_CRYPTO, TFM_PARTITION_INITIAL_ATTESTATION, TEST_FRAMEWORK_NS, SERVICES_TEST_NS, TEST_FRAMEWORK_S, TFM_PARTITION_TEST_SECURE_SERVICES, ENABLE_SECURE_STORAGE_SERVICE_TESTS, ENABLE_INTERNAL_TRUSTED_STORAGE_SERVICE_TESTS, ENABLE_ATTESTATION_SERVICE_TESTS, T_COSE_USE_PSA_CRYPTO, ENABLE_CRYPTO_SERVICE_TESTS, ENABLE_QCBOR_TESTS, CORE_TEST_POSITIVE, TFM_ENABLE_PERIPH_ACCESS_TEST, TFM_ENABLE_IRQ_TEST, TFM_PARTITION_TEST_CORE, ENABLE_PLATFORM_SERVICE_TESTS, ENABLE_T_COSE_TESTS, T_COSE_DISABLE_ES384, T_COSE_DISABLE_ES512, T_COSE_DISABLE_SIGN_VERIFY_TESTS, T_COSE_USE_PSA_CRYPTO_FROM_TFM, TFM_PARTITION_TEST_CORE_IPC, ENABLE_IPC_TEST, TFM_PSA_API, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: as above
  link misc: ../../tfm_regression_s/mdk/release/tfm_regression_s_CMSE_lib.o ../../../../../../../CMSIS/RTOS2/RTX/Library/ARM/RTX_V8MMFN.lib ../../../../../../../devices/LPC55S69/arm/keil_lib_power_cm33_core0.lib --remove
