# Keil uVision project tfm_regression_s.uvprojx, settings and files
target tfm_regression_s debug (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tfm_regression_s.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_LPC55S69JBD100_cm33_core0, TFM_LVL=2, SST_ENCRYPTION, SST_RAM_FS, SST_CREATE_FLASH_LAYOUT, SST_WIPE_ALL, ITS_RAM_FS, ITS_CREATE_FLASH_LAYOUT, ITS_WIPE_ALL, DAUTH_CHIP_DEFAULT, MBEDTLS_MCUX_CASPER_ECC=0, MBEDTLS_MCUX_HASHCRYPT_SHA=0, MBEDTLS_CONFIG_FILE='\"lpcxpresso55s69_mbedcrypto_config.h\"', INCLUDE_TEST_CODE_AND_KEY_ID, TFM_PARTITION_SECURE_STORAGE, TFM_PARTITION_INTERNAL_TRUSTED_STORAGE, TFM_PARTITION_CRYPTO, TFM_PARTITION_INITIAL_ATTESTATION, T_COSE_USE_PSA_CRYPTO, TFM_PARTITION_PLATFORM, TEST_FRAMEWORK_S, SERVICES_TEST_S, TFM_PARTITION_TEST_SECURE_SERVICES, SST_TEST_NV_COUNTERS, SST_ROLLBACK_PROTECTION, TFM_PARTITION_TEST_SST, ENABLE_SECURE_STORAGE_SERVICE_TESTS, ENABLE_INTERNAL_TRUSTED_STORAGE_SERVICE_TESTS, ENABLE_ATTESTATION_SERVICE_TESTS, ENABLE_CRYPTO_SERVICE_TESTS, ENABLE_PLATFORM_SERVICE_TESTS, TFM_PARTITION_TEST_CORE, CORE_TEST_POSITIVE, TFM_ENABLE_PERIPH_ACCESS_TEST, TFM_ENABLE_IRQ_TEST, TFM_PSA_API, CONFIG_TFM_ENABLE_MEMORY_PROTECT, TFM_PARTITION_TEST_CORE_IPC, ENABLE_IPC_TEST, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../tfm_regression_s;../../../../..;../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../devices/LPC55S69;../../../../../../../devices/LPC55S69/drivers;../../../../../../../middleware/mbed-crypto/include;../../../../../../../middleware/mbed-crypto/port;../../../../../../../middleware/tfm;../../../../../../../middleware/tfm/bl2/include;../../../../../../../middleware/tfm/interface/include;../../../../../../../middleware/tfm/secure_fw/core;../../../../../../../middleware/tfm/secure_fw/include;../../../../../../../middleware/tfm/secure_fw/core/include;../../../../../../../middleware/tfm/secure_fw/core/arch/include;../../../../../../../middleware/tfm/secure_fw/core/ipc/include;../../../../../../../middleware/tfm/secure_fw/spm;../../../../../../../middleware/tfm/platform/include;../../../../../../../middleware/tfm/platform/ext/driver;../../../../../../../middleware/tfm/platform/ext/common;../../../../../../../middleware/tfm/platform/ext/target/nxp/common;../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69;../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/Device/Config;../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/Device/Include;../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/partition;../../../../../../../middleware/tfm/platform/ext/target/nxp/common/Native_Driver;../../../../../../../middleware/tfm/secure_fw/services/secure_storage;../../../../../../../middleware/tfm/secure_fw/services/internal_trusted_storage;../../../../../../../middleware/tfm/secure_fw/services/crypto;../../../../../../../middleware/tfm/secure_fw/services/initial_attestation;../../../../../../../middleware/tfm/lib/ext/t_cose/inc;../../../../../../../middleware/tfm/lib/ext/t_cose/src;../../../../../../../middleware/tfm/lib/ext/qcbor/inc;../../../../../../../middleware/tfm/lib/ext/qcbor/util;../../../../../../../middleware/tfm/test/suites/attestation;../../../../../../../middleware/tfm/secure_fw/services/platform;../../../../../../../middleware/tfm/test/suites/platform;../../../../../../../middleware/tfm/test/test_services/tfm_ipc_client;../../../../../../../middleware/tfm/test/test_services/tfm_ipc_service;../../../../../../../devices/LPC55S69/utilities/str;../../../../../../../devices/LPC55S69/utilities/debug_console;../../../../../../../components/uart;../../../../../../../components/serial_manager;../../../../../../../components/lists;../../../../../../../devices/LPC55S69/utilities
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/Device/Source/armclang/LPC55S69_cm33_core0_s.sct
  link misc: ../../../../../../../devices/LPC55S69/arm/keil_lib_power_cm33_core0.lib --remove --predefine="-DTFM_LVL=2 -DTFM_PSA_API -DTFM_PARTITION_TEST_CORE_IPC -DTFM_PARTITION_TEST_SECURE_SERVICES -DTFM_PARTITION_PLATFORM -DTFM_PARTITION_SECURE_STORAGE -DTFM_PARTITION_INTERNAL_TRUSTED_STORAGE -DTFM_PARTITION_CRYPTO -DTFM_PARTITION_INITIAL_ATTESTATION -DTFM_PARTITION_TEST_CORE -DTFM_ENABLE_IRQ_TEST -DTFM_PARTITION_TEST_SST" --import-cmse-lib-out="./debug/tfm_regression_s_CMSE_lib.o"
  group startup
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/Device/Source/armclang/: startup_LPC55S69_cm33_core0_s.S
  group source
    ../../../../../../../middleware/tfm/secure_fw/core/: tfm_core.c
  group board
    ../: pin_mux.c pin_mux.h hardware_init.c app.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/LPC55S69/drivers/: fsl_casper.c fsl_casper.h fsl_hashcrypt.c fsl_hashcrypt.h fsl_rng.c fsl_rng.h fsl_iap.c fsl_iap.h fsl_iap_ffr.h fsl_iap_kbp.h fsl_iap_skboot_authenticate.h fsl_ctimer.c fsl_ctimer.h fsl_iocon.h fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_power.c fsl_power.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_reset.c fsl_reset.h
  group mbed-crypto-include-mbed_psa
    ../../../../../../../middleware/mbed-crypto/include/mbed_psa/: crypto.h crypto_accel_driver.h crypto_compat.h crypto_driver_common.h crypto_entropy_driver.h crypto_extra.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group mbed-crypto-include-mbedtls
    ../../../../../../../middleware/mbed-crypto/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h psa_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h threading.h timing.h version.h xtea.h
  group mbed-crypto-library
    ../../../../../../../middleware/mbed-crypto/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_core.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_se.c psa_crypto_se.h psa_crypto_service_integration.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c threading.c timing.c version.c version_features.c xtea.c
  group mbed-crypto-port
    ../../../../../../../middleware/mbed-crypto/port/: aes_alt.h mbedcrypto_mcux_casper.c mbedcrypto_mcux_config.h mbedcrypto_mcux_entropy.c mbedcrypto_mcux_hashcrypt.c mbedcrypto_mcux_hw_config.h sha1_alt.h sha256_alt.h
  group tfm-bl2-ext-mcuboot-bootutil-include-bootutil
    ../../../../../../../middleware/tfm/bl2/ext/mcuboot/bootutil/include/bootutil/: image.h
  group tfm-bl2-include
    ../../../../../../../middleware/tfm/bl2/include/: tfm_boot_status.h
  group tfm-interface-include-log
    ../../../../../../../middleware/tfm/interface/include/log/: tfm_assert.h tfm_log.h tfm_log_raw.h
  group tfm-interface-include-psa
    ../../../../../../../middleware/tfm/interface/include/psa/: client.h crypto.h crypto_compat.h crypto_extra.h crypto_platform.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h error.h initial_attestation.h internal_trusted_storage.h lifecycle.h protected_storage.h service.h storage_common.h
  group tfm-interface-include
    ../../../../../../../middleware/tfm/interface/include/: psa_audit_defs.h tfm_api.h tfm_crypto_defs.h tfm_mailbox.h tfm_platform_api.h tfm_veneers.h tfm_sst_defs.h tfm_its_defs.h
  group tfm-interface-include-psa_manifest
    ../../../../../../../middleware/tfm/interface/include/psa_manifest/: pid.h sid.h
  group tfm-interface-src-log
    ../../../../../../../middleware/tfm/interface/src/log/: tfm_log_raw.c
  group tfm-platform-ext-common
    ../../../../../../../middleware/tfm/platform/ext/common/: boot_hal.c tfm_platform.c uart_stdout.c uart_stdout.h
  group tfm-platform-ext-common-template
    ../../../../../../../middleware/tfm/platform/ext/common/template/: attest_hal.c crypto_keys.c nv_counters.c tfm_initial_attestation_key_material.c
  group tfm-platform-ext-driver
    ../../../../../../../middleware/tfm/platform/ext/driver/: Driver_Common.h Driver_Flash.h Driver_MPC.h Driver_PPC.h Driver_USART.h
  group tfm-platform-ext-target-nxp-common-CMSIS_Driver
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/common/CMSIS_Driver/: Driver_Flash.c Driver_USART.c
  group tfm-platform-ext-target-nxp-common-Native_Driver
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/common/Native_Driver/: mpu_armv8m_drv.c mpu_armv8m_drv.h
  group tfm-platform-ext-target-nxp-common
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/common/: mini_mbedcrypto_config.h
  group tfm-platform-ext-target-nxp-lpcxpresso55s69-Device-Config
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/Device/Config/: device_cfg.h
  group tfm-platform-ext-target-nxp-lpcxpresso55s69-Device-Include
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/Device/Include/: cmsis.h device_definition.h platform_base_address.h platform_description.h platform_irq.h platform_regs.h
  group tfm-platform-ext-target-nxp-lpcxpresso55s69
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/: lpcxpresso55s69_mbedcrypto_config.h spm_hal.c target_cfg.c target_cfg.h tfm_peripherals_def.h plat_test.c
  group tfm-platform-ext-target-nxp-lpcxpresso55s69-partition
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/partition/: flash_layout.h region_defs.h
  group tfm-platform-ext-target-nxp-lpcxpresso55s69-services-src
    ../../../../../../../middleware/tfm/platform/ext/target/nxp/lpcxpresso55s69/services/src/: tfm_platform_system.c
  group tfm-platform-include
    ../../../../../../../middleware/tfm/platform/include/: tfm_attest_hal.h tfm_hal_device_header.h tfm_plat_boot_seed.h tfm_plat_crypto_keys.h tfm_plat_defs.h tfm_plat_device_id.h tfm_plat_ns.h tfm_plat_nv_counters.h tfm_plat_test.h tfm_platform_system.h tfm_spm_hal.h
  group tfm-secure_fw-core-arch-include
    ../../../../../../../middleware/tfm/secure_fw/core/arch/include/: tfm_arch.h tfm_arch_v8m.h
  group tfm-secure_fw-core-arch
    ../../../../../../../middleware/tfm/secure_fw/core/arch/: tfm_arch.c tfm_arch_v8m_main.c
  group tfm-secure_fw-core-include
    ../../../../../../../middleware/tfm/secure_fw/core/include/: secure_utilities.h tfm_core.h tfm_core_mem_check.h tfm_core_topology.h tfm_core_trustzone.h tfm_core_utils.h tfm_internal.h tfm_irq_list.h tfm_memory_utils.h tfm_nspm.h tfm_platform_core_api.h tfm_secure_api.h tfm_utils.h tfm_version.h
  group tfm-secure_fw-core-ipc-include
    ../../../../../../../middleware/tfm/secure_fw/core/ipc/include/: tfm_list.h tfm_message_queue.h tfm_wait.h tfm_internal_defines.h tfm_list.h tfm_message_queue.h tfm_pools.h tfm_psa_client_call.h tfm_rpc.h tfm_spe_mailbox.h tfm_svcalls.h tfm_thread.h tfm_wait.h
  group tfm-secure_fw-core
    ../../../../../../../middleware/tfm/secure_fw/core/: tfm_boot_data.c tfm_core_mem_check.c tfm_core_utils.c tfm_secure_api.c tfm_secure_irq_handlers.inc tfm_spm_services.c tfm_utils.c tfm_core_svcalls_ipc.c tfm_nspm_ipc.c
  group tfm-secure_fw-include-core
    ../../../../../../../middleware/tfm/secure_fw/include/core/: tfm_core_svc.h
  group tfm-secure_fw-include
    ../../../../../../../middleware/tfm/secure_fw/include/: tfm_spm_services_api.h
  group tfm-secure_fw-services-audit_logging-psa_manifest
    ../../../../../../../middleware/tfm/secure_fw/services/audit_logging/psa_manifest/: tfm_audit_logging.h
  group tfm-secure_fw-services-crypto-psa_manifest
    ../../../../../../../middleware/tfm/secure_fw/services/crypto/psa_manifest/: tfm_crypto.h
  group tfm-secure_fw-services-initial_attestation-psa_manifest
    ../../../../../../../middleware/tfm/secure_fw/services/initial_attestation/psa_manifest/: tfm_initial_attestation.h
  group tfm-secure_fw-services-internal_trusted_storage-psa_manifest
    ../../../../../../../middleware/tfm/secure_fw/services/internal_trusted_storage/psa_manifest/: tfm_internal_trusted_storage.h
  group tfm-secure_fw-services-platform-psa_manifest
    ../../../../../../../middleware/tfm/secure_fw/services/platform/psa_manifest/: tfm_platform.h
  group tfm-secure_fw-services-secure_storage-psa_manifest
    ../../../../../../../middleware/tfm/secure_fw/services/secure_storage/psa_manifest/: tfm_secure_storage.h
  group tfm-secure_fw-services
    ../../../../../../../middleware/tfm/secure_fw/services/: tfm_service_list.inc
  group tfm-secure_fw-spm
    ../../../../../../../middleware/tfm/secure_fw/spm/: spm_api.c spm_api.h spm_db.h spm_partition_defs.h tfm_spm_db.inc spm_api_ipc.c
  group tfm-test-test_services-tfm_core_test-psa_manifest
    ../../../../../../../middleware/tfm/test/test_services/tfm_core_test/psa_manifest/: tfm_test_core.h
  group tfm-test-test_services-tfm_core_test_2-psa_manifest
    ../../../../../../../middleware/tfm/test/test_services/tfm_core_test_2/psa_manifest/: tfm_test_core_2.h
  group tfm-test-test_services-tfm_ipc_client-psa_manifest
    ../../../../../../../middleware/tfm/test/test_services/tfm_ipc_client/psa_manifest/: tfm_ipc_client_partition.h tfm_ipc_client_partition.h
  group tfm-test-test_services-tfm_ipc_service-psa_manifest
    ../../../../../../../middleware/tfm/test/test_services/tfm_ipc_service/psa_manifest/: tfm_ipc_service_partition.h tfm_ipc_service_partition.h
  group tfm-test-test_services-tfm_irq_test_service_1-psa_manifest
    ../../../../../../../middleware/tfm/test/test_services/tfm_irq_test_service_1/psa_manifest/: tfm_irq_test_service_1.h
  group tfm-test-test_services-tfm_multi_core_test-psa_manifest
    ../../../../../../../middleware/tfm/test/test_services/tfm_multi_core_test/psa_manifest/: tfm_multi_core_test.h
  group tfm-test-test_services-tfm_secure_client_2-psa_manifest
    ../../../../../../../middleware/tfm/test/test_services/tfm_secure_client_2/psa_manifest/: tfm_secure_client_2.h
  group tfm-test-test_services-tfm_secure_client_service-psa_manifest
    ../../../../../../../middleware/tfm/test/test_services/tfm_secure_client_service/psa_manifest/: tfm_test_client_service.h
  group tfm-test-test_services-tfm_sst_test_service-psa_manifest
    ../../../../../../../middleware/tfm/test/test_services/tfm_sst_test_service/psa_manifest/: tfm_sst_test_service.h
  group tfm-secure_fw-services-secure_storage-crypto
    ../../../../../../../middleware/tfm/secure_fw/services/secure_storage/crypto/: sst_crypto_interface.c sst_crypto_interface.h
  group tfm-secure_fw-services-secure_storage-nv_counters
    ../../../../../../../middleware/tfm/secure_fw/services/secure_storage/nv_counters/: sst_nv_counters.h
  group tfm-secure_fw-services-secure_storage
    ../../../../../../../middleware/tfm/secure_fw/services/secure_storage/: sst_encrypted_object.c sst_encrypted_object.h sst_object_defs.h sst_object_system.c sst_object_system.h sst_object_table.c sst_object_table.h sst_utils.c sst_utils.h tfm_protected_storage.c tfm_protected_storage.h tfm_sst_req_mngr.c tfm_sst_req_mngr.h tfm_sst_secure_api.c
  group tfm-secure_fw-services-internal_trusted_storage-flash
    ../../../../../../../middleware/tfm/secure_fw/services/internal_trusted_storage/flash/: its_flash.c its_flash.h its_flash_info_external.c its_flash_info_internal.c its_flash_nand.c its_flash_nand.h its_flash_nor.c its_flash_nor.h its_flash_ram.c its_flash_ram.h
  group tfm-secure_fw-services-internal_trusted_storage-flash_fs
    ../../../../../../../middleware/tfm/secure_fw/services/internal_trusted_storage/flash_fs/: its_flash_fs.c its_flash_fs.h its_flash_fs_check_info.h its_flash_fs_dblock.c its_flash_fs_dblock.h its_flash_fs_mblock.c its_flash_fs_mblock.h
  group tfm-secure_fw-services-internal_trusted_storage
    ../../../../../../../middleware/tfm/secure_fw/services/internal_trusted_storage/: its_utils.c its_utils.h tfm_internal_trusted_storage.c tfm_internal_trusted_storage.h tfm_its_req_mngr.c tfm_its_req_mngr.h tfm_its_secure_api.c
  group tfm-secure_fw-services-crypto
    ../../../../../../../middleware/tfm/secure_fw/services/crypto/: crypto_aead.c crypto_alloc.c crypto_asymmetric.c crypto_cipher.c crypto_hash.c crypto_init.c crypto_key.c crypto_key_derivation.c crypto_mac.c crypto_spe.h tfm_crypto_api.h tfm_crypto_secure_api.c tfm_mbedcrypto_include.h
  group tfm-lib-ext-qcbor-inc
    ../../../../../../../middleware/tfm/lib/ext/qcbor/inc/: UsefulBuf.h q_useful_buf.h qcbor.h
  group tfm-lib-ext-qcbor-src
    ../../../../../../../middleware/tfm/lib/ext/qcbor/src/: UsefulBuf.c ieee754.c ieee754.h qcbor_decode.c qcbor_encode.c
  group tfm-lib-ext-qcbor-util
    ../../../../../../../middleware/tfm/lib/ext/qcbor/util/: qcbor_util.c qcbor_util.h
  group tfm-lib-ext-t_cose-crypto_adapters
    ../../../../../../../middleware/tfm/lib/ext/t_cose/crypto_adapters/: t_cose_psa_crypto.c
  group tfm-lib-ext-t_cose-inc
    ../../../../../../../middleware/tfm/lib/ext/t_cose/inc/: q_useful_buf.h t_cose_common.h t_cose_sign1_sign.h t_cose_sign1_verify.h t_cose_sign1_verify.h
  group tfm-lib-ext-t_cose-src
    ../../../../../../../middleware/tfm/lib/ext/t_cose/src/: t_cose_crypto.h t_cose_parameters.c t_cose_parameters.h t_cose_sign1_sign.c t_cose_standard_constants.h t_cose_util.c t_cose_util.h t_cose_sign1_verify.c
  group tfm-secure_fw-services-initial_attestation
    ../../../../../../../middleware/tfm/secure_fw/services/initial_attestation/: attest_eat_defines.h attest_token.c attest_token.h attestation.h attestation_core.c attestation_key.c attestation_key.h tfm_attestation.c tfm_attestation_req_mngr.c tfm_attestation_secure_api.c tfm_client.h
  group tfm-test-suites-attestation
    ../../../../../../../middleware/tfm/test/suites/attestation/: attest_public_key.h attest_public_key.c attest_public_key.h attest_token_decode.c attest_token_decode.h attest_token_test.c attest_token_test.h attest_token_test_values.h attestation_tests_common.h
  group tfm-secure_fw-services-platform
    ../../../../../../../middleware/tfm/secure_fw/services/platform/: platform_sp.c platform_sp.h tfm_platform_secure_api.c
  group tfm-test-framework
    ../../../../../../../middleware/tfm/test/framework/: secure_suites.c test_framework.c test_framework.h test_framework_helpers.c test_framework_helpers.h test_framework_integ_test.h test_framework_integ_test_helper.c test_framework_integ_test_helper.h
  group tfm-test-suites-audit-secure
    ../../../../../../../middleware/tfm/test/suites/audit/secure/: audit_s_tests.h
  group tfm-test-suites-ipc-secure
    ../../../../../../../middleware/tfm/test/suites/ipc/secure/: ipc_s_tests.h ipc_s_interface_testsuite.c ipc_s_tests.h
  group tfm-test-test_services-tfm_secure_client_2
    ../../../../../../../middleware/tfm/test/test_services/tfm_secure_client_2/: tfm_secure_client_2.c tfm_secure_client_2_api.c tfm_secure_client_2_api.h
  group tfm-test-test_services-tfm_secure_client_service
    ../../../../../../../middleware/tfm/test/test_services/tfm_secure_client_service/: tfm_secure_client_service.c tfm_secure_client_service.h
  group tfm-test-suites-sst-secure-nv_counters
    ../../../../../../../middleware/tfm/test/suites/sst/secure/nv_counters/: test_sst_nv_counters.c test_sst_nv_counters.h
  group tfm-test-suites-sst-secure
    ../../../../../../../middleware/tfm/test/suites/sst/secure/: psa_ps_s_interface_testsuite.c psa_ps_s_reliability_testsuite.c s_test_helpers.h sst_rollback_protection_testsuite.c sst_tests.h
  group tfm-test-test_services-tfm_sst_test_service
    ../../../../../../../middleware/tfm/test/test_services/tfm_sst_test_service/: tfm_sst_test_service.c tfm_sst_test_service_api.c tfm_sst_test_service_api.h
  group tfm-test-suites-its
    ../../../../../../../middleware/tfm/test/suites/its/: its_tests_common.c its_tests_common.h
  group tfm-test-suites-its-secure
    ../../../../../../../middleware/tfm/test/suites/its/secure/: its_s_tests.h psa_its_s_interface_testsuite.c psa_its_s_reliability_testsuite.c
  group tfm-test-suites-attestation-secure
    ../../../../../../../middleware/tfm/test/suites/attestation/secure/: attestation_s_interface_testsuite.c attestation_s_tests.h
  group tfm-test-suites-crypto
    ../../../../../../../middleware/tfm/test/suites/crypto/: crypto_tests_common.c crypto_tests_common.h
  group tfm-test-suites-crypto-secure
    ../../../../../../../middleware/tfm/test/suites/crypto/secure/: crypto_s_tests.h crypto_sec_interface_testsuite.c
  group tfm-test-suites-platform
    ../../../../../../../middleware/tfm/test/suites/platform/: platform_tests_common.c platform_tests_common.h
  group tfm-test-suites-platform-secure
    ../../../../../../../middleware/tfm/test/suites/platform/secure/: platform_s_interface_testsuite.c platform_s_tests.h
  group tfm-test-test_services-tfm_core_test
    ../../../../../../../middleware/tfm/test/test_services/tfm_core_test/: core_test_defs.h tfm_ss_core_test.c tfm_ss_core_test.h
  group tfm-test-test_services-tfm_core_test_2
    ../../../../../../../middleware/tfm/test/test_services/tfm_core_test_2/: tfm_ss_core_test_2.c tfm_ss_core_test_2.h
  group tfm-test-test_services-tfm_irq_test_service_1
    ../../../../../../../middleware/tfm/test/test_services/tfm_irq_test_service_1/: tfm_irq_test_service_1.c
  group tfm-interface-src-psa
    ../../../../../../../middleware/tfm/interface/src/psa/: psa_client.c psa_lifecycle.c psa_service.c
  group tfm-secure_fw-core-ipc
    ../../../../../../../middleware/tfm/secure_fw/core/ipc/: tfm_message_queue.c tfm_pools.c tfm_psa_client_call.c tfm_secure_irq_handlers_ipc.inc tfm_svcalls.c tfm_thread.c tfm_wait.c
  group tfm-secure_fw-ns_callable
    ../../../../../../../middleware/tfm/secure_fw/ns_callable/: tfm_psa_api_veneers.c
  group tfm-test-test_services-tfm_ipc_client
    ../../../../../../../middleware/tfm/test/test_services/tfm_ipc_client/: tfm_ipc_client_test.c
  group tfm-test-test_services-tfm_ipc_service
    ../../../../../../../middleware/tfm/test/test_services/tfm_ipc_service/: tfm_ipc_service_test.c
  group device
    ../../../../../../../devices/LPC55S69/: LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h fsl_device_registers.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group utilities
    ../../../../../../../devices/LPC55S69/utilities/: fsl_assert.c
    ../../../../../../../devices/LPC55S69/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group component-uart
    ../../../../../../../components/uart/: uart.h usart_adapter.c
  group component-serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
target tfm_regression_s release (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tfm_regression_s.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_LPC55S69JBD100_cm33_core0, TFM_LVL=2, SST_ENCRYPTION, SST_RAM_FS, SST_CREATE_FLASH_LAYOUT, SST_WIPE_ALL, ITS_RAM_FS, ITS_CREATE_FLASH_LAYOUT, ITS_WIPE_ALL, DAUTH_CHIP_DEFAULT, MBEDTLS_MCUX_CASPER_ECC=0, MBEDTLS_MCUX_HASHCRYPT_SHA=0, MBEDTLS_CONFIG_FILE='\"lpcxpresso55s69_mbedcrypto_config.h\"', INCLUDE_TEST_CODE_AND_KEY_ID, TFM_PARTITION_SECURE_STORAGE, TFM_PARTITION_INTERNAL_TRUSTED_STORAGE, TFM_PARTITION_CRYPTO, TFM_PARTITION_INITIAL_ATTESTATION, T_COSE_USE_PSA_CRYPTO, TFM_PARTITION_PLATFORM, TEST_FRAMEWORK_S, SERVICES_TEST_S, TFM_PARTITION_TEST_SECURE_SERVICES, SST_TEST_NV_COUNTERS, SST_ROLLBACK_PROTECTION, TFM_PARTITION_TEST_SST, ENABLE_SECURE_STORAGE_SERVICE_TESTS, ENABLE_INTERNAL_TRUSTED_STORAGE_SERVICE_TESTS, ENABLE_ATTESTATION_SERVICE_TESTS, ENABLE_CRYPTO_SERVICE_TESTS, ENABLE_PLATFORM_SERVICE_TESTS, TFM_PARTITION_TEST_CORE, CORE_TEST_POSITIVE, TFM_ENABLE_PERIPH_ACCESS_TEST, TFM_ENABLE_IRQ_TEST, TFM_PSA_API, CONFIG_TFM_ENABLE_MEMORY_PROTECT, TFM_PARTITION_TEST_CORE_IPC, ENABLE_IPC_TEST, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: as above
  link misc: ../../../../../../../devices/LPC55S69/arm/keil_lib_power_cm33_core0.lib --remove --predefine="-DTFM_LVL=2 -DTFM_PSA_API -DTFM_PARTITION_TEST_CORE_IPC -DTFM_PARTITION_TEST_SECURE_SERVICES -DTFM_PARTITION_PLATFORM -DTFM_PARTITION_SECURE_STORAGE -DTFM_PARTITION_INTERNAL_TRUSTED_STORAGE -DTFM_PARTITION_CRYPTO -DTFM_PARTITION_INITIAL_ATTESTATION -DTFM_PARTITION_TEST_CORE -DTFM_ENABLE_IRQ_TEST -DTFM_PARTITION_TEST_SST" --import-cmse-lib-out="./release/tfm_regression_s_CMSE_lib.o"
