# IAR project dev_composite_cdc_msc_sdcard_freertos.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S69_core0 NXP LPC55S69_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: _DEBUG=1; DEBUG; CPU_LPC55S69JBD100_cm33_core0=1; USB_STACK_FREERTOS; USB_STACK_FREERTOS_HEAP_SIZE=16384; USB_STACK_USE_DEDICATED_RAM=1; SD_ENABLED; FSL_RTOS_FREE_RTOS; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../..; ..; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../devices/LPC55S69; ../../../../../../../platform/drivers; ../../../../../../../platform/drivers/common; ../../../../..; ../../../../../../../rtos/freertos/freertos_kernel/include; ../../../../../../../middleware/usb; ../../../../../../../middleware/usb/include; ../../../../../../../middleware/usb/device; ../../../../../../../devices/LPC55S69/drivers; ../../../../../../../middleware/sdmmc/sd; ../../../../../../../middleware/sdmmc/common; ../../../../../../../middleware/sdmmc/host/sdif; ../../../../../../../middleware/usb/phy; ../../../../../../../devices/LPC55S69/utilities/str; ../../../../../../../devices/LPC55S69/utilities/debug_console; ../../../../../../../components/uart; ../../../../../../../components/serial_manager; ../../../../../../../components/lists; ../../../../../../../components/osa; ../../../../../../../middleware/sdmmc/osa; ../../../../../../../devices/LPC55S69/utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../..; ../..; ..
  ILINK.IlinkOutputFile: dev_composite_cdc_msc_sdcard_freertos.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x100; __usb_use_usbram__=1
  ILINK.IlinkIcfFile: LPC55S69_cm33_core0_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../devices/LPC55S69/iar/iar_lib_power_cm33_core0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; NDEBUG; CPU_LPC55S69JBD100_cm33_core0=1; USB_STACK_FREERTOS; USB_STACK_FREERTOS_HEAP_SIZE=16384; USB_STACK_USE_DEDICATED_RAM=1; SD_ENABLED; FSL_RTOS_FREE_RTOS; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SERIAL_PORT_TYPE_UART=1
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group board
    ../../../../../: sdmmc_config.c sdmmc_config.h
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group source
    ../: composite.c composite.h disk_sdcard.c disk_sdcard.h usb_device_descriptor.c usb_device_descriptor.h virtual_com.c virtual_com.h usb_device_config.h FreeRTOSConfig.h
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h usb_device_dci.h
  group usb/device/source/lpcip3511
    ../../../../../../../middleware/usb/device/: usb_device_lpcip3511.c usb_device_lpcip3511.h usb_device_lpcip3511.c usb_device_lpcip3511.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/cdc
    ../: usb_device_cdc_acm.c usb_device_cdc_acm.h
  group usb/device/class/msc
    ../: usb_device_msc.c usb_device_msc.h usb_device_msc_ufi.c usb_device_msc_ufi.h
  group usb/device/include
    ../../../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group usb/phy
    ../../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group usb/include
    ../../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group drivers
    ../../../../../../../devices/LPC55S69/drivers/: fsl_sdif.c fsl_sdif.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_iocon.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h
  group freertos/freertos_kernel
    ../../../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.h portasm.s portmacro.h
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos_kernel/include
    ../../../../../../../rtos/freertos/freertos_kernel/include/: FreeRTOS.h StackMacros.h atomic.h croutine.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group sdmmc
    ../../../../../../../middleware/sdmmc/sd/: ChangeLogKSDK.txt
  group sdmmc/src
    ../../../../../../../middleware/sdmmc/sd/: fsl_sd.c
    ../../../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../../../middleware/sdmmc/sd/: fsl_sd.h
    ../../../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.h fsl_sdmmc_spec.h
  group sdmmc/host
    ../../../../../../../middleware/sdmmc/host/sdif/: ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h
    ../../../../../../../middleware/sdmmc/host/sdif/non_blocking/: fsl_sdmmc_host.c
  group sdmmc/osa
    ../../../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.c fsl_sdmmc_osa.h
  group device
    ../../../../../../../devices/LPC55S69/: LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h fsl_device_registers.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group startup
    ../../../../../../../devices/LPC55S69/iar/: startup_LPC55S69_cm33_core0.s
  group utilities
    ../../../../../../../devices/LPC55S69/utilities/: fsl_assert.c
    ../../../../../../../devices/LPC55S69/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group component/uart
    ../../../../../../../components/uart/: uart.h usart_adapter.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
  group component/osa
    ../../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction_free_rtos.h fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction_free_rtos.h
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
