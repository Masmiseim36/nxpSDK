# IAR project fxas21002_fifo_niobe4.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S69_core0 NXP LPC55S69_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_LPC55S69JBD100_cm33_core0; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../..; ..; ../../../../../../lpcxpresso55s69; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../devices/LPC55S69; ../../../../../../../devices/LPC55S69/drivers; ../../../../../../../devices/LPC55S69/cmsis_drivers; ../../../../../../../middleware/issdk/drivers/systick; ../../../../../../../middleware/issdk/drivers/gpio; ../../../../../../../middleware/issdk/drivers/gpio/lpc; ../../../../../../../middleware/issdk/sensors; ../../../../../../../devices/LPC55S69/utilities/str; ../../../../../../../devices/LPC55S69/utilities/debug_console; ../../../../../../../components/uart; ../../../../../../../components/serial_manager; ../../../../../../../components/lists; ../../../../../../../CMSIS/Driver/Include; ../../../../../../../devices/LPC55S69/utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: LPC55S69-AGM01-FXAS21002-FIFO-CORE0.bin
  ILINK.IlinkOutputFile: fxas21002_fifo_niobe4.out
  ILINK.IlinkIcfFile: LPC55S69_cm33_core0_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../devices/LPC55S69/iar/iar_lib_power_cm33_core0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_LPC55S69JBD100_cm33_core0; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group board
    ../../../../../: lpc55s69.c lpc55s69.h frdm_stbc_agm01_shield.h issdk_hal.h RTE_Device.h
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source
    ../: fxas21002_fifo.c
  group doc
    ../: readme.txt readme.txt
  group drivers
    ../../../../../../../devices/LPC55S69/drivers/: fsl_dma.c fsl_dma.h fsl_gint.c fsl_gint.h fsl_flexcomm.c fsl_flexcomm.h fsl_i2c.c fsl_i2c.h fsl_i2c_dma.c fsl_i2c_dma.h fsl_spi.c fsl_spi.h fsl_spi_dma.c fsl_spi_dma.h fsl_usart.c fsl_usart.h fsl_usart_dma.c fsl_usart_dma.h fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_power.c fsl_power.h fsl_iocon.h fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h fsl_gpio.c fsl_gpio.h fsl_reset.c fsl_reset.h
    ../../../../../../../devices/LPC55S69/cmsis_drivers/: fsl_i2c_cmsis.c fsl_i2c_cmsis.h fsl_spi_cmsis.c fsl_spi_cmsis.h fsl_usart_cmsis.c fsl_usart_cmsis.h
  group utilities
    ../../../../../../../middleware/issdk/drivers/systick/: systick_utils.c systick_utils.h
    ../../../../../../../devices/LPC55S69/utilities/: fsl_assert.c
    ../../../../../../../devices/LPC55S69/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group gpio_driver
    ../../../../../../../middleware/issdk/drivers/gpio/: Driver_GPIO.h
    ../../../../../../../middleware/issdk/drivers/gpio/lpc/: gpio_driver.c gpio_driver.h gpio_driver_irq.c
  group interfaces
    ../../../../../../../middleware/issdk/sensors/: register_io_i2c.c register_io_i2c.h register_io_spi.c register_io_spi.h sensor_drv.h sensor_io_i2c.c sensor_io_i2c.h sensor_io_spi.c sensor_io_spi.h
  group sensors
    ../../../../../../../middleware/issdk/sensors/: fxas21002.h fxas21002_drv.c fxas21002_drv.h
  group device
    ../../../../../../../devices/LPC55S69/: LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h fsl_device_registers.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group startup
    ../../../../../../../devices/LPC55S69/iar/: startup_LPC55S69_cm33_core0.s
  group component/uart
    ../../../../../../../components/uart/: uart.h usart_adapter.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_I2C.h Driver_Common.h Driver_SPI.h Driver_USART.h
