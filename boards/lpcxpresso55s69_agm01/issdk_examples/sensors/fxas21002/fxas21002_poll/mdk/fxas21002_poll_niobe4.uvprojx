# Keil uVision project fxas21002_poll_niobe4.uvprojx, settings and files
target fxas21002_poll_niobe4 debug (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: fxas21002_poll_niobe4.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_LPC55S69JBD100_cm33_core0, PRINTF_ADVANCED_ENABLE=1, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../..;..;../../../../../../lpcxpresso55s69;../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../devices/LPC55S69;../../../../../../../devices/LPC55S69/drivers;../../../../../../../devices/LPC55S69/cmsis_drivers;../../../../../../../middleware/issdk/drivers/systick;../../../../../../../middleware/issdk/drivers/gpio;../../../../../../../middleware/issdk/drivers/gpio/lpc;../../../../../../../middleware/issdk/sensors;../../../../../../../devices/LPC55S69/utilities/str;../../../../../../../devices/LPC55S69/utilities/debug_console;../../../../../../../components/uart;../../../../../../../components/serial_manager;../../../../../../../components/lists;../../../../../../../CMSIS/Driver/Include;../../../../../../../devices/LPC55S69/utilities
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: ../../../../../../../devices/LPC55S69/arm/keil_lib_power_cm33_core0.lib --remove
  group board
    ../../../../../: lpc55s69.c lpc55s69.h frdm_stbc_agm01_shield.h issdk_hal.h RTE_Device.h
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source
    ../: fxas21002_poll.c
  group doc
    ../: readme.txt readme.txt
  group drivers
    ../../../../../../../devices/LPC55S69/drivers/: fsl_dma.c fsl_dma.h fsl_gint.c fsl_gint.h fsl_flexcomm.c fsl_flexcomm.h fsl_i2c.c fsl_i2c.h fsl_i2c_dma.c fsl_i2c_dma.h fsl_spi.c fsl_spi.h fsl_spi_dma.c fsl_spi_dma.h fsl_usart.c fsl_usart.h fsl_usart_dma.c fsl_usart_dma.h fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_power.c fsl_power.h fsl_iocon.h fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h fsl_gpio.c fsl_gpio.h fsl_reset.c fsl_reset.h
    ../../../../../../../devices/LPC55S69/cmsis_drivers/: fsl_i2c_cmsis.c fsl_i2c_cmsis.h fsl_spi_cmsis.c fsl_spi_cmsis.h fsl_usart_cmsis.c fsl_usart_cmsis.h
  group utilities
    ../../../../../../../middleware/issdk/drivers/systick/: systick_utils.c systick_utils.h
    ../../../../../../../devices/LPC55S69/utilities/: fsl_assert.c
    ../../../../../../../devices/LPC55S69/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group gpio_driver
    ../../../../../../../middleware/issdk/drivers/gpio/: Driver_GPIO.h
    ../../../../../../../middleware/issdk/drivers/gpio/lpc/: gpio_driver.c gpio_driver.h gpio_driver_irq.c
  group interfaces
    ../../../../../../../middleware/issdk/sensors/: register_io_i2c.c register_io_i2c.h register_io_spi.c register_io_spi.h sensor_drv.h sensor_io_i2c.c sensor_io_i2c.h sensor_io_spi.c sensor_io_spi.h
  group sensors
    ../../../../../../../middleware/issdk/sensors/: fxas21002.h fxas21002_drv.c fxas21002_drv.h
  group device
    ../../../../../../../devices/LPC55S69/: LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h fsl_device_registers.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group startup
    ../../../../../../../devices/LPC55S69/arm/: startup_LPC55S69_cm33_core0.S
  group component-uart
    ../../../../../../../components/uart/: uart.h usart_adapter.c
  group component-serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm33.h mpu_armv8.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_I2C.h Driver_Common.h Driver_SPI.h Driver_USART.h
target fxas21002_poll_niobe4 release (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: fxas21002_poll_niobe4.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_LPC55S69JBD100_cm33_core0, PRINTF_ADVANCED_ENABLE=1, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: as above
