# IAR project cmsis_enet_txrx_transfer_m40.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8QM6_M4_0 NXP MIMX8QM6_M4_0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MIMX8QM6AVUFF_cm4_core0; MIMX8QM_CM4_CORE0; PHY_STABILITY_DELAY_US=500000U
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../../devices/MIMX8QM6/drivers; ../../../../../../../components/phy/mdio/enet; ../../../../../../../components/phy/device/phyar8031; ../../../../../../../devices/MIMX8QM6/utilities/debug_console_lite; ../../../../../../../devices/MIMX8QM6/cmsis_drivers; ../../../../../../../devices/MIMX8QM6; ../../../../../../../devices/MIMX8QM6/scfw_api/main; ../../../../../../../devices/MIMX8QM6/scfw_api/svc/irq; ../../../../../../../devices/MIMX8QM6/scfw_api/svc/misc; ../../../../../../../devices/MIMX8QM6/scfw_api/svc/pad; ../../../../../../../devices/MIMX8QM6/scfw_api/svc/pm; ../../../../../../../devices/MIMX8QM6/scfw_api/svc/rm; ../../../../../../../devices/MIMX8QM6/scfw_api/svc/seco; ../../../../../../../devices/MIMX8QM6/scfw_api/svc/timer; ../../../../../../../devices/MIMX8QM6/scfw_api; ../../../../../../../devices/MIMX8QM6/scfw_api/svc; ../../../../../../../components/uart; ../../../../../../../components/lists; ../../../../../../../CMSIS/Include; ../../../../../../../components/phy; ../../../../../../../CMSIS/Driver/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: m4_image.bin
  ILINK.IlinkOutputFile: cmsis_enet_txrx_transfer_m40.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x1000; __ram_vector_table__=1
  ILINK.IlinkIcfFile: MIMX8QM6xxxFF_cm4_core0_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMX8QM6AVUFF_cm4_core0; MIMX8QM_CM4_CORE0; PHY_STABILITY_DELAY_US=500000U
  AARM.ADefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8QM6xxxFF_cm4_core0_flash.icf
configuration ddr_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMX8QM6AVUFF_cm4_core0; MIMX8QM_CM4_CORE0; PHY_STABILITY_DELAY_US=500000U
  AARM.ADefines: as above
  ILINK.IlinkIcfFile: MIMX8QM6xxxFF_cm4_core0_ddr_ram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMX8QM6AVUFF_cm4_core0; MIMX8QM_CM4_CORE0; PHY_STABILITY_DELAY_US=500000U
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMX8QM6AVUFF_cm4_core0; MIMX8QM_CM4_CORE0; PHY_STABILITY_DELAY_US=500000U
  ICCARM.CCOptLevel: 3
  AARM.ADefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8QM6xxxFF_cm4_core0_flash.icf
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; NDEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMX8QM6AVUFF_cm4_core0; MIMX8QM_CM4_CORE0; PHY_STABILITY_DELAY_US=500000U
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  ILINK.IlinkIcfFile: MIMX8QM6xxxFF_cm4_core0_ddr_ram.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h RTE_Device.h
  group doc
    ../: readme.txt
  group remoteproc
    ../: empty_rsc_table.c
  group source
    ../: cmsis_enet_txrx_transfer.c
  group drivers
    ../../../../../../../devices/MIMX8QM6/drivers/: fsl_irqsteer.h fsl_irqsteer.c fsl_memory.h fsl_cache.c fsl_cache.h fsl_clock.h fsl_clock.c fsl_enet.h fsl_enet.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_edma.h fsl_edma.c
    ../../../../../../../devices/MIMX8QM6/cmsis_drivers/: fsl_enet_cmsis.h fsl_enet_cmsis.c fsl_enet_phy_cmsis.c fsl_enet_phy_cmsis.h
  group mdio
    ../../../../../../../components/phy/mdio/enet/: fsl_enet_mdio.h fsl_enet_mdio.c
    ../../../../../../../components/phy/: fsl_mdio.h
  group phy
    ../../../../../../../components/phy/device/phyar8031/: fsl_phyar8031.h fsl_phyar8031.c
    ../../../../../../../components/phy/: fsl_phy.h
  group utilities
    ../../../../../../../devices/MIMX8QM6/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group device
    ../../../../../../../devices/MIMX8QM6/: fsl_device_registers.h MIMX8QM6_cm4_core0.h MIMX8QM6_cm4_core0_features.h
  group MIMX8QM6
    ../../../../../../../devices/MIMX8QM6/: system_MIMX8QM6_cm4_core0.c system_MIMX8QM6_cm4_core0.h
  group MIMX8QM6/iar
    ../../../../../../../devices/MIMX8QM6/iar/: startup_MIMX8QM6_cm4_core0.s
  group scfw_api/main
    ../../../../../../../devices/MIMX8QM6/scfw_api/main/: imx8qm_pads.h ipc.h ipc_imx8qm.c rpc.h scfw.h types.h
  group scfw_api/svc/irq
    ../../../../../../../devices/MIMX8QM6/scfw_api/svc/irq/: irq_api.h irq_rpc.h irq_rpc_clnt.c
  group scfw_api/svc/misc
    ../../../../../../../devices/MIMX8QM6/scfw_api/svc/misc/: misc_api.h misc_rpc.h misc_rpc_clnt.c
  group scfw_api/svc/pad
    ../../../../../../../devices/MIMX8QM6/scfw_api/svc/pad/: pad_api.h pad_rpc.h pad_rpc_clnt.c
  group scfw_api/svc/pm
    ../../../../../../../devices/MIMX8QM6/scfw_api/svc/pm/: pm_api.h pm_rpc.h pm_rpc_clnt.c
  group scfw_api/svc/rm
    ../../../../../../../devices/MIMX8QM6/scfw_api/svc/rm/: rm_api.h rm_rpc.h rm_rpc_clnt.c
  group scfw_api/svc/seco
    ../../../../../../../devices/MIMX8QM6/scfw_api/svc/seco/: seco_api.h seco_rpc.h seco_rpc_clnt.c
  group scfw_api/svc/timer
    ../../../../../../../devices/MIMX8QM6/scfw_api/svc/timer/: timer_api.h timer_rpc.h timer_rpc_clnt.c
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_ETH_MAC.h Driver_ETH.h Driver_Common.h Driver_ETH_PHY.h
