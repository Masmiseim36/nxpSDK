# IAR project power_mode_switch_m41.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8QM6_M4_1 NXP MIMX8QM6_M4_1
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; SDK_I2C_BASED_COMPONENT_USED=1; CPU_MIMX8QM6AVUFF_cm4_core1; MIMX8QM_CM4_CORE1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../..; ../srtm/channels; ../srtm/services; ../../../../../../devices/MIMX8QM6/drivers; ../../../../../../devices/MIMX8QM6; ../../../../../../devices/MIMX8QM6/scfw_api/main; ../../../../../../devices/MIMX8QM6/scfw_api/svc/irq; ../../../../../../devices/MIMX8QM6/scfw_api/svc/misc; ../../../../../../devices/MIMX8QM6/scfw_api/svc/pad; ../../../../../../devices/MIMX8QM6/scfw_api/svc/pm; ../../../../../../devices/MIMX8QM6/scfw_api/svc/rm; ../../../../../../devices/MIMX8QM6/scfw_api/svc/seco; ../../../../../../devices/MIMX8QM6/scfw_api/svc/timer; ../../../../../../devices/MIMX8QM6/scfw_api; ../../../../../../devices/MIMX8QM6/scfw_api/svc; ../../../../../../devices/MIMX8QM6/utilities/str; ../../../../../../devices/MIMX8QM6/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../CMSIS/Include; ../../../../../../components/srtm/include; ../../../../../../components/srtm/srtm; ../../../../../../rtos/freertos/freertos_kernel/include; ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F; ../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imx8qm_m4; ../../../../../../middleware/multicore/rpmsg_lite/lib/include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_RESUMEMEM; FSL_RTOS_FREE_RTOS; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: power_mode_switch_m41.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x400
  ILINK.IlinkIcfFile: MIMX8QM6xxxFF_cm4_core1_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; CPU_MIMX8QM6AVUFF_cm4_core1; MIMX8QM_CM4_CORE1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  AARM.ADefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; __STARTUP_INITIALIZE_RESUMEMEM; FSL_RTOS_FREE_RTOS; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8QM6xxxFF_cm4_core1_flash.icf
configuration ddr_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  AARM.ADefines: as above
  ILINK.IlinkIcfFile: MIMX8QM6xxxFF_cm4_core1_ddr_ram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SDK_I2C_BASED_COMPONENT_USED=1; CPU_MIMX8QM6AVUFF_cm4_core1; MIMX8QM_CM4_CORE1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_RESUMEMEM; FSL_RTOS_FREE_RTOS; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; CPU_MIMX8QM6AVUFF_cm4_core1; MIMX8QM_CM4_CORE1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; __STARTUP_INITIALIZE_RESUMEMEM; FSL_RTOS_FREE_RTOS; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8QM6xxxFF_cm4_core1_flash.icf
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  ILINK.IlinkIcfFile: MIMX8QM6xxxFF_cm4_core1_ddr_ram.icf
  group remoteproc
    ../: rsc_table.c rsc_table.h remoteproc.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group source
    ../: lpm.c lpm.h power_mode_switch.c power_mode_switch.h FreeRTOSConfig.h rpmsg_config.h
    ./: lpm_asm.s
  group mekmimx8qm
    ../: app_srtm.c app_srtm.h
  group srtm/channels
    ../srtm/channels/: srtm_rpmsg_endpoint.h srtm_rpmsg_endpoint.c
  group srtm/services
    ../srtm/services/: srtm_i2c_service.h srtm_i2c_service.c
  group srtm/port
    ../../../../../../components/srtm/port/: srtm_heap_freertos.c srtm_mutex_freertos.c srtm_sem_freertos.c srtm_message_pool.c
  group srtm/include
    ../../../../../../components/srtm/include/: srtm_channel.h srtm_defs.h srtm_dispatcher.h srtm_message.h srtm_peercore.h srtm_service.h
  group srtm/srtm
    ../../../../../../components/srtm/srtm/: srtm_channel.c srtm_channel_struct.h srtm_dispatcher.c srtm_dispatcher_struct.h srtm_message.c srtm_message_struct.h srtm_peercore.c srtm_peercore_struct.h srtm_service.c srtm_service_struct.h srtm_heap.h srtm_message_pool.h srtm_list.h srtm_mutex.h srtm_sem.h
  group drivers
    ../../../../../../devices/MIMX8QM6/drivers/: fsl_rgpio.h fsl_rgpio.c fsl_flexcan.h fsl_flexcan.c fsl_asmc.h fsl_asmc.c fsl_irqsteer.h fsl_irqsteer.c fsl_gpt.c fsl_gpt.h fsl_tstmr.h fsl_gpio.h fsl_gpio.c fsl_lpit.c fsl_lpit.h fsl_wdog32.h fsl_wdog32.c fsl_sc_event.h fsl_sc_event.c fsl_lpi2c.c fsl_lpi2c.h fsl_mu.h fsl_mu.c fsl_memory.h fsl_cache.c fsl_cache.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_intmux.h fsl_intmux.c
  group drivers/freertos
    ../../../../../../devices/MIMX8QM6/drivers/: fsl_lpi2c_freertos.h fsl_lpi2c_freertos.c
  group freertos/freertos_kernel
    ../../../../../../rtos/freertos/freertos_kernel/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/include
    ../../../../../../rtos/freertos/freertos_kernel/include/: croutine.h StackMacros.h atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group device
    ../../../../../../devices/MIMX8QM6/: fsl_device_registers.h MIMX8QM6_cm4_core1.h MIMX8QM6_cm4_core1_features.h
  group MIMX8QM6
    ../../../../../../devices/MIMX8QM6/: system_MIMX8QM6_cm4_core1.c system_MIMX8QM6_cm4_core1.h
  group MIMX8QM6/iar
    ../../../../../../devices/MIMX8QM6/iar/: startup_MIMX8QM6_cm4_core1.s
  group scfw_api/main
    ../../../../../../devices/MIMX8QM6/scfw_api/main/: imx8qm_pads.h ipc.h ipc_imx8qm.c rpc.h scfw.h types.h
  group scfw_api/svc/irq
    ../../../../../../devices/MIMX8QM6/scfw_api/svc/irq/: irq_api.h irq_rpc.h irq_rpc_clnt.c
  group scfw_api/svc/misc
    ../../../../../../devices/MIMX8QM6/scfw_api/svc/misc/: misc_api.h misc_rpc.h misc_rpc_clnt.c
  group scfw_api/svc/pad
    ../../../../../../devices/MIMX8QM6/scfw_api/svc/pad/: pad_api.h pad_rpc.h pad_rpc_clnt.c
  group scfw_api/svc/pm
    ../../../../../../devices/MIMX8QM6/scfw_api/svc/pm/: pm_api.h pm_rpc.h pm_rpc_clnt.c
  group scfw_api/svc/rm
    ../../../../../../devices/MIMX8QM6/scfw_api/svc/rm/: rm_api.h rm_rpc.h rm_rpc_clnt.c
  group scfw_api/svc/seco
    ../../../../../../devices/MIMX8QM6/scfw_api/svc/seco/: seco_api.h seco_rpc.h seco_rpc_clnt.c
  group scfw_api/svc/timer
    ../../../../../../devices/MIMX8QM6/scfw_api/svc/timer/: timer_api.h timer_rpc.h timer_rpc_clnt.c
  group utilities
    ../../../../../../devices/MIMX8QM6/utilities/: fsl_assert.c
    ../../../../../../devices/MIMX8QM6/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMX8QM6/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group rpmsg_lite
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_lite.h rpmsg_ns.h llist.h rpmsg_default_config.h virtio_ring.h virtqueue.h rpmsg_compiler.h rpmsg_env.h rpmsg_queue.h
    ../../../../../../middleware/multicore/rpmsg_lite/lib/common/: llist.c
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c
    ../../../../../../middleware/multicore/rpmsg_lite/lib/virtio/: virtqueue.c
  group rpmsg_lite/porting
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imx8qm_m4/: rpmsg_platform.h
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/platform/imx8qm_m4/: rpmsg_platform.c
  group rpmsg_lite/env/freertos
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_freertos.c
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_queue.c
