# IAR project lwip_mqtt_freertos_m40.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8QM6_M4_0 NXP MIMX8QM6_M4_0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MIMX8QM6AVUFF_cm4_core0; MIMX8QM_CM4_CORE0; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../../devices/MIMX8QM6/drivers; ../../../../../../../components/phy/mdio/enet; ../../../../../../../components/phy/device/phyar8031; ../../../../../../../middleware/lwip/src/include/lwip/apps; ../../../../../../../middleware/lwip/port; ../../../../../../../middleware/lwip/src; ../../../../../../../middleware/lwip/src/include; ../../../../../../../components/phy; ../../../../../../../devices/MIMX8QM6/utilities/str; ../../../../../../../devices/MIMX8QM6/utilities/debug_console; ../../../../../../../devices/MIMX8QM6; ../../../../../../../devices/MIMX8QM6/scfw_api/main; ../../../../../../../devices/MIMX8QM6/scfw_api/svc/irq; ../../../../../../../devices/MIMX8QM6/scfw_api/svc/misc; ../../../../../../../devices/MIMX8QM6/scfw_api/svc/pad; ../../../../../../../devices/MIMX8QM6/scfw_api/svc/pm; ../../../../../../../devices/MIMX8QM6/scfw_api/svc/rm; ../../../../../../../devices/MIMX8QM6/scfw_api/svc/seco; ../../../../../../../devices/MIMX8QM6/scfw_api/svc/timer; ../../../../../../../devices/MIMX8QM6/scfw_api; ../../../../../../../devices/MIMX8QM6/scfw_api/svc; ../../../../../../../components/uart; ../../../../../../../components/serial_manager; ../../../../../../../components/lists; ../../../../../../../CMSIS/Include; ../../../../../../../rtos/freertos/freertos_kernel/include; ../../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../../../../..
  OBJCOPY.OOCOutputFile: m4_image.bin
  ILINK.IlinkOutputFile: lwip_mqtt_freertos_m40.out
  ILINK.IlinkConfigDefines: __stack_size__=1000; __heap_size__=25600
  ILINK.IlinkIcfFile: MIMX8QM6xxxFF_cm4_core0_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMX8QM6AVUFF_cm4_core0; MIMX8QM_CM4_CORE0; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  AARM.ADefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8QM6xxxFF_cm4_core0_flash.icf
configuration ddr_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMX8QM6AVUFF_cm4_core0; MIMX8QM_CM4_CORE0; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  AARM.ADefines: as above
  ILINK.IlinkIcfFile: MIMX8QM6xxxFF_cm4_core0_ddr_ram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMX8QM6AVUFF_cm4_core0; MIMX8QM_CM4_CORE0; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMX8QM6AVUFF_cm4_core0; MIMX8QM_CM4_CORE0; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8QM6xxxFF_cm4_core0_flash.icf
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; NDEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMX8QM6AVUFF_cm4_core0; MIMX8QM_CM4_CORE0; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  ILINK.IlinkIcfFile: MIMX8QM6xxxFF_cm4_core0_ddr_ram.icf
  group source
    ../: lwip_mqtt_freertos.c lwipopts.h FreeRTOSConfig.h lwip_mqtt_id.h lwip_mqtt_id_scfw.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group remoteproc
    ../: empty_rsc_table.c
  group drivers
    ../../../../../../../devices/MIMX8QM6/drivers/: fsl_irqsteer.h fsl_irqsteer.c fsl_memory.h fsl_cache.c fsl_cache.h fsl_enet.h fsl_enet.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c
  group mdio
    ../../../../../../../components/phy/mdio/enet/: fsl_enet_mdio.h fsl_enet_mdio.c
    ../../../../../../../components/phy/: fsl_mdio.h
  group phy
    ../../../../../../../components/phy/device/phyar8031/: fsl_phyar8031.h fsl_phyar8031.c
    ../../../../../../../components/phy/: fsl_phy.h
  group lwip/src/apps/mqtt
    ../../../../../../../middleware/lwip/src/apps/mqtt/: mqtt.c
  group lwip/src/include/lwip
    ../../../../../../../middleware/lwip/src/include/lwip/: err.h sio.h ip6.h netdb.h altcp_tcp.h arch.h debug.h ip6_addr.h sockets.h if_api.h init.h tcpbase.h tcpip.h def.h inet_chksum.h snmp.h api.h ip4.h inet.h igmp.h altcp_tls.h netif.h opt.h ip.h acd.h tcp.h ip6_frag.h altcp.h ip4_addr.h ip4_frag.h netbuf.h autoip.h dns.h sys.h dhcp.h ip_addr.h icmp6.h mem.h raw.h ip6_zone.h stats.h ethip6.h icmp.h pbuf.h netifapi.h nd6.h etharp.h errno.h mld6.h timeouts.h dhcp6.h udp.h memp.h
  group lwip/src/include/lwip/apps
    ../../../../../../../middleware/lwip/src/include/lwip/apps/: mqtt.h mqtt_opts.h mqtt_priv.h
  group lwip/src/include/lwip/priv
    ../../../../../../../middleware/lwip/src/include/lwip/priv/: api_msg.h tcpip_priv.h mem_priv.h altcp_priv.h nd6_priv.h tcp_priv.h memp_std.h sockets_priv.h raw_priv.h memp_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../../../middleware/lwip/src/include/lwip/prot/: ip6.h ethernet.h ip4.h igmp.h ip.h acd.h tcp.h ieee.h iana.h autoip.h dns.h dhcp.h icmp6.h icmp.h nd6.h etharp.h mld6.h dhcp6.h udp.h
  group lwip/src/include/compat/stdc
    ../../../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/compat/posix
    ../../../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/sys
    ../../../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/compat/posix/net
    ../../../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/netif
    ../../../../../../../middleware/lwip/src/include/netif/: bridgeif_opts.h ethernet.h zepif.h ieee802154.h lowpan6.h lowpan6_common.h lowpan6_ble.h lowpan6_opts.h bridgeif.h slipif.h etharp.h
  group lwip/src/include/netif/ppp
    ../../../../../../../middleware/lwip/src/include/netif/ppp/: eap.h pppol2tp.h chap-md5.h pppcrypt.h ppp.h upap.h pppapi.h ipv6cp.h pppdebug.h pppoe.h mppe.h pppos.h ppp_opts.h chap-new.h ipcp.h lcp.h ccp.h ppp_impl.h eui64.h vj.h ecp.h magic.h fsm.h chap_ms.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: sha1.h md5.h arc4.h md4.h des.h
  group lwip/src/api
    ../../../../../../../middleware/lwip/src/api/: api_lib.c tcpip.c netdb.c sockets.c if_api.c netbuf.c netifapi.c api_msg.c err.c
  group lwip/src/core
    ../../../../../../../middleware/lwip/src/core/: altcp.c sys.c stats.c def.c ip.c netif.c dns.c tcp_out.c pbuf.c timeouts.c init.c tcp_in.c altcp_tcp.c raw.c tcp.c udp.c altcp_alloc.c mem.c inet_chksum.c memp.c
  group lwip/src/core/ipv6
    ../../../../../../../middleware/lwip/src/core/ipv6/: icmp6.c ethip6.c nd6.c ip6_frag.c inet6.c ip6.c dhcp6.c mld6.c ip6_addr.c
  group lwip/src/core/ipv4
    ../../../../../../../middleware/lwip/src/core/ipv4/: igmp.c ip4.c dhcp.c etharp.c ip4_frag.c icmp.c autoip.c acd.c ip4_addr.c
  group lwip/src/netif
    ../../../../../../../middleware/lwip/src/netif/: lowpan6.c lowpan6_ble.c ethernet.c lowpan6_common.c slipif.c bridgeif.c bridgeif_fdb.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../../../middleware/lwip/src/netif/ppp/: utils.c pppol2tp.c chap_ms.c vj.c pppos.c lwip_ecp.c magic.c eui64.c chap-md5.c auth.c ppp.c ccp.c pppapi.c eap.c mppe.c ipv6cp.c ipcp.c lcp.c pppcrypt.c pppoe.c chap-new.c demand.c upap.c multilink.c fsm.c
  group lwip/port
    ../../../../../../../middleware/lwip/port/: enet_ethernetif.c enet_ethernetif.h enet_ethernetif_priv.h enet_ethernetif_kinetis.c sys_arch.c
  group lwip/port/arch
    ../../../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group utilities
    ../../../../../../../devices/MIMX8QM6/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MIMX8QM6/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/MIMX8QM6/utilities/: fsl_assert.c
  group freertos/freertos_kernel
    ../../../../../../../rtos/freertos/freertos_kernel/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_3.c ReadMe.url
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/include
    ../../../../../../../rtos/freertos/freertos_kernel/include/: croutine.h StackMacros.h atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group device
    ../../../../../../../devices/MIMX8QM6/: fsl_device_registers.h MIMX8QM6_cm4_core0.h MIMX8QM6_cm4_core0_features.h
  group MIMX8QM6
    ../../../../../../../devices/MIMX8QM6/: system_MIMX8QM6_cm4_core0.c system_MIMX8QM6_cm4_core0.h
  group MIMX8QM6/iar
    ../../../../../../../devices/MIMX8QM6/iar/: startup_MIMX8QM6_cm4_core0.s
  group scfw_api/main
    ../../../../../../../devices/MIMX8QM6/scfw_api/main/: imx8qm_pads.h ipc.h ipc_imx8qm.c rpc.h scfw.h types.h
  group scfw_api/svc/irq
    ../../../../../../../devices/MIMX8QM6/scfw_api/svc/irq/: irq_api.h irq_rpc.h irq_rpc_clnt.c
  group scfw_api/svc/misc
    ../../../../../../../devices/MIMX8QM6/scfw_api/svc/misc/: misc_api.h misc_rpc.h misc_rpc_clnt.c
  group scfw_api/svc/pad
    ../../../../../../../devices/MIMX8QM6/scfw_api/svc/pad/: pad_api.h pad_rpc.h pad_rpc_clnt.c
  group scfw_api/svc/pm
    ../../../../../../../devices/MIMX8QM6/scfw_api/svc/pm/: pm_api.h pm_rpc.h pm_rpc_clnt.c
  group scfw_api/svc/rm
    ../../../../../../../devices/MIMX8QM6/scfw_api/svc/rm/: rm_api.h rm_rpc.h rm_rpc_clnt.c
  group scfw_api/svc/seco
    ../../../../../../../devices/MIMX8QM6/scfw_api/svc/seco/: seco_api.h seco_rpc.h seco_rpc_clnt.c
  group scfw_api/svc/timer
    ../../../../../../../devices/MIMX8QM6/scfw_api/svc/timer/: timer_api.h timer_rpc.h timer_rpc_clnt.c
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
