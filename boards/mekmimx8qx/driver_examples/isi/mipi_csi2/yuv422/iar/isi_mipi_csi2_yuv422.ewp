# IAR project isi_mipi_csi2_yuv422.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8QX6_M4 NXP MIMX8QX6_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MIMX8QX6AVLFZ; SDK_I2C_BASED_COMPONENT_USED=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../../devices/MIMX8QX6/drivers; ../../../../../../../components/video; ../../../../../../../components/video/i2c; ../../../../../../../components/video/display; ../../../../../../../components/video/display/adv7535; ../../../../../../../components/video/display/rm67191; ../../../../../../../components/video/display/mipi_dsi_cmd; ../../../../../../../components/video/camera/device/ov5640; ../../../../../../../components/video/camera/device/sccb; ../../../../../../../components/video/display/it6263; ../../../../../../../components/video/camera/device/max9286; ../../../../../../../devices/MIMX8QX6/utilities/debug_console_lite; ../../../../../../../components/video/camera; ../../../../../../../components/video/camera/device; ../../../../../../../components/video/camera/receiver; ../../../../../../../components/video/camera/receiver/isi; ../../../../../../../devices/MIMX8QX6; ../../../../../../../components/uart; ../../../../../../../components/lists; ../../../../../../../devices/MIMX8QX6/scfw_api/main; ../../../../../../../devices/MIMX8QX6/scfw_api/svc/irq; ../../../../../../../devices/MIMX8QX6/scfw_api/svc/misc; ../../../../../../../devices/MIMX8QX6/scfw_api/svc/pad; ../../../../../../../devices/MIMX8QX6/scfw_api/svc/pm; ../../../../../../../devices/MIMX8QX6/scfw_api/svc/rm; ../../../../../../../devices/MIMX8QX6/scfw_api/svc/seco; ../../../../../../../devices/MIMX8QX6/scfw_api/svc/timer; ../../../../../../../devices/MIMX8QX6/scfw_api; ../../../../../../../devices/MIMX8QX6/scfw_api/svc; ../../../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: isi_mipi_csi2_yuv422.out
  ILINK.IlinkIcfFile: MIMX8QX6xxxxx_cm4_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMX8QX6AVLFZ; SDK_I2C_BASED_COMPONENT_USED=1
  AARM.ADefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8QX6xxxxx_cm4_flash.icf
configuration ddr_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  AARM.ADefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; __STARTUP_CONFIG_DDR_ALIAS=1; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkConfigDefines: __STARTUP_CONFIG_DDR_ALIAS=1
  ILINK.IlinkIcfFile: MIMX8QX6xxxxx_cm4_ddr_ram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMX8QX6AVLFZ; SDK_I2C_BASED_COMPONENT_USED=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  ILINK.IlinkIcfFile: MIMX8QX6xxxxx_cm4_flash.icf
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  ILINK.IlinkConfigDefines: __STARTUP_CONFIG_DDR_ALIAS=1
  ILINK.IlinkIcfFile: MIMX8QX6xxxxx_cm4_ddr_ram.icf
  group source
    ../: isi_mipi_csi2_yuv422.c app_display.h app_display.c
  group board
    ../: pin_mux.c pin_mux.h isi_board.c isi_config.h isi_example.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group remoteproc
    ../: empty_rsc_table.c
  group drivers
    ../../../../../../../devices/MIMX8QX6/drivers/: fsl_irqsteer.h fsl_irqsteer.c fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_lpi2c.c fsl_lpi2c.h fsl_dpu.c fsl_dpu.h fsl_dpu_irqsteer.h fsl_ldb.h fsl_ldb.c fsl_prg.c fsl_prg.h fsl_dpr.c fsl_dpr.h fsl_gpio.h fsl_gpio.c fsl_isi.c fsl_isi.h fsl_mipi_csi2rx.c fsl_mipi_csi2rx.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c
  group video
    ../../../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../../../components/video/i2c/: fsl_video_i2c.h fsl_video_i2c.c
    ../../../../../../../components/video/display/: fsl_display.h
    ../../../../../../../components/video/display/adv7535/: fsl_adv7535.h fsl_adv7535.c
    ../../../../../../../components/video/display/rm67191/: fsl_rm67191.h fsl_rm67191.c
    ../../../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
    ../../../../../../../components/video/camera/device/ov5640/: fsl_ov5640.h fsl_ov5640.c
    ../../../../../../../components/video/camera/device/sccb/: fsl_sccb.h fsl_sccb.c
    ../../../../../../../components/video/display/it6263/: fsl_it6263.h fsl_it6263.c
    ../../../../../../../components/video/camera/device/max9286/: fsl_max9286.h fsl_max9286.c
    ../../../../../../../components/video/camera/: fsl_camera.h
    ../../../../../../../components/video/camera/device/: fsl_camera_device.h
    ../../../../../../../components/video/camera/receiver/: fsl_camera_receiver.h
    ../../../../../../../components/video/camera/receiver/isi/: fsl_isi_camera_adapter.h fsl_isi_camera_adapter.c
  group utilities
    ../../../../../../../devices/MIMX8QX6/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group device
    ../../../../../../../devices/MIMX8QX6/: fsl_device_registers.h MIMX8QX6_cm4.h MIMX8QX6_cm4_features.h system_MIMX8QX6_cm4.c system_MIMX8QX6_cm4.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group MIMX8QX6/iar
    ../../../../../../../devices/MIMX8QX6/iar/: startup_MIMX8QX6_cm4.s
  group scfw_api/main
    ../../../../../../../devices/MIMX8QX6/scfw_api/main/: imx8qx_pads.h ipc.h ipc_imx8qx.c rpc.h scfw.h types.h
  group scfw_api/svc/irq
    ../../../../../../../devices/MIMX8QX6/scfw_api/svc/irq/: irq_api.h irq_rpc.h irq_rpc_clnt.c
  group scfw_api/svc/misc
    ../../../../../../../devices/MIMX8QX6/scfw_api/svc/misc/: misc_api.h misc_rpc.h misc_rpc_clnt.c
  group scfw_api/svc/pad
    ../../../../../../../devices/MIMX8QX6/scfw_api/svc/pad/: pad_api.h pad_rpc.h pad_rpc_clnt.c
  group scfw_api/svc/pm
    ../../../../../../../devices/MIMX8QX6/scfw_api/svc/pm/: pm_api.h pm_rpc.h pm_rpc_clnt.c
  group scfw_api/svc/rm
    ../../../../../../../devices/MIMX8QX6/scfw_api/svc/rm/: rm_api.h rm_rpc.h rm_rpc_clnt.c
  group scfw_api/svc/seco
    ../../../../../../../devices/MIMX8QX6/scfw_api/svc/seco/: seco_api.h seco_rpc.h seco_rpc_clnt.c
  group scfw_api/svc/timer
    ../../../../../../../devices/MIMX8QX6/scfw_api/svc/timer/: timer_api.h timer_rpc.h timer_rpc_clnt.c
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
