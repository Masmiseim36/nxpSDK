# IAR project sai_edma_transfer.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8QX6_M4 NXP MIMX8QX6_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MIMX8QX6AVLFZ; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MIMX8QX6/drivers; ../../../../../../components/codec/wm8960; ../../../../../../components/codec; ../../../../../../components/codec/port/wm8960; ../../../../../../components/codec/i2c; ../../../../../../components/i2c; ../../../../../../devices/MIMX8QX6/utilities/debug_console_lite; ../../../../../../devices/MIMX8QX6; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../../../devices/MIMX8QX6/scfw_api/main; ../../../../../../devices/MIMX8QX6/scfw_api/svc/irq; ../../../../../../devices/MIMX8QX6/scfw_api/svc/misc; ../../../../../../devices/MIMX8QX6/scfw_api/svc/pad; ../../../../../../devices/MIMX8QX6/scfw_api/svc/pm; ../../../../../../devices/MIMX8QX6/scfw_api/svc/rm; ../../../../../../devices/MIMX8QX6/scfw_api/svc/seco; ../../../../../../devices/MIMX8QX6/scfw_api/svc/timer; ../../../../../../devices/MIMX8QX6/scfw_api; ../../../../../../devices/MIMX8QX6/scfw_api/svc; ../../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: sai_edma_transfer.out
  ILINK.IlinkIcfFile: MIMX8QX6xxxxx_cm4_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMX8QX6AVLFZ; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE
  AARM.ADefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8QX6xxxxx_cm4_flash.icf
configuration ddr_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  AARM.ADefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; __STARTUP_CONFIG_DDR_ALIAS=1; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkConfigDefines: __STARTUP_CONFIG_DDR_ALIAS=1
  ILINK.IlinkIcfFile: MIMX8QX6xxxxx_cm4_ddr_ram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMX8QX6AVLFZ; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  ILINK.IlinkIcfFile: MIMX8QX6xxxxx_cm4_flash.icf
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  ILINK.IlinkConfigDefines: __STARTUP_CONFIG_DDR_ALIAS=1
  ILINK.IlinkIcfFile: MIMX8QX6xxxxx_cm4_ddr_ram.icf
  group source
    ../: sai_edma_transfer.c music.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group remoteproc
    ../: empty_rsc_table.c
  group drivers
    ../../../../../../devices/MIMX8QX6/drivers/: fsl_lpi2c.c fsl_lpi2c.h fsl_irqsteer.h fsl_irqsteer.c fsl_edma.h fsl_edma.c fsl_memory.h fsl_sai_edma.h fsl_sai_edma.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_sai.h fsl_sai.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c
  group codec
    ../../../../../../components/codec/wm8960/: fsl_wm8960.h fsl_wm8960.c
    ../../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../../components/codec/port/wm8960/: fsl_codec_adapter.c fsl_codec_adapter.h
    ../../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
  group component/i2c
    ../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group utilities
    ../../../../../../devices/MIMX8QX6/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group device
    ../../../../../../devices/MIMX8QX6/: fsl_device_registers.h MIMX8QX6_cm4.h MIMX8QX6_cm4_features.h system_MIMX8QX6_cm4.c system_MIMX8QX6_cm4.h
  group MIMX8QX6/iar
    ../../../../../../devices/MIMX8QX6/iar/: startup_MIMX8QX6_cm4.s
  group scfw_api/main
    ../../../../../../devices/MIMX8QX6/scfw_api/main/: imx8qx_pads.h ipc.h ipc_imx8qx.c rpc.h scfw.h types.h
  group scfw_api/svc/irq
    ../../../../../../devices/MIMX8QX6/scfw_api/svc/irq/: irq_api.h irq_rpc.h irq_rpc_clnt.c
  group scfw_api/svc/misc
    ../../../../../../devices/MIMX8QX6/scfw_api/svc/misc/: misc_api.h misc_rpc.h misc_rpc_clnt.c
  group scfw_api/svc/pad
    ../../../../../../devices/MIMX8QX6/scfw_api/svc/pad/: pad_api.h pad_rpc.h pad_rpc_clnt.c
  group scfw_api/svc/pm
    ../../../../../../devices/MIMX8QX6/scfw_api/svc/pm/: pm_api.h pm_rpc.h pm_rpc_clnt.c
  group scfw_api/svc/rm
    ../../../../../../devices/MIMX8QX6/scfw_api/svc/rm/: rm_api.h rm_rpc.h rm_rpc_clnt.c
  group scfw_api/svc/seco
    ../../../../../../devices/MIMX8QX6/scfw_api/svc/seco/: seco_api.h seco_rpc.h seco_rpc_clnt.c
  group scfw_api/svc/timer
    ../../../../../../devices/MIMX8QX6/scfw_api/svc/timer/: timer_api.h timer_rpc.h timer_rpc_clnt.c
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
