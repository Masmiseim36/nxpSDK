# IAR project rpmsg_lite_pingpong_rtos_linux_remote.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8QX6_M4 NXP MIMX8QX6_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MIMX8QX6AVLFZ; BOARD_USE_SCFW_IRQ; SDK_I2C_BASED_COMPONENT_USED=1; CODEC_CS42888_ENABLE; FSL_RTOS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../srtm/channels; ../srtm/services; ../../../../../../components/codec/cs42888; ../../../../../../devices/MIMX8QX6/drivers; ../../../../../../components/codec; ../../../../../../components/codec/port/cs42888; ../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imx8qx_cm4; ../../../../../../components/codec/i2c; ../../../../../../components/i2c; ../../../../../../rtos/freertos/freertos_kernel/include; ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F; ../../../../../../devices/MIMX8QX6; ../../../../../../devices/MIMX8QX6/utilities/str; ../../../../../../devices/MIMX8QX6/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../devices/MIMX8QX6/scfw_api/main; ../../../../../../devices/MIMX8QX6/scfw_api/svc/irq; ../../../../../../devices/MIMX8QX6/scfw_api/svc/misc; ../../../../../../devices/MIMX8QX6/scfw_api/svc/pad; ../../../../../../devices/MIMX8QX6/scfw_api/svc/pm; ../../../../../../devices/MIMX8QX6/scfw_api/svc/rm; ../../../../../../devices/MIMX8QX6/scfw_api/svc/seco; ../../../../../../devices/MIMX8QX6/scfw_api/svc/timer; ../../../../../../devices/MIMX8QX6/scfw_api; ../../../../../../devices/MIMX8QX6/scfw_api/svc; ../../../../../../CMSIS/Include; ../../../../../../components/srtm/include; ../../../../../../components/srtm/srtm; ../../../../../../middleware/multicore/rpmsg_lite/lib/include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: rpmsg_lite_pingpong_rtos_linux_remote.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x400
  ILINK.IlinkIcfFile: MIMX8QX6xxxxx_cm4_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMX8QX6AVLFZ; BOARD_USE_SCFW_IRQ; SDK_I2C_BASED_COMPONENT_USED=1; CODEC_CS42888_ENABLE; FSL_RTOS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1
  AARM.ADefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8QX6xxxxx_cm4_flash.icf
configuration ddr_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  AARM.ADefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; __STARTUP_CONFIG_DDR_ALIAS=1; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkConfigDefines: __STARTUP_CONFIG_DDR_ALIAS=1; __stack_size__=0x400; __heap_size__=0x400
  ILINK.IlinkIcfFile: MIMX8QX6xxxxx_cm4_ddr_ram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMX8QX6AVLFZ; BOARD_USE_SCFW_IRQ; SDK_I2C_BASED_COMPONENT_USED=1; CODEC_CS42888_ENABLE; FSL_RTOS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  ILINK.IlinkIcfFile: MIMX8QX6xxxxx_cm4_flash.icf
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  ILINK.IlinkConfigDefines: as above
  ILINK.IlinkIcfFile: MIMX8QX6xxxxx_cm4_ddr_ram.icf
  group source
    ../: main_remote.c FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h rpmsg_config.h board.c board.h clock_config.c clock_config.h
  group remoteproc
    ../: rsc_table.c rsc_table.h remoteproc.h
  group doc
    ../: readme.txt
  group mekmimx8qx
    ../: app_srtm.c app_srtm.h
  group srtm/channels
    ../srtm/channels/: srtm_rpmsg_endpoint.h srtm_rpmsg_endpoint.c srtm_mu_endpoint.h srtm_mu_endpoint.c
  group srtm/services
    ../srtm/services/: srtm_i2c_service.h srtm_i2c_service.c
  group srtm/port
    ../../../../../../components/srtm/port/: srtm_heap_freertos.c srtm_mutex_freertos.c srtm_sem_freertos.c srtm_message_pool.c
  group srtm/include
    ../../../../../../components/srtm/include/: srtm_channel.h srtm_defs.h srtm_dispatcher.h srtm_message.h srtm_peercore.h srtm_service.h
  group srtm/srtm
    ../../../../../../components/srtm/srtm/: srtm_channel.c srtm_channel_struct.h srtm_dispatcher.c srtm_dispatcher_struct.h srtm_message.c srtm_message_struct.h srtm_peercore.c srtm_peercore_struct.h srtm_service.c srtm_service_struct.h srtm_heap.h srtm_message_pool.h srtm_list.h srtm_mutex.h srtm_sem.h
  group codec
    ../../../../../../components/codec/cs42888/: fsl_cs42888.h fsl_cs42888.c
    ../../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../../components/codec/port/cs42888/: fsl_codec_adapter.c fsl_codec_adapter.h
    ../../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
  group drivers
    ../../../../../../devices/MIMX8QX6/drivers/: fsl_irqsteer.h fsl_irqsteer.c fsl_lpi2c.c fsl_lpi2c.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_mu.h fsl_mu.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_edma.h fsl_edma.c fsl_memory.h fsl_sai_edma.h fsl_sai_edma.c fsl_sai.h fsl_sai.c
  group drivers/freertos
    ../../../../../../devices/MIMX8QX6/drivers/: fsl_lpi2c_freertos.h fsl_lpi2c_freertos.c
  group freertos/freertos_kernel
    ../../../../../../rtos/freertos/freertos_kernel/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/include
    ../../../../../../rtos/freertos/freertos_kernel/include/: croutine.h StackMacros.h atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group rpmsg_lite
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_lite.h rpmsg_ns.h llist.h rpmsg_default_config.h virtio_ring.h virtqueue.h rpmsg_compiler.h rpmsg_env.h rpmsg_queue.h
    ../../../../../../middleware/multicore/rpmsg_lite/lib/common/: llist.c
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c
    ../../../../../../middleware/multicore/rpmsg_lite/lib/virtio/: virtqueue.c
  group rpmsg_lite/porting
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imx8qx_cm4/: rpmsg_platform.h
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/platform/imx8qx_cm4/: rpmsg_platform.c
  group rpmsg_lite/env/freertos
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_freertos.c
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_queue.c
  group component/i2c
    ../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group device
    ../../../../../../devices/MIMX8QX6/: fsl_device_registers.h MIMX8QX6_cm4.h MIMX8QX6_cm4_features.h system_MIMX8QX6_cm4.c system_MIMX8QX6_cm4.h
  group utilities
    ../../../../../../devices/MIMX8QX6/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMX8QX6/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMX8QX6/utilities/: fsl_assert.c
  group MIMX8QX6/iar
    ../../../../../../devices/MIMX8QX6/iar/: startup_MIMX8QX6_cm4.s
  group scfw_api/main
    ../../../../../../devices/MIMX8QX6/scfw_api/main/: imx8qx_pads.h ipc.h ipc_imx8qx.c rpc.h scfw.h types.h
  group scfw_api/svc/irq
    ../../../../../../devices/MIMX8QX6/scfw_api/svc/irq/: irq_api.h irq_rpc.h irq_rpc_clnt.c
  group scfw_api/svc/misc
    ../../../../../../devices/MIMX8QX6/scfw_api/svc/misc/: misc_api.h misc_rpc.h misc_rpc_clnt.c
  group scfw_api/svc/pad
    ../../../../../../devices/MIMX8QX6/scfw_api/svc/pad/: pad_api.h pad_rpc.h pad_rpc_clnt.c
  group scfw_api/svc/pm
    ../../../../../../devices/MIMX8QX6/scfw_api/svc/pm/: pm_api.h pm_rpc.h pm_rpc_clnt.c
  group scfw_api/svc/rm
    ../../../../../../devices/MIMX8QX6/scfw_api/svc/rm/: rm_api.h rm_rpc.h rm_rpc_clnt.c
  group scfw_api/svc/seco
    ../../../../../../devices/MIMX8QX6/scfw_api/svc/seco/: seco_api.h seco_rpc.h seco_rpc_clnt.c
  group scfw_api/svc/timer
    ../../../../../../devices/MIMX8QX6/scfw_api/svc/timer/: timer_api.h timer_rpc.h timer_rpc_clnt.c
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
