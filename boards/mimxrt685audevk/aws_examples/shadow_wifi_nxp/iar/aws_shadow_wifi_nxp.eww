<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>aws_shadow_wifi_nxp</project>
        <configuration>flash_debug</configuration>
      </member>
      <member>
        <project>aws_shadow_wifi_nxp</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_debug</name>
      <member>
        <project>aws_shadow_wifi_nxp</project>
        <configuration>flash_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_release</name>
      <member>
        <project>aws_shadow_wifi_nxp</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/aws_shadow_wifi_nxp.ewp</path>
  </project>
</workspace>
