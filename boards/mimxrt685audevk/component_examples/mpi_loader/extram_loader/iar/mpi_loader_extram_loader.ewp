# IAR project mpi_loader_extram_loader.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; FSL_SDK_DISABLE_DRIVER_CLOCK_CONTROL=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../components/mpi_loader; ../../../../../../devices/MIMXRT685S/utilities/str; ../../../../../../devices/MIMXRT685S/utilities/debug_console_lite; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: extram_loader.bin
  ILINK.IlinkOutputFile: mpi_loader_extram_loader.out
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; FSL_SDK_DISABLE_DRIVER_CLOCK_CONTROL=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: extram_loader.c
  group board
    ../: pin_mux.c pin_mux.h mpi_loader_ram.json board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group mpi_loader
    ../../../../../../components/mpi_loader/: fsl_mpi_loader.h fsl_mpi_loader.c
  group utilities
    ../../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT685S/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../devices/MIMXRT685S/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_power.h fsl_power.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c
  group device
    ../../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group MIMXRT685S
    ../../../../../../devices/MIMXRT685S/: system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group MIMXRT685S/iar
    ../../../../../../devices/MIMXRT685S/iar/: startup_MIMXRT685S_cm33.s
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
