# IAR project dmic_i2s_hwvad.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; SDK_DEBUGCONSOLE=1; SDK_I2C_BASED_COMPONENT_USED=1; CODEC_CS42448_ENABLE; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../devices/MIMXRT685S/drivers; ../../../../../components/codec/i2c; ../../../../../components/i2c; ../../../../../devices/MIMXRT685S/utilities/str; ../../../../../devices/MIMXRT685S/utilities/debug_console; ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../components/sx1502; ../../../../../components/codec/cs42448; ../../../../../components/codec; ../../../../../components/codec/port/cs42448; ../../../../../components/codec/port; ../../../../../rtos/freertos/freertos_kernel/include; ../../../../../devices/MIMXRT685S; ../../../../../components/uart; ../../../flash_config; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: dmic_i2s_hwvad.out
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; SDK_I2C_BASED_COMPONENT_USED=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; SDK_DEBUGCONSOLE=1; SDK_I2C_BASED_COMPONENT_USED=1; CODEC_CS42448_ENABLE; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; SDK_DEBUGCONSOLE=1; SDK_I2C_BASED_COMPONENT_USED=1; CODEC_CS42448_ENABLE; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; SDK_I2C_BASED_COMPONENT_USED=1; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; SDK_DEBUGCONSOLE=1; SDK_I2C_BASED_COMPONENT_USED=1; CODEC_CS42448_ENABLE; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
  group source
    ../: dmic_i2s_hwvad.c FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT685S/drivers/: fsl_i2c.h fsl_i2c.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_dmic.c fsl_dmic.h fsl_i2s.h fsl_i2s.c fsl_usart.h fsl_usart.c fsl_dmic_dma.c fsl_dmic_dma.h fsl_dma.c fsl_dma.h fsl_i2s_dma.h fsl_i2s_dma.c fsl_inputmux.h fsl_inputmux.c fsl_inputmux_connections.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c
  group codec
    ../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
    ../../../../../components/codec/cs42448/: fsl_cs42448.h fsl_cs42448.c
    ../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
  group codec/port
    ../../../../../components/codec/port/: fsl_codec_adapter.h
  group codec/port/cs42448
    ../../../../../components/codec/port/cs42448/: fsl_codec_cs42448_adapter.c fsl_codec_cs42448_adapter.h
  group component/i2c
    ../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_flexcomm_i2c.c
  group component/sx1502
    ../../../../../components/sx1502/: fsl_sx1502.h fsl_sx1502.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group utilities
    ../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT685S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT685S/utilities/: fsl_assert.c
  group freertos/freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.h portasm.s portmacro.h
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos_kernel/include
    ../../../../../rtos/freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group device
    ../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group MIMXRT685S
    ../../../../../devices/MIMXRT685S/: system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group MIMXRT685S/iar
    ../../../../../devices/MIMXRT685S/iar/: startup_MIMXRT685S_cm33.s
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
