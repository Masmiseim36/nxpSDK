# IAR project dsp_audio_demo_bm_cm33.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; DSP_IMAGE_COPY_TO_RAM=1; DSP_NCACHE; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT685SFVKB_cm33; MIMXRT685S_cm33_SERIES; BOOT_HEADER_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; CODEC_MULTI_ADAPTERS=1; CODEC_CS42448_ENABLE
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../flash_config; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT685S; ../../../../../../devices/MIMXRT685S/periph; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S/utilities/debug_console_lite; ../../../../../../devices/MIMXRT685S/utilities/str; ../../../../../../components/codec/i2c; ../../../../../../components/codec; ../../../../../../components/codec/port; ../../../../../../components/codec/port/cs42448; ../../../../../../components/codec/cs42448; ../../../../../../components/gpio; ../../../../../../components/i2c; ../../../../../../components/uart; ../../../../../../components/pmic/pca9420
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DSP_IMAGE_COPY_TO_RAM=1; DSP_NCACHE; MCUXPRESSO_SDK; CPU_MIMXRT685SFVKB_cm33; MIMXRT685S_cm33_SERIES
  AARM.AUserIncludes: ..; ../../hifi4/binary; ../../../../flash_config; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT685S; ../../../../../../devices/MIMXRT685S/periph; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S/utilities/debug_console_lite; ../../../../../../devices/MIMXRT685S/utilities/str; ../../../../../../components/codec/i2c; ../../../../../../components/codec; ../../../../../../components/codec/port; ../../../../../../components/codec/port/cs42448; ../../../../../../components/codec/cs42448; ../../../../../../components/gpio; ../../../../../../components/i2c; ../../../../../../components/uart; ../../../../../../components/pmic/pca9420
  OBJCOPY.OOCOutputFile: dsp_audio_demo_bm.bin
  ILINK.IlinkOutputFile: dsp_audio_demo_bm_cm33.out
  ILINK.IlinkKeepSymbols: __dsp_literal_bin; __dsp_text_bin; __dsp_data_bin; __dsp_ncache_bin
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_ram.icf
  ILINK.IlinkExtraOptions: --image_input=../../hifi4/binary/dsp_data_release.bin,__dsp_data_bin,__dsp_data_section,4; --image_input=../../hifi4/binary/dsp_ncache_release.bin,__dsp_ncache_bin,__dsp_ncache_section,4
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; DSP_IMAGE_COPY_TO_RAM=1; DSP_NCACHE; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT685SFVKB_cm33; MIMXRT685S_cm33_SERIES; BOOT_HEADER_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; CODEC_MULTI_ADAPTERS=1; CODEC_CS42448_ENABLE
  ICCARM.CCOptLevel: 3
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
  group source
    ../: main.c dsp_config.h dsp_support.c dsp_support.h pmic_support.c pmic_support.h mcux_config.h
  group dsp_binary
    ../../hifi4/binary/: dsp_literal_release.bin dsp_text_release.bin dsp_data_release.bin dsp_ncache_release.bin
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group device
    ../../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S_cm33.h MIMXRT685S_cm33_COMMON.h MIMXRT685S_cm33_features.h system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group device/periph
    ../../../../../../devices/MIMXRT685S/periph/: PERI_ADC.h PERI_AHB_SECURE_CTRL.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CASPER.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CMP.h PERI_CRC.h PERI_CTIMER.h PERI_DMA.h PERI_DMIC.h PERI_ESPI.h PERI_FLEXCOMM.h PERI_FLEXSPI.h PERI_FREQME.h PERI_GPIO.h PERI_HASHCRYPT.h PERI_I2C.h PERI_I2S.h PERI_I3C.h PERI_INPUTMUX.h PERI_IOPCTL.h PERI_MRT.h PERI_MU.h PERI_OCOTP.h PERI_OSTIMER.h PERI_OTFAD.h PERI_PINT.h PERI_PMC.h PERI_POWERQUAD.h PERI_PUF.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RTC.h PERI_SCT.h PERI_SEMA42.h PERI_SPI.h PERI_SYSCTL0.h PERI_SYSCTL1.h PERI_TRNG.h PERI_USART.h PERI_USBHSD.h PERI_USBHSDCD.h PERI_USBHSH.h PERI_USBPHY.h PERI_USDHC.h PERI_UTICK.h PERI_WWDT.h
  group startup/iar
    ../../../../../../devices/MIMXRT685S/iar/: startup_MIMXRT685S_cm33.s
  group drivers
    ../../../../../../devices/MIMXRT685S/drivers/: fsl_clock.c fsl_clock.h fsl_dsp.c fsl_dsp.h fsl_i2s_bridge.c fsl_i2s_bridge.h fsl_inputmux_connections.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_flexcomm.h fsl_flexcomm.c fsl_usart.h fsl_usart.c fsl_i2c.h fsl_i2c.c fsl_flexspi.c fsl_flexspi.h fsl_gpio.h fsl_gpio.c fsl_iopctl.h
  group utilities
    ../../../../../../devices/MIMXRT685S/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MIMXRT685S/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group codec
    ../../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
    ../../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../../components/codec/cs42448/: fsl_cs42448.h fsl_cs42448.c
  group codec/port
    ../../../../../../components/codec/port/: fsl_codec_adapter.c fsl_codec_adapter.h
  group codec/port/cs42448
    ../../../../../../components/codec/port/cs42448/: fsl_codec_cs42448_adapter.h fsl_codec_cs42448_adapter.c
  group component/gpio
    ../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_rt_gpio.c
  group component/i2c
    ../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_flexcomm_i2c.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/pmic/pca9420
    ../../../../../../components/pmic/pca9420/: fsl_pca9420.c fsl_pca9420.h
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
