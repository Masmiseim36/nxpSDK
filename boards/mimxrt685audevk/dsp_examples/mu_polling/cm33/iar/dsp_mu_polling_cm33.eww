<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>dsp_mu_polling_cm33</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>dsp_mu_polling_cm33</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>dsp_mu_polling_cm33</project>
        <configuration>flash_debug</configuration>
      </member>
      <member>
        <project>dsp_mu_polling_cm33</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>dsp_mu_polling_cm33</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>dsp_mu_polling_cm33</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_debug</name>
      <member>
        <project>dsp_mu_polling_cm33</project>
        <configuration>flash_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_release</name>
      <member>
        <project>dsp_mu_polling_cm33</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/dsp_mu_polling_cm33.ewp</path>
  </project>
</workspace>
