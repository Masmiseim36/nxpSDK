# Keil uVision project dsp_nn_demo_cm33.uvprojx, settings and files
target dsp_nn_demo_cm33 flash_debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: dsp_nn_demo_cm33.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, DSP_IMAGE_COPY_TO_RAM=1, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, PRINTF_ADVANCED_ENABLE=1, PRINTF_FLOAT_ENABLE=1, SCANF_ADVANCED_ENABLE=1, SCANF_FLOAT_ENABLE=1, SDK_I2C_BASED_COMPONENT_USED=1, SERIAL_PORT_TYPE_UART=1, SDK_OS_FREE_RTOS, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../dsp_examples/nn_demo/cm33;../../../../../../devices/MIMXRT685S/drivers;../../../../../../middleware/multicore/rpmsg_lite/lib/include;../../../../../../middleware/multicore/rpmsg_lite/lib/include/environment/freertos;../../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM33_NTZ/non_secure;../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imxrt600_m33;../../../../../../components/pca9420;../../../../../../devices/MIMXRT685S;../../../../../../devices/MIMXRT685S/utilities/str;../../../../../../devices/MIMXRT685S/utilities/debug_console;../../../../../../components/uart;../../../../flash_config;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../CMSIS/Core/Include;../../../../../../rtos/freertos/freertos_kernel/include
  asm define: DEBUG, DSP_IMAGE_COPY_TO_RAM=1, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, PRINTF_ADVANCED_ENABLE=1, PRINTF_FLOAT_ENABLE=1, SCANF_ADVANCED_ENABLE=1, SCANF_FLOAT_ENABLE=1
  asm include: ..;../../dsp/binary
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x10200000 size 0x280000
  memory RVCT7: RAM 0x20200000 size 0x280000
  memory RVCT8: RAM 0x30200000 size 0x280000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_flash.scf
  link misc: --remove --keep=*(CodeQuickAccess) --entry=Reset_Handler --predefine="-D__stack_size__=0x600" --predefine="-D__heap_size__=0x60000" --predefine="-D__use_shmem__=1"
  group source
    ../: main_cm33.c dsp_config.h srtm_config.h srtm_config_audio.h srtm_config_nn.h rpmsg_config.h incbin.S FreeRTOSConfig.h
  group board
    ../: counter.c counter.h pin_mux.c pin_mux.h dsp_support.c dsp_support.h dsp_ipc.c dsp_ipc.h dsp_nn_utils.c dsp_nn_utils.h pmic_support.c pmic_support.h board.c board.h clock_config.c clock_config.h
  group nn
    ../: dsp_nn.c dsp_nn.h config_nn.h
  group unit_tests
    ../: unit_tests_nn.h unit_tests_nn.c unit_tests_nn_conv_ds.c conv_ds_in.h conv_ds_out.h unit_tests_nn_conv_std.c conv_std_in.h conv_std_out.h unit_tests_nn_maxpool.c maxpool_in.h maxpool_out.h unit_tests_nn_relu.c unit_tests_nn_echo.c
  group doc
    ../: readme.txt
  group dsp_binary
    ../../dsp/binary/: dsp_text_release.bin dsp_data_release.bin
  group drivers
    ../../../../../../devices/MIMXRT685S/drivers/: fsl_clock.h fsl_clock.c fsl_i2c.h fsl_i2c.c fsl_i3c.h fsl_i3c.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_dsp.h fsl_dsp.c fsl_inputmux.h fsl_inputmux.c fsl_mu.h fsl_mu.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c fsl_inputmux_connections.h
  group rpmsg_lite/include
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_lite.h rpmsg_ns.h llist.h rpmsg_default_config.h virtio_ring.h virtqueue.h rpmsg_compiler.h rpmsg_env.h rpmsg_queue.h
  group rpmsg_lite/common
    ../../../../../../middleware/multicore/rpmsg_lite/lib/common/: llist.c
  group rpmsg_lite/rpmsg_lite
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c rpmsg_queue.c
  group rpmsg_lite/virtio
    ../../../../../../middleware/multicore/rpmsg_lite/lib/virtio/: virtqueue.c
  group rpmsg_lite/rpmsg_lite/porting/environment
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_freertos.c
  group rpmsg_lite/include/environment/freertos
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/environment/freertos/: rpmsg_env_specific.h
  group freertos/freertos_kernel/portable/GCC/ARM_CM33_NTZ/non_secure
    ../../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c portasm.h portmacro.h
  group rpmsg_lite/include/platform/imxrt600_m33
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imxrt600_m33/: rpmsg_platform.h
  group rpmsg_lite/rpmsg_lite/porting/platform/imxrt600_m33
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/platform/imxrt600_m33/: rpmsg_platform.c
  group pmic_driver
    ../../../../../../components/pca9420/: fsl_pca9420.h fsl_pca9420.c
  group device
    ../../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h
  group utilities
    ../../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT685S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT685S/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group MIMXRT685S
    ../../../../../../devices/MIMXRT685S/: system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group MIMXRT685S/arm
    ../../../../../../devices/MIMXRT685S/arm/: startup_MIMXRT685S_cm33.S
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group freertos/freertos_kernel
    ../../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    ../../../../../../rtos/freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos_kernel/portable
    ../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
target dsp_nn_demo_cm33 flash_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.14.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: dsp_nn_demo_cm33.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, DSP_IMAGE_COPY_TO_RAM=1, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, PRINTF_ADVANCED_ENABLE=1, PRINTF_FLOAT_ENABLE=1, SCANF_ADVANCED_ENABLE=1, SCANF_FLOAT_ENABLE=1, SDK_I2C_BASED_COMPONENT_USED=1, SERIAL_PORT_TYPE_UART=1, SDK_OS_FREE_RTOS, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, DSP_IMAGE_COPY_TO_RAM=1, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, PRINTF_ADVANCED_ENABLE=1, PRINTF_FLOAT_ENABLE=1, SCANF_ADVANCED_ENABLE=1, SCANF_FLOAT_ENABLE=1
  asm include: ..;../../dsp/binary
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_flash.scf
  link misc: as above
