# Keil uVision project mbedtls3x_benchmark.uvprojx, settings and files
target mbedtls3x_benchmark debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: mbedtls3x_benchmark.out
  AfterMake: fromelf.exe --output "$Lsdk20-app.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, MULADDC_CANNOT_USE_R7, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, PRINTF_FLOAT_ENABLE=1, MBEDTLS_CONFIG_FILE='\"mcux_mbedtls_config.h\"', MCUXPRESSO_SDK, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../../middleware/mbedtls3x/port/rng;../../../../../middleware/mbedtls3x/include;../../../../../middleware/mbedtls3x/library;../../../../../devices/MIMXRT685S/drivers;../../../../../devices/MIMXRT685S;../../../../../devices/MIMXRT685S/utilities/debug_console;../../../../../devices/MIMXRT685S/utilities;../../../../../components/uart;../../../flash_config;../../../../../components/serial_manager;../../../../../components/lists;../../../../../middleware/mbedtls3x/port;../../../../../CMSIS/Core/Include;../../../../../devices/MIMXRT685S/utilities/str
  asm define: DEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x10200000 size 0x280000
  memory RVCT7: RAM 0x20200000 size 0x280000
  memory RVCT8: RAM 0x30200000 size 0x280000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_ram.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314 --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x8000"
  group source
    ../: benchmark.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group mimxrt685audevk/mbedtls3x_examples/mbedtls3x_benchmark/.
    ../: hardware_init.c app.h
  group doc
    ../: readme.md
  group mbedtls3x/port/rng
    ../../../../../middleware/mbedtls3x/port/rng/: psa_mcux_entropy.c
  group drivers
    ../../../../../devices/MIMXRT685S/drivers/: fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c fsl_trng.c fsl_trng.h
  group device
    ../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h
  group utilities
    ../../../../../devices/MIMXRT685S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT685S/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group MIMXRT685S
    ../../../../../devices/MIMXRT685S/: system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group MIMXRT685S/arm
    ../../../../../devices/MIMXRT685S/arm/: startup_MIMXRT685S_cm33.S
  group mbedtls3x/port
    ../../../../../middleware/mbedtls3x/port/: mcux_mbedtls_config.h mcux_mbedtls_accelerator_config.h mcux_psa_defines.h mcux_mbedtls_config.h mcux_mbedtls_accelerator_config.h
  group mbedtls3x/library
    ../../../../../middleware/mbedtls3x/library/: psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers_no_static.c psa_crypto_ecp.c psa_crypto_ffdh.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_pake.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write.c x509write_crt.c x509write_csr.c x509_internal.h pkcs7.c aes.c aesni.c aesni.h alignment.h aesce.c aesce.h aria.c asn1parse.c asn1write.c base64.c base64_internal.h bignum.c bignum_core.h bignum_core.c bignum_mod.c bignum_mod.h bignum_mod_raw.c bignum_mod_raw.h bignum_mod_raw_invasive.h block_cipher.c block_cipher_internal.h bn_mul.h camellia.c ccm.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cipher_wrap.h cmac.c common.h constant_time.c constant_time_impl.h constant_time_internal.h ctr_drbg.c ctr.h des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_curves_new.c ecp_internal_alt.h ecp_invasive.h entropy.c entropy_poll.c entropy_poll.h error.c gcm.c hkdf.c hmac_drbg.c lmots.c lmots.h lms.c md.c md_psa.h md_wrap.h md5.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c padlock.h pem.c pk.c pk_ecc.c pk_internal.h pk_wrap.c pk_wrap.h pkcs5.c pkcs12.c pkparse.c pkwrite.c pkwrite.h platform.c platform_util.c poly1305.c psa_crypto_aead.h psa_crypto_cipher.h psa_crypto_core.h psa_crypto_core_common.h psa_crypto_driver_wrappers_no_static.h psa_crypto_driver_wrappers.h psa_crypto_ecp.h psa_crypto_ffdh.h psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.h psa_crypto_pake.h psa_crypto_random_impl.h psa_crypto_rsa.h psa_crypto_se.h psa_crypto_slot_management.h psa_crypto_storage.h psa_util_internal.h psa_util.c ripemd160.c rsa.c rsa_alt_helpers.c rsa_alt_helpers.h rsa_internal.h sha1.c sha3.c sha256.c sha512.c threading.c timing.c version.c version_features.c debug.c debug_internal.h mps_common.h mps_error.h mps_reader.c mps_reader.h mps_trace.c mps_trace.h net_sockets.c ssl_cache.c ssl_ciphersuites.c ssl_ciphersuites_internal.h ssl_client.c ssl_client.h ssl_cookie.c ssl_debug_helpers.h ssl_debug_helpers_generated.c ssl_misc.h ssl_msg.c ssl_ticket.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_invasive.h ssl_tls13_keys.c ssl_tls13_keys.h ssl_tls13_server.c
  group mbedtls3x/include/mbedtls
    ../../../../../middleware/mbedtls3x/include/mbedtls/: pkcs7.h x509.h x509_crl.h x509_crt.h x509_csr.h aes.h aria.h asn1.h asn1write.h base64.h bignum.h block_cipher.h build_info.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cipher.h cmac.h compat-2.x.h config_adjust_legacy_crypto.h config_adjust_legacy_from_psa.h config_adjust_psa_from_legacy.h config_adjust_psa_superset_legacy.h config_adjust_ssl.h config_adjust_x509.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h error.h gcm.h hkdf.h hmac_drbg.h lms.h mbedtls_config.h md.h md5.h memory_buffer_alloc.h nist_kw.h oid.h pem.h pk.h pkcs5.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h private_access.h psa_util.h ripemd160.h rsa.h sha1.h sha3.h sha256.h sha512.h threading.h timing.h version.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_ticket.h net_sockets.h
  group mbedtls3x/include/psa
    ../../../../../middleware/mbedtls3x/include/psa/: build_info.h crypto.h crypto_adjust_auto_enabled.h crypto_adjust_config_key_pair_types.h crypto_adjust_config_synonyms.h crypto_builtin_composites.h crypto_builtin_key_derivation.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_key_derivation.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_legacy.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target mbedtls3x_benchmark flash_debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: mbedtls3x_benchmark.out
  AfterMake: fromelf.exe --output "$Lsdk20-app.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, MULADDC_CANNOT_USE_R7, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, PRINTF_FLOAT_ENABLE=1, MBEDTLS_CONFIG_FILE='\"mcux_mbedtls_config.h\"', MCUXPRESSO_SDK, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: DEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x10200000 size 0x280000
  memory RVCT7: RAM 0x20200000 size 0x280000
  memory RVCT8: RAM 0x30200000 size 0x280000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_flash.scf
  link misc: --remove --keep=*(CodeQuickAccess) --entry=Reset_Handler --diag_suppress 6314 --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x8000"
target mbedtls3x_benchmark release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.14.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: mbedtls3x_benchmark.out
  AfterMake: fromelf.exe --output "$Lsdk20-app.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, MULADDC_CANNOT_USE_R7, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, PRINTF_FLOAT_ENABLE=1, MBEDTLS_CONFIG_FILE='\"mcux_mbedtls_config.h\"', MCUXPRESSO_SDK, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_ram.scf
  link misc: as above
target mbedtls3x_benchmark flash_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.14.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: mbedtls3x_benchmark.out
  AfterMake: fromelf.exe --output "$Lsdk20-app.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, MULADDC_CANNOT_USE_R7, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, PRINTF_FLOAT_ENABLE=1, MBEDTLS_CONFIG_FILE='\"mcux_mbedtls_config.h\"', MCUXPRESSO_SDK, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_flash.scf
  link misc: as above
