# Keil uVision project mbedtls3x_psatest.uvprojx, settings and files
target mbedtls3x_psatest debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: mbedtls3x_psatest.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, MULADDC_CANNOT_USE_R7, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, MBEDTLS_CONFIG_FILE='\"mcux_mbedtls_psatest_config.h\"', MCUXPRESSO_SDK, TF_M_PROFILE_MEDIUM, CRYPTO, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../middleware/mbedtls3x/port/rng;../../../../../middleware/mbedtls3x/include;../../../../../middleware/mbedtls3x/library;../../../../../middleware/tfm/psa-arch-tests/api-tests/val/nspe;../../../../../middleware/tfm/psa-arch-tests/api-tests/val/common;../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/drivers/nvmem;../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/tgt_dev_apis_nxp/nspe;../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/common/nspe/crypto;../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/common/nspe;../../../../../middleware/tfm/psa-arch-tests/api-tests/val;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/common;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c001;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c002;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c003;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c004;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c005;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c006;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c007;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c008;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c009;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c010;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c011;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c012;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c013;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c014;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c015;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c016;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c017;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c018;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c019;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c020;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c021;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c022;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c023;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c024;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c025;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c026;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c027;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c028;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c029;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c030;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c031;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c032;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c033;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c034;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c035;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c036;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c037;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c038;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c039;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c040;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c041;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c042;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c043;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c044;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c045;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c046;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c047;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c048;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c049;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c050;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c051;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c052;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c053;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c054;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c055;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c056;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c057;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c058;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c059;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c060;../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c061;../../../../../devices/MIMXRT685S/drivers;../../../../../devices/MIMXRT685S;../../../../../devices/MIMXRT685S/utilities/str;../../../../../devices/MIMXRT685S/utilities/debug_console;../../../../../components/uart;../../../flash_config;../../../../../components/serial_manager;../../../../../components/lists;../../../../../middleware/mbedtls3x/port;../../../../../CMSIS/Core/Include
  asm define: DEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x10200000 size 0x280000
  memory RVCT7: RAM 0x20200000 size 0x280000
  memory RVCT8: RAM 0x30200000 size 0x280000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_ram.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314 --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x8000"
  group source
    ../: main.c
  group board
    ../: pin_mux.c pin_mux.h mcux_mbedtls_psatest_config.h board.c board.h clock_config.c clock_config.h
  group mimxrt685audevk/mbedtls3x_examples/mbedtls3x_psatest/.
    ../: hardware_init.c app.h
  group doc
    ../: readme.txt
  group mbedtls3x/port/rng
    ../../../../../middleware/mbedtls3x/port/rng/: psa_mcux_entropy.c
  group mbedtls3x/include/mbedtls
    ../../../../../middleware/mbedtls3x/include/mbedtls/: aes.h aria.h asn1.h asn1write.h base64.h bignum.h build_info.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cipher.h cmac.h compat-2.x.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h error.h gcm.h hkdf.h hmac_drbg.h legacy_or_psa.h lms.h mbedtls_config.h md.h md5.h memory_buffer_alloc.h net_sockets.h nist_kw.h oid.h pem.h pk.h pkcs5.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h private_access.h psa_util.h ripemd160.h rsa.h sha1.h sha256.h sha512.h threading.h timing.h version.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_ticket.h pkcs7.h x509.h x509_crl.h x509_crt.h x509_csr.h
  group mbedtls3x/include/psa
    ../../../../../middleware/mbedtls3x/include/psa/: crypto.h crypto_builtin_composites.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group mbedtls3x/library
    ../../../../../middleware/mbedtls3x/library/: aes.c aesni.c aesni.h alignment.h aesce.c aesce.h aria.c asn1parse.c asn1write.c base64.c bignum.c bignum_core.h bignum_core.c bignum_mod.c bignum_mod.h bignum_mod_raw.c bignum_mod_raw.h bignum_mod_raw_invasive.h bn_mul.h camellia.c ccm.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cipher_wrap.h cmac.c common.h constant_time.c constant_time_internal.h constant_time_invasive.h ctr_drbg.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_internal_alt.h ecp_invasive.h entropy.c entropy_poll.c entropy_poll.h error.c gcm.c hash_info.c hash_info.h hkdf.c hmac_drbg.c lmots.c lmots.h lms.c md.c md_wrap.h md5.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c padlock.h pem.c pk.c pk_wrap.c pk_wrap.h pkcs5.c pkcs12.c pkparse.c pkwrite.c pkwrite.h platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_pake.h psa_crypto_pake.c psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c psa_util.c ripemd160.c rsa.c rsa_alt_helpers.c rsa_alt_helpers.h sha1.c sha256.c sha512.c threading.c timing.c version.c version_features.c debug.c mps_common.h mps_error.h mps_reader.c mps_reader.h mps_trace.c mps_trace.h net_sockets.c ssl_cache.c ssl_ciphersuites.c ssl_client.c ssl_client.h ssl_cookie.c ssl_debug_helpers.h ssl_debug_helpers_generated.c ssl_misc.h ssl_msg.c ssl_ticket.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_invasive.h ssl_tls13_keys.c ssl_tls13_keys.h ssl_tls13_server.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c pkcs7.c
  group api-tests/val
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/val/: test_entry_list.inc test_entry_fn_declare_list.inc
  group api-tests/val/nspe
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/val/nspe/: pal_interfaces_ns.h val_attestation.c val_attestation.h val_crypto.c val_crypto.h val_entry.c val_entry.h val_framework.c val_framework.h val_dispatcher.c val_dispatcher.h val_interfaces.c val_interfaces.h val_peripherals.c val_peripherals.h val_storage.c val_storage.h
  group api-tests/val/common
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/val/common/: val.h val_client_defs.h val_target.c val_target.h
  group api-tests/platform/drivers/nvmem
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/drivers/nvmem/: pal_nvmem.c pal_nvmem.h
  group api-tests/platform/targets/tgt_dev_apis_nxp/nspe
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/tgt_dev_apis_nxp/nspe/: pal_attestation_config.h pal_config.h pal_crypto_config.h pal_driver_intf.c pal_storage_config.h target_database.h target_database.c
  group api-tests/platform/targets/common/nspe/crypto
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/common/nspe/crypto/: pal_crypto_config_check.h pal_crypto_intf.c pal_crypto_intf.h
  group api-tests/platform/targets/common/nspe
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/common/nspe/: pal_common.h
  group api-tests/dev_apis/crypto/common
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/common/: test_crypto_common.c test_crypto_common.h
  group api-tests/dev_apis/crypto/test_c001
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c001/: test_c001.c test_c001.h test_entry_c001.c
  group api-tests/dev_apis/crypto/test_c002
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c002/: test_c002.c test_c002.h test_data.h test_entry_c002.c
  group api-tests/dev_apis/crypto/test_c003
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c003/: test_c003.c test_c003.h test_data.h test_entry_c003.c
  group api-tests/dev_apis/crypto/test_c004
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c004/: test_c004.c test_c004.h test_data.h test_entry_c004.c
  group api-tests/dev_apis/crypto/test_c005
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c005/: test_c005.c test_c005.h test_data.h test_entry_c005.c
  group api-tests/dev_apis/crypto/test_c006
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c006/: test_c006.c test_c006.h test_data.h test_entry_c006.c
  group api-tests/dev_apis/crypto/test_c007
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c007/: test_c007.c test_c007.h test_data.h test_entry_c007.c
  group api-tests/dev_apis/crypto/test_c008
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c008/: test_c008.c test_c008.h test_data.h test_entry_c008.c
  group api-tests/dev_apis/crypto/test_c009
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c009/: test_c009.c test_c009.h test_data.h test_entry_c009.c
  group api-tests/dev_apis/crypto/test_c010
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c010/: test_c010.c test_c010.h test_data.h test_entry_c010.c
  group api-tests/dev_apis/crypto/test_c011
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c011/: test_c011.c test_c011.h test_data.h test_entry_c011.c
  group api-tests/dev_apis/crypto/test_c012
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c012/: test_c012.c test_c012.h test_data.h test_entry_c012.c
  group api-tests/dev_apis/crypto/test_c013
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c013/: test_c013.c test_c013.h test_data.h test_entry_c013.c
  group api-tests/dev_apis/crypto/test_c014
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c014/: test_c014.c test_c014.h test_data.h test_entry_c014.c
  group api-tests/dev_apis/crypto/test_c015
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c015/: test_c015.c test_c015.h test_data.h test_entry_c015.c
  group api-tests/dev_apis/crypto/test_c016
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c016/: test_c016.c test_c016.h test_data.h test_entry_c016.c
  group api-tests/dev_apis/crypto/test_c017
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c017/: test_c017.c test_c017.h test_data.h test_entry_c017.c
  group api-tests/dev_apis/crypto/test_c018
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c018/: test_c018.c test_c018.h test_data.h test_entry_c018.c
  group api-tests/dev_apis/crypto/test_c019
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c019/: test_c019.c test_c019.h test_data.h test_entry_c019.c
  group api-tests/dev_apis/crypto/test_c020
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c020/: test_c020.c test_c020.h test_data.h test_entry_c020.c
  group api-tests/dev_apis/crypto/test_c021
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c021/: test_c021.c test_c021.h test_data.h test_entry_c021.c
  group api-tests/dev_apis/crypto/test_c022
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c022/: test_c022.c test_c022.h test_data.h test_entry_c022.c
  group api-tests/dev_apis/crypto/test_c023
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c023/: test_c023.c test_c023.h test_data.h test_entry_c023.c
  group api-tests/dev_apis/crypto/test_c024
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c024/: test_c024.c test_c024.h test_data.h test_entry_c024.c
  group api-tests/dev_apis/crypto/test_c025
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c025/: test_c025.c test_c025.h test_data.h test_entry_c025.c
  group api-tests/dev_apis/crypto/test_c026
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c026/: test_c026.c test_c026.h test_data.h test_entry_c026.c
  group api-tests/dev_apis/crypto/test_c027
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c027/: test_c027.c test_c027.h test_data.h test_entry_c027.c
  group api-tests/dev_apis/crypto/test_c028
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c028/: test_c028.c test_c028.h test_data.h test_entry_c028.c
  group api-tests/dev_apis/crypto/test_c029
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c029/: test_c029.c test_c029.h test_data.h test_entry_c029.c
  group api-tests/dev_apis/crypto/test_c030
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c030/: test_c030.c test_c030.h test_data.h test_entry_c030.c
  group api-tests/dev_apis/crypto/test_c031
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c031/: test_c031.c test_c031.h test_data.h test_entry_c031.c
  group api-tests/dev_apis/crypto/test_c032
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c032/: test_c032.c test_c032.h test_data.h test_entry_c032.c
  group api-tests/dev_apis/crypto/test_c033
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c033/: test_c033.c test_c033.h test_data.h test_entry_c033.c
  group api-tests/dev_apis/crypto/test_c034
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c034/: test_c034.c test_c034.h test_data.h test_entry_c034.c
  group api-tests/dev_apis/crypto/test_c035
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c035/: test_c035.c test_c035.h test_data.h test_entry_c035.c
  group api-tests/dev_apis/crypto/test_c036
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c036/: test_c036.c test_c036.h test_data.h test_entry_c036.c
  group api-tests/dev_apis/crypto/test_c037
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c037/: test_c037.c test_c037.h test_data.h test_entry_c037.c
  group api-tests/dev_apis/crypto/test_c038
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c038/: test_c038.c test_c038.h test_data.h test_entry_c038.c
  group api-tests/dev_apis/crypto/test_c039
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c039/: test_c039.c test_c039.h test_data.h test_entry_c039.c
  group api-tests/dev_apis/crypto/test_c040
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c040/: test_c040.c test_c040.h test_data.h test_entry_c040.c
  group api-tests/dev_apis/crypto/test_c041
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c041/: test_c041.c test_c041.h test_data.h test_entry_c041.c
  group api-tests/dev_apis/crypto/test_c042
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c042/: test_c042.c test_c042.h test_data.h test_entry_c042.c
  group api-tests/dev_apis/crypto/test_c043
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c043/: test_c043.c test_c043.h test_data.h test_entry_c043.c
  group api-tests/dev_apis/crypto/test_c044
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c044/: test_c044.c test_c044.h test_data.h test_entry_c044.c
  group api-tests/dev_apis/crypto/test_c045
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c045/: test_c045.c test_c045.h test_data.h test_entry_c045.c
  group api-tests/dev_apis/crypto/test_c046
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c046/: test_c046.c test_c046.h test_data.h test_entry_c046.c
  group api-tests/dev_apis/crypto/test_c047
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c047/: test_c047.c test_c047.h test_data.h test_entry_c047.c
  group api-tests/dev_apis/crypto/test_c048
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c048/: test_c048.c test_c048.h test_data.h test_entry_c048.c
  group api-tests/dev_apis/crypto/test_c049
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c049/: test_c049.c test_c049.h test_data.h test_entry_c049.c
  group api-tests/dev_apis/crypto/test_c050
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c050/: test_c050.c test_c050.h test_data.h test_entry_c050.c
  group api-tests/dev_apis/crypto/test_c051
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c051/: test_c051.c test_c051.h test_data.h test_entry_c051.c
  group api-tests/dev_apis/crypto/test_c052
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c052/: test_c052.c test_c052.h test_data.h test_entry_c052.c
  group api-tests/dev_apis/crypto/test_c053
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c053/: test_c053.c test_c053.h test_data.h test_entry_c053.c
  group api-tests/dev_apis/crypto/test_c054
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c054/: test_c054.c test_c054.h test_data.h test_entry_c054.c
  group api-tests/dev_apis/crypto/test_c055
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c055/: test_c055.c test_c055.h test_data.h test_entry_c055.c
  group api-tests/dev_apis/crypto/test_c056
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c056/: test_c056.c test_c056.h test_data.h test_entry_c056.c
  group api-tests/dev_apis/crypto/test_c057
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c057/: test_c057.c test_c057.h test_data.h test_entry_c057.c
  group api-tests/dev_apis/crypto/test_c058
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c058/: test_c058.c test_c058.h test_data.h test_entry_c058.c
  group api-tests/dev_apis/crypto/test_c059
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c059/: test_c059.c test_c059.h test_data.h test_entry_c059.c
  group api-tests/dev_apis/crypto/test_c060
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c060/: test_c060.c test_c060.h test_data.h test_entry_c060.c
  group api-tests/dev_apis/crypto/test_c061
    ../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c061/: test_c061.c test_c061.h test_data.h test_entry_c061.c
  group drivers
    ../../../../../devices/MIMXRT685S/drivers/: fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c fsl_trng.c fsl_trng.h
  group device
    ../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h
  group utilities
    ../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT685S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT685S/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group MIMXRT685S
    ../../../../../devices/MIMXRT685S/: system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group MIMXRT685S/arm
    ../../../../../devices/MIMXRT685S/arm/: startup_MIMXRT685S_cm33.S
  group mbedtls3x/port
    ../../../../../middleware/mbedtls3x/port/: mcux_mbedtls_config.h mcux_mbedtls_accelerator_config.h mcux_mbedtls_config.h mcux_mbedtls_accelerator_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target mbedtls3x_psatest flash_debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: mbedtls3x_psatest.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, MULADDC_CANNOT_USE_R7, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, MBEDTLS_CONFIG_FILE='\"mcux_mbedtls_psatest_config.h\"', MCUXPRESSO_SDK, TF_M_PROFILE_MEDIUM, CRYPTO, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: DEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x10200000 size 0x280000
  memory RVCT7: RAM 0x20200000 size 0x280000
  memory RVCT8: RAM 0x30200000 size 0x280000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_flash.scf
  link misc: --remove --keep=*(CodeQuickAccess) --entry=Reset_Handler --diag_suppress 6314 --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x8000"
target mbedtls3x_psatest release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.14.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: mbedtls3x_psatest.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, MULADDC_CANNOT_USE_R7, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, MBEDTLS_CONFIG_FILE='\"mcux_mbedtls_psatest_config.h\"', MCUXPRESSO_SDK, TF_M_PROFILE_MEDIUM, CRYPTO, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_ram.scf
  link misc: as above
target mbedtls3x_psatest flash_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.14.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: mbedtls3x_psatest.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, MULADDC_CANNOT_USE_R7, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, MBEDTLS_CONFIG_FILE='\"mcux_mbedtls_psatest_config.h\"', MCUXPRESSO_SDK, TF_M_PROFILE_MEDIUM, CRYPTO, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_flash.scf
  link misc: as above
