# IAR project ota_mcuboot_basic.ewp, settings and files
configuration flash_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; XIP_IMAGE; XIP_EXTERNAL_FLASH; PRINTF_ADVANCED_ENABLE=1; SHELL_PRINT_COPYRIGHT=0; MCUXPRESSO_SDK; MFLASH_FILE_BASEADDR=7340032; DEBUG_CONSOLE_RX_ENABLE=0; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pe257,Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../bootutil_port; ../bootutil_port/mcuboot_config; ../bootutil_port/sysflash; ../bootutil_port/board_specific; ../../../../../components/flash/mflash/mimxrt685audevk; ../../../../../middleware/mcuboot_opensource/ext/tinycrypt/lib/include; ../../../../../devices/MIMXRT685S/utilities/shell; ../../../../../devices/MIMXRT685S/drivers; ../../../../../devices/MIMXRT685S; ../../../../../devices/MIMXRT685S/utilities/debug_console; ../../../../../devices/MIMXRT685S/utilities; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../components/flash/mflash; ../../../../../devices/MIMXRT685S/utilities/str; ../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: ota_mcuboot_basic.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash_mcuboot.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; XIP_IMAGE; XIP_EXTERNAL_FLASH; PRINTF_ADVANCED_ENABLE=1; SHELL_PRINT_COPYRIGHT=0; MCUXPRESSO_SDK; MFLASH_FILE_BASEADDR=7340032; DEBUG_CONSOLE_RX_ENABLE=0; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  group tinycrypt/include/tinycrypt
    ../tinycrypt/: ecc_platform_specific.h
    ../../../../../middleware/mcuboot_opensource/ext/tinycrypt/lib/include/tinycrypt/: aes.h cbc_mode.h ccm_mode.h cmac_mode.h constants.h ctr_mode.h ctr_prng.h ecc.h ecc_dsa.h hmac.h hmac_prng.h sha256.h utils.h
  group tinycrypt/source
    ../../../../../middleware/mcuboot_opensource/ext/tinycrypt/lib/source/: aes_decrypt.c aes_encrypt.c cbc_mode.c ccm_mode.c cmac_mode.c ctr_mode.c ctr_prng.c ecc.c ecc_dsa.c hmac.c hmac_prng.c sha256.c utils.c
  group source
    ../: ota_mcuboot_basic.c xmodem.c xmodem.h mcuboot_app_support.c mcuboot_app_support.h
  group board
    ../: pin_mux.c pin_mux.h platform_bindings.c platform_bindings.h board.c board.h clock_config.c clock_config.h
  group bootutil_port
    ../bootutil_port/: flash_map.h
  group bootutil_port/board_specific
    ../bootutil_port/board_specific/: flash_partitioning.h flash_partitioning.c sblconfig.h
  group bootutil_port/mcuboot_config
    ../bootutil_port/mcuboot_config/: mcuboot_config.h mcuboot_logging.h
  group bootutil_port/sysflash
    ../bootutil_port/sysflash/: sysflash.h
  group doc
    ../: readme.md
  group flash/mflash
    ../../../../../components/flash/mflash/: mflash_common.h
  group flash/mflash/mimxrt685audevk
    ../../../../../components/flash/mflash/mimxrt685audevk/: mflash_drv.h mflash_drv.c
  group utilities
    ../../../../../devices/MIMXRT685S/utilities/shell/: fsl_shell.c fsl_shell.h
    ../../../../../devices/MIMXRT685S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT685S/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
  group drivers
    ../../../../../devices/MIMXRT685S/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_power.h fsl_power.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c
  group device
    ../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group MIMXRT685S
    ../../../../../devices/MIMXRT685S/: system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group MIMXRT685S/iar
    ../../../../../devices/MIMXRT685S/iar/: startup_MIMXRT685S_cm33.s
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
