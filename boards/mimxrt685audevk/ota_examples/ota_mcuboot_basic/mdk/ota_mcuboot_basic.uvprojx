# Keil uVision project ota_mcuboot_basic.uvprojx, settings and files
target ota_mcuboot_basic flash_debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: ota_mcuboot_basic.out
  AfterMake: fromelf.exe --output "$Lota_mcuboot_basic.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, XIP_IMAGE, XIP_EXTERNAL_FLASH, PRINTF_ADVANCED_ENABLE=1, SHELL_PRINT_COPYRIGHT=0, MCUXPRESSO_SDK, MFLASH_FILE_BASEADDR=7340032, DEBUG_CONSOLE_RX_ENABLE=0, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../bootutil_port;../bootutil_port/mcuboot_config;../bootutil_port/sysflash;../bootutil_port/board_specific;../../../../../components/flash/mflash/mimxrt685audevk;../../../../../middleware/mcuboot_opensource/ext/tinycrypt/lib/include;../../../../../devices/MIMXRT685S/utilities/shell;../../../../../devices/MIMXRT685S/drivers;../../../../../devices/MIMXRT685S;../../../../../devices/MIMXRT685S/utilities/debug_console;../../../../../devices/MIMXRT685S/utilities;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../components/flash/mflash;../../../../../devices/MIMXRT685S/utilities/str;../../../../../CMSIS/Core/Include
  asm define: DEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x10200000 size 0x280000
  memory RVCT7: RAM 0x20200000 size 0x280000
  memory RVCT8: RAM 0x30200000 size 0x280000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_flash_mcuboot.scf
  link misc: --remove --keep=*(CodeQuickAccess) --entry=Reset_Handler --diag_suppress 6314 --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x2000"
  group tinycrypt/include/tinycrypt
    ../tinycrypt/: ecc_platform_specific.h
    ../../../../../middleware/mcuboot_opensource/ext/tinycrypt/lib/include/tinycrypt/: aes.h cbc_mode.h ccm_mode.h cmac_mode.h constants.h ctr_mode.h ctr_prng.h ecc.h ecc_dsa.h hmac.h hmac_prng.h sha256.h utils.h
  group source
    ../: ota_mcuboot_basic.c xmodem.c xmodem.h mcuboot_app_support.c mcuboot_app_support.h
  group board
    ../: pin_mux.c pin_mux.h platform_bindings.c platform_bindings.h board.c board.h clock_config.c clock_config.h
  group bootutil_port/board_specific
    ../bootutil_port/board_specific/: flash_partitioning.h flash_partitioning.c sblconfig.h
  group bootutil_port/mcuboot_config
    ../bootutil_port/mcuboot_config/: mcuboot_config.h mcuboot_logging.h
  group bootutil_port
    ../bootutil_port/: flash_map.h
  group bootutil_port/sysflash
    ../bootutil_port/sysflash/: sysflash.h
  group doc
    ../: readme.md
  group flash/mflash/mimxrt685audevk
    ../../../../../components/flash/mflash/mimxrt685audevk/: mflash_drv.h mflash_drv.c
  group tinycrypt/source
    ../../../../../middleware/mcuboot_opensource/ext/tinycrypt/lib/source/: aes_decrypt.c aes_encrypt.c cbc_mode.c ccm_mode.c cmac_mode.c ctr_mode.c ctr_prng.c ecc.c ecc_dsa.c hmac.c hmac_prng.c sha256.c utils.c
  group utilities
    ../../../../../devices/MIMXRT685S/utilities/shell/: fsl_shell.c fsl_shell.h
    ../../../../../devices/MIMXRT685S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT685S/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
  group drivers
    ../../../../../devices/MIMXRT685S/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_power.h fsl_power.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c
  group device
    ../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group MIMXRT685S
    ../../../../../devices/MIMXRT685S/: system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group MIMXRT685S/arm
    ../../../../../devices/MIMXRT685S/arm/: startup_MIMXRT685S_cm33.S
  group flash/mflash
    ../../../../../components/flash/mflash/: mflash_common.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target ota_mcuboot_basic flash_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.14.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: ota_mcuboot_basic.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, XIP_IMAGE, XIP_EXTERNAL_FLASH, PRINTF_ADVANCED_ENABLE=1, SHELL_PRINT_COPYRIGHT=0, MCUXPRESSO_SDK, MFLASH_FILE_BASEADDR=7340032, DEBUG_CONSOLE_RX_ENABLE=0, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: MIMXRT685Sxxxx_cm33_flash_mcuboot.scf
  link misc: as above
