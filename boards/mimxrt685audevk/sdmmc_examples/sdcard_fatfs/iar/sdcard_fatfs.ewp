# IAR project sdcard_fatfs.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; SD_ENABLED; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../middleware/fatfs/source; ../../../../../middleware/fatfs/source/fsl_sd_disk; ../../../../../devices/MIMXRT685S/drivers; ../../../../../components/pca9420; ../../../../../middleware/sdmmc/sd; ../../../../../middleware/sdmmc/common; ../../../../../middleware/sdmmc/host/usdhc; ../../../../../devices/MIMXRT685S/utilities/debug_console_lite; ../../../../../components/gpio; ../../../../../devices/MIMXRT685S; ../../../../../components/uart; ../../../flash_config; ../../../../../components/lists; ../../../../../CMSIS/Core/Include; ../../../../../middleware/sdmmc/osa; ../../../../../components/osa
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: sdcard_fatfs.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x1000
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; SDK_I2C_BASED_COMPONENT_USED=1; SD_ENABLED; MCUXPRESSO_SDK
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; SD_ENABLED; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; SDK_I2C_BASED_COMPONENT_USED=1; SD_ENABLED; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
  group source
    ../: sdcard_fatfs.c ffconf.h
  group board
    ../: pin_mux.c pin_mux.h sdmmc_config.c sdmmc_config.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group fatfs/source
    ../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_sd_disk
    ../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group drivers
    ../../../../../devices/MIMXRT685S/drivers/: fsl_gpio.h fsl_gpio.c fsl_i2c.h fsl_i2c.c fsl_usdhc.c fsl_usdhc.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_power.h fsl_power.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_reset.h fsl_reset.c
  group pmic_driver
    ../../../../../components/pca9420/: fsl_pca9420.h fsl_pca9420.c
  group sdmmc/src
    ../../../../../middleware/sdmmc/sd/: fsl_sd.c
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc/sd/: fsl_sd.h
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sd
    ../../../../../middleware/sdmmc/sd/: ChangeLogKSDK.txt
  group sdmmc/host
    ../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt
    ../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group sdmmc/osa
    ../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group utilities
    ../../../../../devices/MIMXRT685S/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group component/gpio
    ../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_rt_gpio.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.c
  group device
    ../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group MIMXRT685S
    ../../../../../devices/MIMXRT685S/: system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group MIMXRT685S/iar
    ../../../../../devices/MIMXRT685S/iar/: startup_MIMXRT685S_cm33.s
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
