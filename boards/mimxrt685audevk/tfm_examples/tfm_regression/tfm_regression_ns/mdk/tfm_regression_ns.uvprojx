# Keil uVision project tfm_regression_ns.uvprojx, settings and files
target tfm_regression_ns debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tfm_regression_ns.out
  BeforeMake: $KARM/ARMCLANG/bin/armclang --target=arm-arm-none-eabi -march=armv8-m.main -E -P -xc -I "$P/../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/mimxrt685audevk/partition" -I "$P/../../../../../../middleware/tfm/tf-m/platform/ext/common" "$P/../../../../../../middleware/tfm/tf-m/platform/ext/common/armclang/tfm_common_ns.sct" -o "$P/../../../../../../middleware/tfm/tf-m/platform/ext/common/armclang/tfm_common_ns_pre.sct"
  AfterMake: fromelf.exe --output "$Lsdk20-app.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, OS_DYNAMIC_MEM_SIZE=7168, MCUXPRESSO_SDK, TFM_LVL=2, PROJECT_CONFIG_HEADER_FILE='\"config_profile_large.h\"', CONFIG_TFM_FLOAT_ABI=2, CONFIG_TFM_ENABLE_CP10CP11, CONFIG_TFM_LAZY_STACKING, __DOMAIN_NS=1, DOMAIN_NS=1, CONFIG_TFM_USE_TRUSTZONE, ATTEST_TOKEN_PROFILE_PSA_IOT_1, PLATFORM_DEFAULT_CRYPTO_KEYS, PS_ENCRYPTION, TFM_CRYPTO_TEST_ALG_CBC, TFM_CRYPTO_TEST_ALG_CCM, TFM_CRYPTO_TEST_ALG_GCM, TFM_CRYPTO_TEST_ALG_SHA_512, TFM_CRYPTO_TEST_HKDF, TFM_CRYPTO_TEST_ECDH, TFM_CRYPTO_TEST_UNSUPPORTED_ALG, TFM_NS_REG_TEST, TFM_S_REG_TEST, TEST_NS_PS, TEST_NS_PLATFORM, TFM_PARTITION_IPC_TEST, TEST_NS_IPC, TEST_NS_SLIH_IRQ, SERIAL_PORT_TYPE_UART=1, TARGET_CONFIG_HEADER_FILE='\"config_tfm_target.h\"', TEST_NS_ITS, TEST_NS_CRYPTO, TFM_PARTITION_INTERNAL_TRUSTED_STORAGE, T_COSE_USE_PSA_CRYPTO, QCBOR_DISABLE_FLOAT_HW_USE, USEFULBUF_DISABLE_ALL_FLOAT, QCBOR_DISABLE_PREFERRED_FLOAT, TEST_NS_ATTESTATION
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ../../../../../../devices/MIMXRT685S;..;../../../../../../devices/MIMXRT685S/drivers;../../../../../../middleware/tfm/tf-m/config/profile;../../../../../../middleware/tfm/tf-m/platform/include;../../../../../../middleware/tfm/tf-m/platform/ext;../../../../../../middleware/tfm/tf-m/platform/ext/common;../../../../../../middleware/tfm/tf-m/platform/ext/driver;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Config;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Include;../../../../../../middleware/tfm/tf-m/interface/include;../../../../../../middleware/tfm/tf-m/interface/include/crypto_keys;../../../../../../middleware/tfm/tf-m/interface/include/psa;../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest;../../../../../../middleware/tfm/tf-m/interface/include/os_wrapper;../../../../../../middleware/tfm/tf-m/bl2/include;../../../../../../middleware/tfm/tf-m/secure_fw/spm/include;../../../../../../middleware/tfm/tf-m/secure_fw/include;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage;../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform;../../../../../../middleware/tfm/tf-m/config;../../../../../../middleware/tfm/tf-m-tests/test/framework;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/ipc/non_secure;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/t_cose/non_secure;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/multi_core/non_secure;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/ps/non_secure;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/qcbor/non_secure;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/platform/non_secure;../../../../../../middleware/tfm/tf-m-tests;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/common_test_services/tfm_secure_client_service;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/platform;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/common/suites;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/common/service;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/irq;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/common;../../../../../../devices/MIMXRT685S/utilities/debug_console;../../../../../../devices/MIMXRT685S/utilities;../../../../../../components/uart;../../../../flash_config;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../middleware/tfm/tf-m-tests/app;../../../../../../middleware/tfm/tf-m-tests/log;../../../../../../middleware/tfm/tf-m-tests/ns_interface;../../../../../../middleware/tfm/tf-m-tests/ns_interface/ns_client_ext;../../../../../../CMSIS/RTOS2/RTX/Source;../../../../../../CMSIS/RTOS2/RTX/Include;../../../../../../CMSIS/RTOS2/RTX/Config;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/mimxrt685audevk;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/mimxrt685audevk/partition;../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/mimxrt685audevk/Device/Include;../../../../../../CMSIS/RTOS2/Include;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/its;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/its/non_secure;../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/inc;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/crypto;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/crypto/non_secure;../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/boot;../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/src;../../../../../../middleware/tfm/tf-m;../../../../../../middleware/tfm/qcbor/src;../../../../../../middleware/tfm/qcbor/inc;../../../../../../middleware/tfm/qcbor/inc/qcbor;../../../../../../middleware/tfm/qcbor/test;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/attestation/ext/qcbor_util;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/attestation/non_secure;../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/attestation;../../../../../../CMSIS/Core/Include;../../../../../../devices/MIMXRT685S/utilities/str
  asm define: DEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x10200000 size 0x280000
  memory RVCT7: RAM 0x20200000 size 0x280000
  memory RVCT8: RAM 0x30200000 size 0x280000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: ../../../../../../middleware/tfm/tf-m/platform/ext/common/armclang/tfm_common_ns_pre.sct
  link misc: ../../../../../../CMSIS/RTOS2/RTX/Library/ARM/RTX_V8MMFN.lib ../../tfm_regression_s/mdk/debug/tfm_regression_s_CMSE_lib.o --remove --entry=Reset_Handler --diag_suppress 6314
  group startup
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/mimxrt685audevk/Device/Source/: startup_mimxrt685audevk.c
  group device
    ../../../../../../devices/MIMXRT685S/: system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h fsl_device_registers.h MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h
  group board
    ../: pin_mux.c pin_mux.h hardware_init.c app.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.md
  group drivers
    ../../../../../../devices/MIMXRT685S/drivers/: fsl_ctimer.h fsl_ctimer.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c
  group tf-m/platform/ext/target/nxp/common/CMSIS_Driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/CMSIS_Driver/: Driver_USART.c
  group tf-m/config/profile
    ../../../../../../middleware/tfm/tf-m/config/profile/: config_profile_large.h
  group tf-m/platform/include
    ../../../../../../middleware/tfm/tf-m/platform/include/: tfm_plat_crypto_keys.h tfm_hal_device_header.h tfm_plat_boot_seed.h tfm_plat_device_id.h tfm_plat_defs.h tfm_plat_ns.h region.h tfm_plat_test.h
  group tf-m/platform/ext/common
    ../../../../../../middleware/tfm/tf-m/platform/ext/common/: uart_stdout.h uart_stdout.c
  group tf-m/platform/ext/driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/driver/: Driver_USART.h Driver_Common.h
  group tf-m/platform/ext/target/nxp/common
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/: libc_dummy.c target_cfg_common.h plat_test.c
  group tf-m/platform/ext/target/nxp/common/Device/Include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Include/: cmsis.h device_definition.h platform_irq.h platform_regs.h
  group tf-m/platform/ext/target/nxp/common/Device/Config
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Config/: device_cfg.h
  group tf-m/interface/include/crypto_keys
    ../../../../../../middleware/tfm/tf-m/interface/include/crypto_keys/: tfm_builtin_key_ids.h
  group tf-m/interface/include/psa_manifest
    ../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest/: sid.h
  group tf-m/interface/include
    ../../../../../../middleware/tfm/tf-m/interface/include/: tfm_attest_defs.h config_impl.h tfm_crypto_defs.h tfm_its_defs.h tfm_ps_defs.h tfm_api.h tfm_ns_interface.h tfm_psa_call_pack.h tfm_ns_client_ext.h tfm_platform_api.h tfm_attest_iat_defs.h
  group tf-m/interface/include/os_wrapper
    ../../../../../../middleware/tfm/tf-m/interface/include/os_wrapper/: common.h mutex.h
  group tf-m/interface/include/psa
    ../../../../../../middleware/tfm/tf-m/interface/include/psa/: client.h crypto_client_struct.h error.h framework_feature.h initial_attestation.h internal_trusted_storage.h lifecycle.h protected_storage.h service.h storage_common.h
  group tf-m/interface/include/psa/tfm
    ../../../../../../middleware/tfm/tf-m/interface/include/psa/tfm/: crypto.h crypto_compat.h crypto_extra.h crypto_platform.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group tf-m/secure_fw/spm/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/: tfm_arch.h tfm_arch_v8m.h utilities.h
  group tf-m/secure_fw/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/include/: config_tfm.h
  group tf-m/config
    ../../../../../../middleware/tfm/tf-m/config/: config_base.h
  group tf-m/secure_fw/partitions/crypto
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/: config_crypto_check.h
  group tf-m/secure_fw/partitions/protected_storage
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/: config_ps_check.h
  group tf-m/interface/src/os_wrapper
    ../../../../../../middleware/tfm/tf-m/interface/src/os_wrapper/: tfm_ns_interface_rtos.c
  group tf-m/interface/src
    ../../../../../../middleware/tfm/tf-m/interface/src/: tfm_crypto_api.c tfm_attest_api.c tfm_its_api.c tfm_ps_api.c tfm_platform_api.c tfm_psa_ns_api.c
  group tf-m-tests/test/secure_fw
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/: non_secure_suites.c
  group tf-m-tests/test/framework
    ../../../../../../middleware/tfm/tf-m-tests/test/framework/: test_framework.c test_framework.h test_framework_error_codes.h test_framework_integ_test.h test_framework_integ_test_helper.c test_framework_integ_test_helper.h test_framework_helpers.c test_framework_helpers.h test_log.h
  group tf-m-tests/test/secure_fw/suites/spm/ipc/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/ipc/non_secure/: ipc_ns_tests.h ipc_ns_interface_testsuite.c ipc_ns_tests.h
  group tf-m-tests/test/secure_fw/suites/t_cose/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/t_cose/non_secure/: t_cose_ns_tests.h
  group tf-m-tests/test/secure_fw/suites/multi_core/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/multi_core/non_secure/: multi_core_ns_test.h
  group tf-m-tests/test/secure_fw/suites/ps/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/ps/non_secure/: ps_ns_tests.h ns_test_helpers.c ns_test_helpers.h psa_ps_ns_interface_testsuite.c ps_ns_tests.h
  group tf-m-tests/test/secure_fw/suites/qcbor/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/qcbor/non_secure/: qcbor_ns_tests.h
  group tf-m-tests/test/secure_fw/suites/platform/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/platform/non_secure/: platform_ns_tests.h platform_ns_tests.h platform_ns_interface_testsuite.c
  group tf-m-tests/test/secure_fw/suites/platform
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/platform/: platform_tests_common.c platform_tests_common.h
  group tf-m-tests/test/secure_fw/suites/spm/common/service
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/common/service/: client_api_test_defs.h client_api_test_defs.h
  group tf-m-tests/test/secure_fw/suites/spm/common/suites
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/common/suites/: client_api_tests.c client_api_tests.h irq_test.c irq_test.h
  group tf-m-tests/test/secure_fw/suites/spm/common
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/common/: spm_test_defs.h
  group tf-m-tests/test/secure_fw/suites/spm/irq
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/spm/irq/: irq_testsuite.c irq_testsuite.h
  group utilities
    ../../../../../../devices/MIMXRT685S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT685S/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group tf-m-tests/app
    ../../../../../../middleware/tfm/tf-m-tests/app/: os_wrapper_cmsis_rtos_v2.c main_ns.c test_app.c test_app.h tfm_log.h
  group tf-m-tests/log
    ../../../../../../middleware/tfm/tf-m-tests/log/: tfm_log_raw.c tfm_log_raw.h
  group tf-m-tests/ns_interface/os_wrapper
    ../../../../../../middleware/tfm/tf-m-tests/ns_interface/os_wrapper/: delay.h msg_queue.h semaphore.h thread.h
  group tf-m-tests/ns_interface/ns_client_ext
    ../../../../../../middleware/tfm/tf-m-tests/ns_interface/ns_client_ext/: tfm_nsid_manager.h tz_shim_layer.c
  group CMSIS/RTOS2/RTX/Source
    ../../../../../../CMSIS/RTOS2/RTX/Source/: rtx_core_c.h rtx_core_ca.h rtx_core_cm.h rtx_lib.h rtx_lib.c
  group CMSIS/RTOS2/RTX/Include
    ../../../../../../CMSIS/RTOS2/RTX/Include/: rtx_evr.h rtx_os.h rtx_def.h
  group CMSIS/RTOS2/RTX/Config
    ../../../../../../CMSIS/RTOS2/RTX/Config/: RTX_Config.c RTX_Config.h
  group tf-m/platform/ext/target/nxp/mimxrt685audevk
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/mimxrt685audevk/: config_tfm_target.h target_cfg.h tfm_peripherals_def.h
  group tf-m/platform/ext/target/nxp/mimxrt685audevk/Device/Include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/mimxrt685audevk/Device/Include/: platform_base_address.h
  group tf-m/platform/ext/target/nxp/mimxrt685audevk/partition
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/mimxrt685audevk/partition/: region_defs.h flash_layout.h
  group CMSIS/RTOS2/Include
    ../../../../../../CMSIS/RTOS2/Include/: os_tick.h cmsis_os2.h
  group tf-m-tests/test/secure_fw/suites/its
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/its/: its_tests_common.c its_tests_common.h
  group tf-m-tests/test/secure_fw/suites/its/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/its/non_secure/: psa_its_ns_interface_testsuite.c its_ns_tests.h
  group tf-m/platform/ext/common/template
    ../../../../../../middleware/tfm/tf-m/platform/ext/common/template/: tfm_initial_attest_pub_key.c
  group tf-m/lib/ext/t_cose/src
    ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/src/: t_cose_sign1_sign.c t_cose_crypto.h t_cose_parameters.c t_cose_parameters.h t_cose_sign1_sign.c t_cose_standard_constants.h t_cose_util.c t_cose_util.h t_cose_sign1_verify.c
  group tf-m/lib/ext/t_cose/inc
    ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/inc/: t_cose_sign1_sign.h t_cose_common.h q_useful_buf.h t_cose_sign1_sign.h t_cose_sign1_verify.h
  group tf-m-tests/test/secure_fw/suites/crypto
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/crypto/: crypto_tests_common.c crypto_tests_common.h crypto_tests_check_config.h
  group tf-m-tests/test/secure_fw/suites/crypto/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/crypto/non_secure/: crypto_ns_interface_testsuite.c crypto_ns_tests.h
  group tf-m/secure_fw/partitions/initial_attestation
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation/: attest.h attest_token.h attest_key.h
  group tf-m/secure_fw/spm/include/boot
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/boot/: tfm_boot_status.h
  group tf-m/lib/ext/t_cose/crypto_adapters
    ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/crypto_adapters/: t_cose_psa_crypto.c
  group tf-m-tests/test/secure_fw/suites/attestation/non_secure
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/attestation/non_secure/: attest_asymmetric_ns_interface_testsuite.c attest_ns_tests.h
  group tf-m-tests/test/secure_fw/suites/attestation
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/attestation/: attest_token_decode_asymmetric.c attest_token_decode.h attest_token_decode_common.c attest_token_test.c attest_token_test.h attest_token_test_values.h attest_tests_common.h
  group qcbor/src
    ../../../../../../middleware/tfm/qcbor/src/: ieee754.c ieee754.h qcbor_decode.c qcbor_encode.c UsefulBuf.c
  group qcbor/inc/qcbor
    ../../../../../../middleware/tfm/qcbor/inc/qcbor/: qcbor.h qcbor_common.h qcbor_decode.h qcbor_encode.h qcbor_private.h qcbor_spiffy_decode.h UsefulBuf.h
  group qcbor/test
    ../../../../../../middleware/tfm/qcbor/test/: float_tests.h qcbor_encode_tests.c qcbor_encode_tests.h not_well_formed_cbor.h qcbor_decode_tests.c qcbor_decode_tests.h run_tests.c run_tests.h UsefulBuf_Tests.c UsefulBuf_Tests.h
  group tf-m-tests/test/secure_fw/suites/attestation/ext/qcbor_util
    ../../../../../../middleware/tfm/tf-m-tests/test/secure_fw/suites/attestation/ext/qcbor_util/: qcbor_util.c qcbor_util.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h
target tfm_regression_ns release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT685SFVKB:cm33 NXP
  pack: NXP.MIMXRT685S_DFP.14.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tfm_regression_ns.out
  BeforeMake: as above
  AfterMake: fromelf.exe --output "$Lsdk20-app.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT685SFVKB_cm33, BOOT_HEADER_ENABLE=1, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, OS_DYNAMIC_MEM_SIZE=7168, MCUXPRESSO_SDK, TFM_LVL=2, PROJECT_CONFIG_HEADER_FILE='\"config_profile_large.h\"', CONFIG_TFM_FLOAT_ABI=2, CONFIG_TFM_ENABLE_CP10CP11, CONFIG_TFM_LAZY_STACKING, __DOMAIN_NS=1, DOMAIN_NS=1, CONFIG_TFM_USE_TRUSTZONE, ATTEST_TOKEN_PROFILE_PSA_IOT_1, PLATFORM_DEFAULT_CRYPTO_KEYS, PS_ENCRYPTION, TFM_CRYPTO_TEST_ALG_CBC, TFM_CRYPTO_TEST_ALG_CCM, TFM_CRYPTO_TEST_ALG_GCM, TFM_CRYPTO_TEST_ALG_SHA_512, TFM_CRYPTO_TEST_HKDF, TFM_CRYPTO_TEST_ECDH, TFM_CRYPTO_TEST_UNSUPPORTED_ALG, TFM_NS_REG_TEST, TFM_S_REG_TEST, TEST_NS_PS, TEST_NS_PLATFORM, TFM_PARTITION_IPC_TEST, TEST_NS_IPC, TEST_NS_SLIH_IRQ, SERIAL_PORT_TYPE_UART=1, TARGET_CONFIG_HEADER_FILE='\"config_tfm_target.h\"', TEST_NS_ITS, TEST_NS_CRYPTO, TFM_PARTITION_INTERNAL_TRUSTED_STORAGE, T_COSE_USE_PSA_CRYPTO, QCBOR_DISABLE_FLOAT_HW_USE, USEFULBUF_DISABLE_ALL_FLOAT, QCBOR_DISABLE_PREFERRED_FLOAT, TEST_NS_ATTESTATION
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: as above
  link misc: ../../../../../../CMSIS/RTOS2/RTX/Library/ARM/RTX_V8MMFN.lib ../../tfm_regression_s/mdk/release/tfm_regression_s_CMSE_lib.o --remove --entry=Reset_Handler --diag_suppress 6314
