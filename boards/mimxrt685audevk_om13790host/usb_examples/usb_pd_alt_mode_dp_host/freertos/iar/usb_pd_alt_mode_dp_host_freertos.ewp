# IAR project usb_pd_alt_mode_dp_host_freertos.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; _DEBUG=1; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; USB_STACK_FREERTOS_HEAP_SIZE=10240; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; SDK_OS_FREE_RTOS; I2C_RETRY_TIMES=40000; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; TIMER_PORT_TYPE_MRT=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../mimxrt685audevk; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../middleware/usb/pd/ptn5110; ../../../../../../middleware/usb/pd; ../../../../../../middleware/usb/pd/phy_interface; ../../../../../../components/osa; ../../../../../../middleware/usb/pd/alt_mode; ../../../../../../components/i2c; ../../../../../../components/lists; ../../../../../../components/gpio; ../../../../../../components/timer; ../../../../../../components/serial_manager; ../../../../../../components/uart; ../../../../../../devices/MIMXRT685S; ../../../../../mimxrt685audevk/flash_config; ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../../devices/MIMXRT685S/utilities; ../../../../../../devices/MIMXRT685S/utilities/debug_console; ../../../../../../middleware/usb/include; ../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../CMSIS/Core/Include; ../../../../../../devices/MIMXRT685S/utilities/str
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..; ../../../../../mimxrt685audevk; ../../../../../../rtos/freertos/freertos-kernel/include
  ILINK.IlinkOutputFile: usb_pd_alt_mode_dp_host_freertos.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x1000
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; USB_STACK_FREERTOS_HEAP_SIZE=10240; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; SDK_OS_FREE_RTOS; I2C_RETRY_TIMES=40000; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; TIMER_PORT_TYPE_MRT=1; SERIAL_PORT_TYPE_UART=1
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; _DEBUG=0; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; USB_STACK_FREERTOS_HEAP_SIZE=10240; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; SDK_OS_FREE_RTOS; I2C_RETRY_TIMES=40000; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; TIMER_PORT_TYPE_MRT=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; USB_STACK_FREERTOS_HEAP_SIZE=10240; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; SDK_OS_FREE_RTOS; I2C_RETRY_TIMES=40000; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; TIMER_PORT_TYPE_MRT=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_flash.icf
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group source
    ../: pd_board_config.h pd_app.c pd_app.h pd_app_demo.c pd_command_app.c pd_command_interface.c pd_command_interface.h pd_power_app.c pd_power_interface.c pd_power_interface.h usb_pd_config.h pd_app_misc.h pd_dp_board_chip.c pd_dp_board_chip.h pd_crossbar_cbtl.h pd_crossbar_cbtl.c pd_ptn36502.h pd_ptn36502.c pd_dp_hpd_driver.h pd_dp_hpd_driver.c pd_power_nx20p3483.h pd_power_nx20p3483.c FreeRTOSConfig.h
  group drivers
    ../../../../../../devices/MIMXRT685S/drivers/: fsl_mrt.h fsl_mrt.c fsl_usart.h fsl_usart.c fsl_cache.c fsl_cache.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_flexcomm.h fsl_flexcomm.c fsl_i2c.h fsl_i2c.c fsl_flexspi.c fsl_flexspi.h fsl_inputmux.h fsl_inputmux.c fsl_gpio.h fsl_gpio.c fsl_iopctl.h fsl_pint.h fsl_pint.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_inputmux_connections.h
  group usb/ptn5110
    ../../../../../../middleware/usb/pd/ptn5110/: usb_pd_ptn5110.h usb_pd_ptn5110_connect.c usb_pd_ptn5110_hal.c usb_pd_ptn5110_interface.c usb_pd_ptn5110_msg.c usb_pd_ptn5110_register.h
  group usb/pd
    ../../../../../../middleware/usb/pd/: usb_pd.h usb_pd_interface.h usb_pd_phy.h usb_pd_spec.h usb_pd_timer.c usb_pd_timer.h usb_pd.h usb_pd_connect.c usb_pd_interface.h usb_pd_interface.c usb_pd_msg.c usb_pd_phy.h usb_pd_policy.c usb_pd_spec.h usb_pd_timer.c usb_pd_timer.h usb_pd_auto_policy.h
  group usb/pd/altmode
    ../../../../../../middleware/usb/pd/alt_mode/: usb_pd_alt_mode.c usb_pd_alt_mode.h usb_pd_alt_mode_dp.c usb_pd_alt_mode_dp.h
  group usb/phy_interface
    ../../../../../../middleware/usb/pd/phy_interface/: usb_pd_i2c.h usb_pd_i2c.c
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h fsl_os_abstraction_config.h
  group component/i2c
    ../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_flexcomm_i2c.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/gpio
    ../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_lpc_gpio.c
  group component/timer
    ../../../../../../components/timer/: fsl_adapter_timer.h fsl_adapter_mrt.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group device
    ../../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h
  group MIMXRT685S
    ../../../../../../devices/MIMXRT685S/: system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group MIMXRT685S/iar
    ../../../../../../devices/MIMXRT685S/iar/: startup_MIMXRT685S_cm33.s
  group flash_config
    ../../../../../mimxrt685audevk/flash_config/: flash_config.c flash_config.h
  group utilities
    ../../../../../../devices/MIMXRT685S/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../../devices/MIMXRT685S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
