<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>flash_component_octal_xspi_cm33_core0</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>flash_component_octal_xspi_cm33_core0</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>flash_component_octal_xspi_cm33_core0</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>flash_component_octal_xspi_cm33_core0</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/flash_component_octal_xspi_cm33_core0.ewp</path>
  </project>
</workspace>
