<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>dvs_pvt_comp_only_secondary</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>dvs_pvt_comp_only_secondary</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>dvs_pvt_comp_only_secondary</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>dvs_pvt_comp_only_secondary</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/dvs_pvt_comp_only_secondary.ewp</path>
  </project>
</workspace>
