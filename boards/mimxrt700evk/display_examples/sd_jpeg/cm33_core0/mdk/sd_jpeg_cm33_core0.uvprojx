# Keil uVision project sd_jpeg_cm33_core0.uvprojx, settings and files
target sd_jpeg_cm33_core0 debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT798SGFOB:cm33_core0 NXP
  pack: NXP.MIMXRT798S_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: sd_jpeg_cm33_core0.out
  AfterMake: fromelf.exe --output "$Lsd_jpeg.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, SDK_DEBUGCONSOLE_UART, DEMO_RM67162_USE_RG565=0, DEMO_SSD1963_USE_RG565=0, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, BOARD_ENABLE_PSRAM_CACHE=0, SSD1963_DATA_WITDH=8, SDK_I2C_BASED_COMPONENT_USED=1, FLEXIO_MCULCD_DATA_BUS_WIDTH=8, CPU_MIMXRT798SGFOB_cm33_core0, MIMXRT798S_cm33_core0_SERIES, OSA_USED, BOOT_HEADER_ENABLE=1, USE_RTOS=0, MCUX_DBI_LEGACY=0, SD_ENABLED=1
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../flash_config;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MIMXRT798S;../../../../../../devices/MIMXRT798S/periph;../../../../../../devices/MIMXRT798S/drivers;../../../../../../devices/MIMXRT798S/utilities/debug_console_lite;../../../../../../components/lists;../../../../../../devices/MIMXRT798S/utilities/str;../../../../../../components/gpio;../../../../../../components/uart;../../../../../../components/osa;../../../../../../components/video;../../../../../../components/video/display/dc;../../../../../../components/video/display;../../../../../../components/video/display/dbi;../../../../../../components/video/display/dbi/flexio;../../../../../../components/video/display/dbi/lcdif;../../../../../../components/video/display/dc/dsi_cmd;../../../../../../components/video/display/dc/lcdif;../../../../../../components/video/display/dc/dbi;../../../../../../components/video/display/mipi_dsi_cmd;../../../../../../components/video/display/hx8394;../../../../../../components/video/display/rm68191;../../../../../../components/video/display/rm68200;../../../../../../components/video/display/rm67162;../../../../../../components/video/display/co5300;../../../../../../components/video/display/rpi;../../../../../../components/display/ssd1963;../../../../../../middleware/fatfs/source;../../../../../../middleware/fatfs/template;../../../../../../middleware/fatfs/source/fsl_sd_disk;../../../../../../middleware/sdmmc/common;../../../../../../middleware/sdmmc/osa;../../../../../../middleware/sdmmc/sd;../../../../../../middleware/sdmmc/host/usdhc;../../../../../../middleware/libjpeg/inc
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT798SGFOB_cm33_core0, MIMXRT798S_cm33_core0_SERIES, OSA_USED
  asm misc: -include ../mcux_config.h
  asm include: ..;../../../../flash_config;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MIMXRT798S;../../../../../../devices/MIMXRT798S/periph;../../../../../../devices/periph;../../../../../../devices/MIMXRT798S/drivers;../../../../../../devices/MIMXRT798S/utilities/debug_console_lite;../../../../../../components/lists;../../../../../../devices/MIMXRT798S/utilities/str;../../../../../../components/gpio;../../../../../../components/uart;../../../../../../components/osa;../../../../../../components/video;../../../../../../components/video/display/dc;../../../../../../components/video/display;../../../../../../components/video/display/dbi;../../../../../../components/video/display/dbi/flexio;../../../../../../components/video/display/dbi/lcdif;../../../../../../components/video/display/dc/dsi_cmd;../../../../../../components/video/display/dc/lcdif;../../../../../../components/video/display/dc/dbi;../../../../../../components/video/display/mipi_dsi_cmd;../../../../../../components/video/display/hx8394;../../../../../../components/video/display/rm68191;../../../../../../components/video/display/rm68200;../../../../../../components/video/display/rm67162;../../../../../../components/video/display/co5300;../../../../../../components/video/display/rpi;../../../../../../components/display/ssd1963;../../../../../../middleware/fatfs/source;../../../../../../middleware/fatfs/template;../../../../../../middleware/fatfs/source/fsl_sd_disk;../../../../../../middleware/sdmmc/common;../../../../../../middleware/sdmmc/osa;../../../../../../middleware/sdmmc/sd;../../../../../../middleware/sdmmc/host/usdhc;../../../../../../middleware/libjpeg/inc
  library: MicroLIB
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20080000 size 0x280000
  memory RVCT7: RAM 0x30080000 size 0x280000
  memory RVCT8: RAM 0x680000 size 0x100000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x10080000 size 0x280000
  scatter file: MIMXRT798Sxxxx_cm33_core0_ram.scf
  link misc: --remove --predefine=\"-D__stack_size__=0x1000\" --predefine=\"-D__heap_size__=0x20000\" --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: pics.zip sd_jpeg.c jconfig.h sdmmc_config.h sdmmc_config.c display_support.h display_support.c ffconf_gen.h fsl_os_abstraction_config.h mcux_config.h mcux_config.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv8m_mpu.h
  group device
    ../../../../../../devices/MIMXRT798S/: fsl_device_registers.h MIMXRT798S_cm33_core0.h MIMXRT798S_cm33_core0_COMMON.h MIMXRT798S_cm33_core0_features.h system_MIMXRT798S_cm33_core0.c system_MIMXRT798S_cm33_core0.h
  group device/periph
    ../../../../../../devices/MIMXRT798S/periph/: PERI_ADC.h PERI_AHBSC0.h PERI_AHBSC3.h PERI_AHBSC4.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CDOG.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CLKCTL2.h PERI_CLKCTL3.h PERI_CLKCTL4.h PERI_CMP.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUG_MAILBOX.h PERI_DMA.h PERI_ELS.h PERI_FLEXIO.h PERI_FREQME.h PERI_FRO.h PERI_GDET.h PERI_GLIKEY.h PERI_GPIO.h PERI_I2S.h PERI_I3C.h PERI_INPUTMUX0.h PERI_INPUTMUX1.h PERI_IOPCTL0.h PERI_IOPCTL1.h PERI_IOPCTL2.h PERI_ITRC.h PERI_JPEGDEC.h PERI_JPGDECWRP.h PERI_LCDIF.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_LP_FLEXCOMM.h PERI_MIPI_DSI_HOST.h PERI_MMU.h PERI_MRT.h PERI_MU.h PERI_NIC.h PERI_OCOTP.h PERI_OSC32KNP.h PERI_OSCCA.h PERI_OSTIMER.h PERI_PDM.h PERI_PINT.h PERI_PKC.h PERI_PMC.h PERI_PNGDEC.h PERI_PUF.h PERI_PVTS.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RSTCTL2.h PERI_RSTCTL3.h PERI_RSTCTL4.h PERI_RTC.h PERI_SCT.h PERI_SDADC.h PERI_SEMA42.h PERI_SLEEPCON0.h PERI_SLEEPCON1.h PERI_SYSCON0.h PERI_SYSCON1.h PERI_SYSCON2.h PERI_SYSCON3.h PERI_SYSCON4.h PERI_SYSPM.h PERI_TRNG.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_UTICK.h PERI_WWDT.h PERI_XCACHE.h PERI_XSPI.h
  group startup
    ../../../../../../devices/MIMXRT798S/: startup_MIMXRT798S_cm33_core0.c
  group drivers
    ../../../../../../devices/MIMXRT798S/drivers/: fsl_clock.c fsl_clock.h fsl_edma_soc.c fsl_edma_soc.h fsl_iopctl.h fsl_soc_mipi_dsi.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_edma.h fsl_edma_core.h fsl_edma.c fsl_flexio.c fsl_flexio.h fsl_flexio_mculcd_edma.c fsl_flexio_mculcd_edma.h fsl_flexio_mculcd.c fsl_flexio_mculcd.h fsl_glikey.h fsl_glikey.c fsl_gpio.h fsl_gpio.c fsl_lcdif.h fsl_lcdif.c fsl_lpflexcomm.h fsl_lpflexcomm.c fsl_lpuart.h fsl_lpuart.c fsl_lpi2c.h fsl_lpi2c.c fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_usdhc.c fsl_usdhc.h fsl_xspi.c fsl_xspi.h
  group utilities
    ../../../../../../devices/MIMXRT798S/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
    ../../../../../../devices/MIMXRT798S/utilities/: fsl_memcpy.S
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group utilities/str
    ../../../../../../devices/MIMXRT798S/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MIMXRT798S/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/gpio
    ../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_gpio.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c fsl_os_abstraction.h
  group video
    ../../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../../components/video/display/dc/: fsl_dc_fb.h
    ../../../../../../components/video/display/: fsl_display.h
    ../../../../../../components/video/display/dbi/: fsl_dbi.h fsl_dbi.c
    ../../../../../../components/video/display/dbi/flexio/: fsl_dbi_flexio_edma.h fsl_dbi_flexio_edma.c
    ../../../../../../components/video/display/dbi/lcdif/: fsl_dbi_lcdif.h fsl_dbi_lcdif.c
    ../../../../../../components/video/display/dc/dsi_cmd/: fsl_dc_fb_dsi_cmd.h fsl_dc_fb_dsi_cmd.c
    ../../../../../../components/video/display/dc/lcdif/: fsl_dc_fb_lcdif.h fsl_dc_fb_lcdif.c
    ../../../../../../components/video/display/dc/dbi/: fsl_dc_fb_dbi.h fsl_dc_fb_dbi.c
    ../../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
    ../../../../../../components/video/display/hx8394/: fsl_hx8394.h fsl_hx8394.c
    ../../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../../components/video/display/rm67162/: fsl_rm67162.h fsl_rm67162.c
    ../../../../../../components/video/display/co5300/: fsl_co5300.h fsl_co5300.c
    ../../../../../../components/video/display/rpi/: fsl_rpi.h fsl_rpi.c
  group lcdc
    ../../../../../../components/display/ssd1963/: fsl_ssd1963.h fsl_ssd1963.c
  group fatfs/source
    ../../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group source/template
    ../../../../../../middleware/fatfs/template/: ffconf.h
  group fatfs/source/fsl_sd_disk
    ../../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group sdmmc/common
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h fsl_sdmmc_common.c
  group sdmmc/osa
    ../../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group sdmmc/sd
    ../../../../../../middleware/sdmmc/sd/: fsl_sd.c fsl_sd.h
  group sdmmc/host/usdhc
    ../../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h fsl_sdmmc_host.h
  group sdmmc/host/usdhc/non_blocking
    ../../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group libjpeg/inc
    ../../../../../../middleware/libjpeg/inc/: cderror.h cdjpeg.h jdct.h jerror.h jinclude.h jmemsys.h jmorecfg.h jpegint.h jpeglib.h jversion.h transupp.h
  group libjpeg/src
    ../../../../../../middleware/libjpeg/src/: jaricom.c jcapimin.c jcapistd.c jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcprepct.c jcsample.c jctrans.c jdapimin.c jdapistd.c jdarith.c jdatadst.c jdatasrc.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jdtrans.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jmemmgr.c jmemnobs.c jquant1.c jquant2.c jutils.c
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
target sd_jpeg_cm33_core0 flash_debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT798SGFOB:cm33_core0 NXP
  pack: NXP.MIMXRT798S_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: sd_jpeg_cm33_core0.out
  AfterMake: fromelf.exe --output "$Lsd_jpeg.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20080000 size 0x280000
  memory RVCT7: RAM 0x30080000 size 0x280000
  memory RVCT8: RAM 0x680000 size 0x100000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x10080000 size 0x280000
  scatter file: MIMXRT798Sxxxx_cm33_core0_flash.scf
  link misc: as above
target sd_jpeg_cm33_core0 release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT798SGFOB:cm33_core0 NXP
  pack: NXP.MIMXRT798S_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: sd_jpeg_cm33_core0.out
  AfterMake: fromelf.exe --output "$Lsd_jpeg.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, SDK_DEBUGCONSOLE_UART, DEMO_RM67162_USE_RG565=0, DEMO_SSD1963_USE_RG565=0, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, BOARD_ENABLE_PSRAM_CACHE=0, SSD1963_DATA_WITDH=8, SDK_I2C_BASED_COMPONENT_USED=1, FLEXIO_MCULCD_DATA_BUS_WIDTH=8, CPU_MIMXRT798SGFOB_cm33_core0, MIMXRT798S_cm33_core0_SERIES, OSA_USED, BOOT_HEADER_ENABLE=1, USE_RTOS=0, MCUX_DBI_LEGACY=0, SD_ENABLED=1
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20080000 size 0x280000
  memory RVCT7: RAM 0x30080000 size 0x280000
  memory RVCT8: RAM 0x680000 size 0x100000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x10080000 size 0x280000
  scatter file: MIMXRT798Sxxxx_cm33_core0_ram.scf
  link misc: as above
target sd_jpeg_cm33_core0 flash_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT798SGFOB:cm33_core0 NXP
  pack: NXP.MIMXRT798S_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: sd_jpeg_cm33_core0.out
  AfterMake: fromelf.exe --output "$Lsd_jpeg.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20080000 size 0x280000
  memory RVCT7: RAM 0x30080000 size 0x280000
  memory RVCT8: RAM 0x680000 size 0x100000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x10080000 size 0x280000
  scatter file: MIMXRT798Sxxxx_cm33_core0_flash.scf
  link misc: as above
