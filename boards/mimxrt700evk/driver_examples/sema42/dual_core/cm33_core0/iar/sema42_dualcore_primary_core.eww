<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>sema42_dualcore_primary_core</project>
        <configuration>flash_debug</configuration>
      </member>
      <member>
        <project>sema42_dualcore_primary_core</project>
        <configuration>flash_release</configuration>
      </member>
      <member>
        <project>sema42_dualcore_secondary_core</project>
        <configuration>flash_debug</configuration>
      </member>
      <member>
        <project>sema42_dualcore_secondary_core</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_debug</name>
      <member>
        <project>sema42_dualcore_primary_core</project>
        <configuration>flash_debug</configuration>
      </member>
      <member>
        <project>sema42_dualcore_secondary_core</project>
        <configuration>flash_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_release</name>
      <member>
        <project>sema42_dualcore_primary_core</project>
        <configuration>flash_release</configuration>
      </member>
      <member>
        <project>sema42_dualcore_secondary_core</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/sema42_dualcore_primary_core.ewp</path>
  </project>
</workspace>
