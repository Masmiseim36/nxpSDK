<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>central_pxm_cm33_core0</project>
        <configuration>flash_release</configuration>
      </member>
      <member>
        <project>central_pxm_cm33_core0</project>
        <configuration>flash_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_release</name>
      <member>
        <project>central_pxm_cm33_core0</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_debug</name>
      <member>
        <project>central_pxm_cm33_core0</project>
        <configuration>flash_debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/central_pxm_cm33_core0.ewp</path>
  </project>
</workspace>
