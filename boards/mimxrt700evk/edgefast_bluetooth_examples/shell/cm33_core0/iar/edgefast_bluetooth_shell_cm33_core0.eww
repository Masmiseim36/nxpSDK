<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>edgefast_bluetooth_shell_cm33_core0</project>
        <configuration>flash_release</configuration>
      </member>
      <member>
        <project>edgefast_bluetooth_shell_cm33_core0</project>
        <configuration>flash_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_release</name>
      <member>
        <project>edgefast_bluetooth_shell_cm33_core0</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_debug</name>
      <member>
        <project>edgefast_bluetooth_shell_cm33_core0</project>
        <configuration>flash_debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/edgefast_bluetooth_shell_cm33_core0.ewp</path>
  </project>
</workspace>
