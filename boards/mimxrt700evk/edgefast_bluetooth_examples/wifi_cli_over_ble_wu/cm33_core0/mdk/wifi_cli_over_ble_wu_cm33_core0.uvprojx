# Keil uVision project wifi_cli_over_ble_wu_cm33_core0.uvprojx, settings and files
target wifi_cli_over_ble_wu_cm33_core0 flash_debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT798SGFOB:cm33_core0 NXP
  pack: NXP.MIMXRT798S_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: wifi_cli_over_ble_wu_cm33_core0.out
  AfterMake: fromelf.exe --output "$Lwifi_cli_over_ble_wu.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CFG_BLE, LPUART_RING_BUFFER_SIZE=1024U, PRINTF_ADVANCED_ENABLE=1, SDK_DEBUGCONSOLE_UART=1, SDK_OS_FREE_RTOS, USE_RTOS=1, APPL_USE_STANDARD_IO, CONFIG_ARM=1, DATA_SECTION_IS_CACHEABLE=1, EDGEFAST_BT_LITTLEFS_MFLASH, FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0, FSL_FEATURE_FLASH_PAGE_SIZE_BYTES=4096, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, GATT_CLIENT, GATT_DB, HAL_UART_ADAPTER_FIFO=1, IOT_WIFI_ENABLE_SAVE_NETWORK=1, LFS_NO_ERROR=1, LFS_NO_INTRINSICS=1, USB_HOST_CONFIG_BUFFER_PROPERTY_CACHEABLE=1, gMemManagerLight=0, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT798SGFOB_cm33_core0, MIMXRT798S_cm33_core0_SERIES, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING=1, OSA_USED, BOOT_HEADER_ENABLE=1, SERIAL_PORT_TYPE_UART=1, TIMER_PORT_TYPE_MRT=1, CONFIG_WIFI_BT_CMOBO_DNLD, CONFIG_WIFI_IND_DNLD=0, CONFIG_WIFI_IND_RESET=0, WIFI_IW612_BOARD_MURATA_2EL_M2, PSA_CRYPTO_DRIVER_ELS_PKC, MFLASH_FILE_BASEADDR=7340032, CONFIG_NXP_WIFI_SOFTAP_SUPPORT=1, PRINTF_FLOAT_ENABLE=1, SO_REUSE=1, MBEDTLS_CONFIG_FILE='\"mcux_mbedtls_config.h\"', SDIO_ENABLED=1, LFS_THREADSAFE=1, LOG_ENABLE_ASYNC_MODE=1, LOG_MAX_ARGUMENT_COUNT=10, LOG_ENABLE_OVERWRITE=1
  c misc: -include ../edgefast_bluetooth_app.h -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../flash_config;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MIMXRT798S;../../../../../../devices/MIMXRT798S/periph;../../../../../../devices/MIMXRT798S/drivers;../../../../../../devices/MIMXRT798S/utilities/debug_console;../../../../../../components/lists;../../../../../../devices/MIMXRT798S/utilities/str;../../../../../../components/log;../../../../../../components/serial_manager;../../../../../../components/button;../../../../../../components/common_task;../../../../../../components/gpio;../../../../../../components/timer;../../../../../../components/timer_manager;../../../../../../components/uart;../../../../../../components/osa;../../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits;../../../../../../components/wifi_bt_module/Murata/tx_pwr_limits;../../../../../../components/wifi_bt_module/u-blox/tx_pwr_limits;../../../../../../components/wifi_bt_module/incl;../../../../../../components/els_pkc;../../../../../../components/els_pkc/src/comps/common/inc;../../../../../../components/els_pkc/src/comps/mcuxClAead/inc;../../../../../../components/els_pkc/src/comps/mcuxClAead/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClAeadModes/inc;../../../../../../components/els_pkc/src/comps/mcuxClAeadModes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClAes/inc;../../../../../../components/els_pkc/src/comps/mcuxClAes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc;../../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClCipher/inc;../../../../../../components/els_pkc/src/comps/mcuxClCipher/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClCipherModes/inc;../../../../../../components/els_pkc/src/comps/mcuxClCipherModes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClCore/inc;../../../../../../components/els_pkc/src/comps/mcuxClCrc/inc;../../../../../../components/els_pkc/src/comps/mcuxClCrc/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClEcc/inc;../../../../../../components/els_pkc/src/comps/mcuxClEcc/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClEls/inc;../../../../../../components/els_pkc/src/comps/mcuxClEls/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClGlikey/inc;../../../../../../components/els_pkc/src/comps/mcuxClGlikey/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClHash/inc;../../../../../../components/els_pkc/src/comps/mcuxClHash/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClHashModes/inc;../../../../../../components/els_pkc/src/comps/mcuxClHashModes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClHmac/inc;../../../../../../components/els_pkc/src/comps/mcuxClHmac/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClKey/inc;../../../../../../components/els_pkc/src/comps/mcuxClKey/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClMac/inc;../../../../../../components/els_pkc/src/comps/mcuxClMac/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClMacModes/inc;../../../../../../components/els_pkc/src/comps/mcuxClMacModes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClMath/inc;../../../../../../components/els_pkc/src/comps/mcuxClMath/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClMemory/inc;../../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc;../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClOsccaAeadModes/inc;../../../../../../components/els_pkc/src/comps/mcuxClOsccaAeadModes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClOsccaCipherModes/inc;../../../../../../components/els_pkc/src/comps/mcuxClOsccaCipherModes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClOsccaMacModes/inc;../../../../../../components/els_pkc/src/comps/mcuxClOsccaMacModes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClOsccaPkc/inc;../../../../../../components/els_pkc/src/comps/mcuxClOsccaPkc/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClOsccaRandomModes/inc;../../../../../../components/els_pkc/src/comps/mcuxClOsccaRandomModes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClOsccaSafo/inc;../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm2/inc;../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm2/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm3/inc;../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm3/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm4/inc;../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm4/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClPadding/inc;../../../../../../components/els_pkc/src/comps/mcuxClPadding/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClPkc/inc;../../../../../../components/els_pkc/src/comps/mcuxClPkc/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClPrng/inc;../../../../../../components/els_pkc/src/comps/mcuxClPrng/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClPsaDriver/inc;../../../../../../components/els_pkc/src/comps/mcuxClPsaDriver/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClRandom/inc;../../../../../../components/els_pkc/src/comps/mcuxClRandom/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClRandomModes/inc;../../../../../../components/els_pkc/src/comps/mcuxClRandomModes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClRsa/inc;../../../../../../components/els_pkc/src/comps/mcuxClRsa/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClSession/inc;../../../../../../components/els_pkc/src/comps/mcuxClSession/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClSignature/inc;../../../../../../components/els_pkc/src/comps/mcuxClSignature/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClTrng/inc;../../../../../../components/els_pkc/src/comps/mcuxClTrng/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxCsslCPreProcessor/inc;../../../../../../components/els_pkc/src/comps/mcuxCsslDataIntegrity/inc;../../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/inc;../../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/inc;../../../../../../components/els_pkc/src/comps/mcuxCsslSecureCounter/inc;../../../../../../components/els_pkc/src/inc;../../../../../../components/els_pkc/src/compiler;../../../../../../components/els_pkc/src/platforms/mimxrt;../../../../../../components/els_pkc/src/platforms/mimxrt/inc;../../../../../../components/els_pkc/includes/platform/mimxrt;../../../../../../components/psa_crypto_driver/osal;../../../../../../components/psa_crypto_driver/osal/baremetal;../../../../../../components/psa_crypto_driver/els_pkc/oracle/platforms/mimxrt;../../../../../../components/psa_crypto_driver/els_pkc/oracle/inc;../../../../../../components/psa_crypto_driver/els_pkc/include/common;../../../../../../components/psa_crypto_driver/els_pkc/include/transparent;../../../../../../components/psa_crypto_driver/els_pkc/include/opaque;../../../../../../components/psa_crypto_driver/els_pkc;../../../../../../components/flash/mflash;../../../../../../components/flash/mflash/mimxrt700;../../../../../../middleware/wifi_nxp;../../../../../../middleware/wifi_nxp/incl;../../../../../../middleware/wifi_nxp/incl/port/osa;../../../../../../middleware/wifi_nxp/port/osa;../../../../../../middleware/wifi_nxp/incl/port;../../../../../../middleware/wifi_nxp/incl/wifidriver;../../../../../../middleware/wifi_nxp/wifi_bt_firmware;../../../../../../middleware/wifi_nxp/wifidriver;../../../../../../middleware/wifi_nxp/wifidriver/incl;../../../../../../middleware/wifi_nxp/wifi_bt_firmware/IW416;../../../../../../middleware/wifi_nxp/wifi_bt_firmware/8987;../../../../../../middleware/wifi_nxp/wifi_bt_firmware/nw61x;../../../../../../middleware/wifi_nxp/wifi_bt_firmware/iw610;../../../../../../middleware/wifi_nxp/firmware_dnld;../../../../../../middleware/wifi_nxp/sdio_nxp_abs;../../../../../../middleware/wifi_nxp/sdio_nxp_abs/incl;../../../../../../middleware/wifi_nxp/fwdnld_intf_abs;../../../../../../middleware/wifi_nxp/incl/port/net;../../../../../../middleware/wifi_nxp/incl/port/net/hooks;../../../../../../middleware/wifi_nxp/dhcpd;../../../../../../middleware/wifi_nxp/incl/wlcmgr;../../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if;../../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if/incl;../../../../../../middleware/wifi_nxp/certs;../../../../../../middleware/wifi_nxp/port/net;../../../../../../middleware/wifi_nxp/cli;../../../../../../middleware/wifi_nxp/nw_utils;../../../../../../middleware/usb/include;../../../../../../middleware/usb/host;../../../../../../middleware/usb/config/host/ehci;../../../../../../middleware/usb/host/class;../../../../../../middleware/usb/phy;../../../../../../middleware/fatfs/source;../../../../../../middleware/fatfs/source/fsl_usb_disk;../../../../../../middleware/littlefs;../../../../../../middleware/lwip/port;../../../../../../middleware/lwip/src/include;../../../../../../middleware/lwip/port/sys_arch/dynamic;../../../../../../middleware/mbedtls3x/include;../../../../../../middleware/mbedtls3x/library;../../../../../../middleware/mbedtls3x/port;../../../../../../middleware/sdmmc/common;../../../../../../middleware/sdmmc/osa;../../../../../../middleware/sdmmc/sdio;../../../../../../middleware/sdmmc/host/usdhc;../../../../../../middleware/wireless/ethermind/bluetooth/export/eOSAL;../../../../../../middleware/wireless/ethermind/bluetooth/export/include;../../../../../../middleware/wireless/ethermind/bluetooth/export/vendor;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/att;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avctp;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avdtp;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/bnep;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/dbase;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/hci_1.2;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/mcap;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/obex;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/rfcomm;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sdp;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sm;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/smp;../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/aes_cmac;../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/at_parser;../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/object_parser;../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/racp;../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/storage;../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/xml_parser;../../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth;../../../../../../middleware/wireless/ethermind/port/pal/mcux/ethal;../../../../../../middleware/wireless/ethermind/port/pal/mcux/sbc;../../../../../../middleware/wireless/ethermind/port/osal/src/freertos;../../../../../../middleware/wireless/ethermind/port/pal/mcux;../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/sbc;../../../../../../middleware/wireless/ethermind/bluetooth/export/extension;../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/config;../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/host;../../../../../../middleware/edgefast_bluetooth/include;../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/controller/configs/mbedtls;../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/crypto;../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/platform;../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind;../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/platform/configs;../../../../../../middleware/edgefast_bluetooth/source/porting;../../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth/controller;../../../../../../middleware/edgefast_bluetooth/source/services;../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure;../../../../../../rtos/freertos/freertos-kernel/template/ARM_CM33_3_priority_bits
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT798SGFOB_cm33_core0, MIMXRT798S_cm33_core0_SERIES, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, OSA_USED
  asm misc: -include ../mcux_config.h
  asm include: ..;../../../../flash_config;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MIMXRT798S;../../../../../../devices/MIMXRT798S/periph;../../../../../../devices/periph;../../../../../../devices/MIMXRT798S/drivers;../../../../../../devices/MIMXRT798S/utilities/debug_console;../../../../../../components/lists;../../../../../../devices/MIMXRT798S/utilities/str;../../../../../../components/log;../../../../../../components/serial_manager;../../../../../../components/button;../../../../../../components/common_task;../../../../../../components/gpio;../../../../../../components/timer;../../../../../../components/timer_manager;../../../../../../components/uart;../../../../../../components/osa;../../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits;../../../../../../components/wifi_bt_module/Murata/tx_pwr_limits;../../../../../../components/wifi_bt_module/u-blox/tx_pwr_limits;../../../../../../components/wifi_bt_module/incl;../../../../../../components/els_pkc;../../../../../../components/els_pkc/src/comps/common/inc;../../../../../../components/els_pkc/src/comps/mcuxClAead/inc;../../../../../../components/els_pkc/src/comps/mcuxClAead/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClAeadModes/inc;../../../../../../components/els_pkc/src/comps/mcuxClAeadModes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClAes/inc;../../../../../../components/els_pkc/src/comps/mcuxClAes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc;../../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClCipher/inc;../../../../../../components/els_pkc/src/comps/mcuxClCipher/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClCipherModes/inc;../../../../../../components/els_pkc/src/comps/mcuxClCipherModes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClCore/inc;../../../../../../components/els_pkc/src/comps/mcuxClCrc/inc;../../../../../../components/els_pkc/src/comps/mcuxClCrc/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClEcc/inc;../../../../../../components/els_pkc/src/comps/mcuxClEcc/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClEls/inc;../../../../../../components/els_pkc/src/comps/mcuxClEls/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClGlikey/inc;../../../../../../components/els_pkc/src/comps/mcuxClGlikey/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClHash/inc;../../../../../../components/els_pkc/src/comps/mcuxClHash/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClHashModes/inc;../../../../../../components/els_pkc/src/comps/mcuxClHashModes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClHmac/inc;../../../../../../components/els_pkc/src/comps/mcuxClHmac/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClKey/inc;../../../../../../components/els_pkc/src/comps/mcuxClKey/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClMac/inc;../../../../../../components/els_pkc/src/comps/mcuxClMac/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClMacModes/inc;../../../../../../components/els_pkc/src/comps/mcuxClMacModes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClMath/inc;../../../../../../components/els_pkc/src/comps/mcuxClMath/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClMemory/inc;../../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc;../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClOsccaAeadModes/inc;../../../../../../components/els_pkc/src/comps/mcuxClOsccaAeadModes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClOsccaCipherModes/inc;../../../../../../components/els_pkc/src/comps/mcuxClOsccaCipherModes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClOsccaMacModes/inc;../../../../../../components/els_pkc/src/comps/mcuxClOsccaMacModes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClOsccaPkc/inc;../../../../../../components/els_pkc/src/comps/mcuxClOsccaPkc/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClOsccaRandomModes/inc;../../../../../../components/els_pkc/src/comps/mcuxClOsccaRandomModes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClOsccaSafo/inc;../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm2/inc;../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm2/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm3/inc;../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm3/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm4/inc;../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm4/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClPadding/inc;../../../../../../components/els_pkc/src/comps/mcuxClPadding/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClPkc/inc;../../../../../../components/els_pkc/src/comps/mcuxClPkc/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClPrng/inc;../../../../../../components/els_pkc/src/comps/mcuxClPrng/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClPsaDriver/inc;../../../../../../components/els_pkc/src/comps/mcuxClPsaDriver/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClRandom/inc;../../../../../../components/els_pkc/src/comps/mcuxClRandom/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClRandomModes/inc;../../../../../../components/els_pkc/src/comps/mcuxClRandomModes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClRsa/inc;../../../../../../components/els_pkc/src/comps/mcuxClRsa/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClSession/inc;../../../../../../components/els_pkc/src/comps/mcuxClSession/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClSignature/inc;../../../../../../components/els_pkc/src/comps/mcuxClSignature/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClTrng/inc;../../../../../../components/els_pkc/src/comps/mcuxClTrng/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxCsslCPreProcessor/inc;../../../../../../components/els_pkc/src/comps/mcuxCsslDataIntegrity/inc;../../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/inc;../../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/inc;../../../../../../components/els_pkc/src/comps/mcuxCsslSecureCounter/inc;../../../../../../components/els_pkc/src/inc;../../../../../../components/els_pkc/src/compiler;../../../../../../components/els_pkc/src/platforms/mimxrt;../../../../../../components/els_pkc/src/platforms/mimxrt/inc;../../../../../../components/els_pkc/includes/platform/mimxrt;../../../../../../components/psa_crypto_driver/osal;../../../../../../components/psa_crypto_driver/osal/baremetal;../../../../../../components/psa_crypto_driver/els_pkc/oracle/platforms/mimxrt;../../../../../../components/psa_crypto_driver/els_pkc/oracle/inc;../../../../../../components/psa_crypto_driver/els_pkc/include/common;../../../../../../components/psa_crypto_driver/els_pkc/include/transparent;../../../../../../components/psa_crypto_driver/els_pkc/include/opaque;../../../../../../components/psa_crypto_driver/els_pkc;../../../../../../components/flash/mflash;../../../../../../components/flash/mflash/mimxrt700;../../../../../../middleware/wifi_nxp;../../../../../../middleware/wifi_nxp/incl;../../../../../../middleware/wifi_nxp/incl/port/osa;../../../../../../middleware/wifi_nxp/port/osa;../../../../../../middleware/wifi_nxp/incl/port;../../../../../../middleware/wifi_nxp/incl/wifidriver;../../../../../../middleware/wifi_nxp/wifi_bt_firmware;../../../../../../middleware/wifi_nxp/wifidriver;../../../../../../middleware/wifi_nxp/wifidriver/incl;../../../../../../middleware/wifi_nxp/wifi_bt_firmware/IW416;../../../../../../middleware/wifi_nxp/wifi_bt_firmware/8987;../../../../../../middleware/wifi_nxp/wifi_bt_firmware/nw61x;../../../../../../middleware/wifi_nxp/wifi_bt_firmware/iw610;../../../../../../middleware/wifi_nxp/firmware_dnld;../../../../../../middleware/wifi_nxp/sdio_nxp_abs;../../../../../../middleware/wifi_nxp/sdio_nxp_abs/incl;../../../../../../middleware/wifi_nxp/fwdnld_intf_abs;../../../../../../middleware/wifi_nxp/incl/port/net;../../../../../../middleware/wifi_nxp/incl/port/net/hooks;../../../../../../middleware/wifi_nxp/dhcpd;../../../../../../middleware/wifi_nxp/incl/wlcmgr;../../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if;../../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if/incl;../../../../../../middleware/wifi_nxp/certs;../../../../../../middleware/wifi_nxp/port/net;../../../../../../middleware/wifi_nxp/cli;../../../../../../middleware/wifi_nxp/nw_utils;../../../../../../middleware/usb/include;../../../../../../middleware/usb/host;../../../../../../middleware/usb/config/host/ehci;../../../../../../middleware/usb/host/class;../../../../../../middleware/usb/phy;../../../../../../middleware/fatfs/source;../../../../../../middleware/fatfs/source/fsl_usb_disk;../../../../../../middleware/littlefs;../../../../../../middleware/lwip/port;../../../../../../middleware/lwip/src/include;../../../../../../middleware/lwip/port/sys_arch/dynamic;../../../../../../middleware/mbedtls3x/include;../../../../../../middleware/mbedtls3x/library;../../../../../../middleware/mbedtls3x/port;../../../../../../middleware/sdmmc/common;../../../../../../middleware/sdmmc/osa;../../../../../../middleware/sdmmc/sdio;../../../../../../middleware/sdmmc/host/usdhc;../../../../../../middleware/wireless/ethermind/bluetooth/export/eOSAL;../../../../../../middleware/wireless/ethermind/bluetooth/export/include;../../../../../../middleware/wireless/ethermind/bluetooth/export/vendor;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/att;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avctp;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avdtp;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/bnep;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/dbase;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/hci_1.2;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/mcap;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/obex;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/rfcomm;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sdp;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sm;../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/smp;../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/aes_cmac;../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/at_parser;../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/object_parser;../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/racp;../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/storage;../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/xml_parser;../../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth;../../../../../../middleware/wireless/ethermind/port/pal/mcux/ethal;../../../../../../middleware/wireless/ethermind/port/pal/mcux/sbc;../../../../../../middleware/wireless/ethermind/port/osal/src/freertos;../../../../../../middleware/wireless/ethermind/port/pal/mcux;../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/sbc;../../../../../../middleware/wireless/ethermind/bluetooth/export/extension;../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/config;../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/host;../../../../../../middleware/edgefast_bluetooth/include;../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/controller/configs/mbedtls;../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/crypto;../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/platform;../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind;../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/platform/configs;../../../../../../middleware/edgefast_bluetooth/source/porting;../../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth/controller;../../../../../../middleware/edgefast_bluetooth/source/services;../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure;../../../../../../rtos/freertos/freertos-kernel/template/ARM_CM33_3_priority_bits
  library: MicroLIB
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20080000 size 0x280000
  memory RVCT7: RAM 0x30080000 size 0x280000
  memory RVCT8: RAM 0x680000 size 0x100000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x10080000 size 0x280000
  scatter file: MIMXRT798Sxxxx_cm33_core0_flash.scf
  link misc: ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/ble/cm33/mdk/libethermind_ble_core.lib ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/ble/cm33/mdk/libethermind_ble_gatt.lib ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/ble/cm33/mdk/libethermind_ble_protocol.lib ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/ble/cm33/mdk/libethermind_ble_util.lib --remove --keep=*(._bt_*) --keep=*(._net_buf_pool*) --keep=*(._settings_handler_static*) --keep=mflash_drv.o(*) --legacyalign --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: edgefast_bluetooth_app.h edgefast_bluetooth_app.h fsl_component_serial_port_ble_wu.c fsl_component_serial_port_ble_wu.h serial_port_ble_wu_lower_level.c wifi_cli_adapter.c lwiphooks.h lwipopts.h lwippools.h main.c wifi_config.h FreeRTOSConfigBoard.h sdmmc_config.c sdmmc_config.h wifi_bt_config.c wifi_bt_config.h app.h hardware_init.c pin_mux.c pin_mux.h FreeRTOSConfig.h edgefast_bluetooth_audio_config.h edgefast_bluetooth_config.h fsl_debug_console_conf.h fsl_os_abstraction_config.h mcux_config.h mcux_config.h mcux_config.h usb_host_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv8m_mpu.h
  group device
    ../../../../../../devices/MIMXRT798S/: fsl_device_registers.h MIMXRT798S_cm33_core0.h MIMXRT798S_cm33_core0_COMMON.h MIMXRT798S_cm33_core0_features.h system_MIMXRT798S_cm33_core0.c system_MIMXRT798S_cm33_core0.h
  group device/periph
    ../../../../../../devices/MIMXRT798S/periph/: PERI_ADC.h PERI_AHBSC0.h PERI_AHBSC3.h PERI_AHBSC4.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CDOG.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CLKCTL2.h PERI_CLKCTL3.h PERI_CLKCTL4.h PERI_CMP.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUG_MAILBOX.h PERI_DMA.h PERI_ELS.h PERI_FLEXIO.h PERI_FREQME.h PERI_FRO.h PERI_GDET.h PERI_GLIKEY.h PERI_GPIO.h PERI_I2S.h PERI_I3C.h PERI_INPUTMUX0.h PERI_INPUTMUX1.h PERI_IOPCTL0.h PERI_IOPCTL1.h PERI_IOPCTL2.h PERI_ITRC.h PERI_JPEGDEC.h PERI_JPGDECWRP.h PERI_LCDIF.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_LP_FLEXCOMM.h PERI_MIPI_DSI_HOST.h PERI_MMU.h PERI_MRT.h PERI_MU.h PERI_NIC.h PERI_OCOTP.h PERI_OSC32KNP.h PERI_OSCCA.h PERI_OSTIMER.h PERI_PDM.h PERI_PINT.h PERI_PKC.h PERI_PMC.h PERI_PNGDEC.h PERI_PUF.h PERI_PVTS.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RSTCTL2.h PERI_RSTCTL3.h PERI_RSTCTL4.h PERI_RTC.h PERI_SCT.h PERI_SDADC.h PERI_SEMA42.h PERI_SLEEPCON0.h PERI_SLEEPCON1.h PERI_SYSCON0.h PERI_SYSCON1.h PERI_SYSCON2.h PERI_SYSCON3.h PERI_SYSCON4.h PERI_SYSPM.h PERI_TRNG.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_UTICK.h PERI_WWDT.h PERI_XCACHE.h PERI_XSPI.h
  group startup
    ../../../../../../devices/MIMXRT798S/: startup_MIMXRT798S_cm33_core0.c
  group drivers
    ../../../../../../devices/MIMXRT798S/drivers/: fsl_clock.c fsl_clock.h fsl_edma_soc.c fsl_edma_soc.h fsl_iopctl.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_edma.h fsl_edma_core.h fsl_edma.c fsl_glikey.h fsl_glikey.c fsl_gpio.h fsl_gpio.c fsl_lpflexcomm.h fsl_lpflexcomm.c fsl_lpuart.h fsl_lpuart.c fsl_lpuart_edma.h fsl_lpuart_edma.c fsl_mrt.h fsl_mrt.c fsl_usdhc.c fsl_usdhc.h fsl_xspi.c fsl_xspi.h
  group utilities
    ../../../../../../devices/MIMXRT798S/utilities/debug_console/: fsl_assert.h fsl_assert.c
    ../../../../../../devices/MIMXRT798S/utilities/: fsl_memcpy.S
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group utilities/str
    ../../../../../../devices/MIMXRT798S/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console
    ../../../../../../devices/MIMXRT798S/utilities/debug_console/: fsl_debug_console.h fsl_debug_console.c
  group component/log
    ../../../../../../components/log/: fsl_component_log.h fsl_component_log.c fsl_component_log_config.h
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/button
    ../../../../../../components/button/: fsl_component_button.h fsl_component_button.c
  group component/common_task
    ../../../../../../components/common_task/: fsl_component_common_task.h fsl_component_common_task.c
  group component/gpio
    ../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_gpio.c
  group component/timer
    ../../../../../../components/timer/: fsl_adapter_timer.h fsl_adapter_mrt.c
  group component/timer_manager
    ../../../../../../components/timer_manager/: fsl_component_timer_manager.h fsl_component_timer_manager.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h
  group component/wifi_bt_module/AzureWave/tx_pwr_limits
    ../../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits/: wlan_txpwrlimit_cfg_WW.h wlan_txpwrlimit_cfg_WW_rw610.h
  group component/wifi_bt_module/Murata/tx_pwr_limits
    ../../../../../../components/wifi_bt_module/Murata/tx_pwr_limits/: wlan_txpwrlimit_cfg_murata_1XK_WW.h wlan_txpwrlimit_cfg_murata_1ZM_WW.h wlan_txpwrlimit_cfg_murata_2EL_WW.h wlan_txpwrlimit_cfg_murata_NH.h
  group component/wifi_bt_module/u-blox/tx_pwr_limits
    ../../../../../../components/wifi_bt_module/u-blox/tx_pwr_limits/: wlan_txpwrlimit_cfg_jody_w5_WW.h
  group component/wifi_bt_module/incl
    ../../../../../../components/wifi_bt_module/incl/: wifi_bt_module_config.h
  group component/els_pkc/doc/mimxrt/html
    ../../../../../../components/els_pkc/doc/mimxrt/html/: a00002.html a00002.js a00005.html a00005.js a00008.html a00008.js a00011.html a00011.js a00014.html a00014.js a00017.html a00017.js a00020.html a00020.js a00023.html a00023.js a00026.html a00026.js a00029.html a00029.js a00032.html a00032.js a00035.html a00035.js a00038.html a00038.js a00044.html a00044.js a00047.html a00047.js a00050.html a00050.js a00083.html a00083.js a00086.html a00086.js a00089.html a00092.html a00095.html a00098.html a00098.js a00101.html a00101.js a00104.html a00107.html a00110.html a00113.html a00116.html a00155.html a00155.js a00158.html a00158.js a00161.html a00161.js a00164.html a00164.js a00167.html a00167.js a00170.html a00170.js a00173.html a00173.js a00176.html a00176.js a00179.html a00179.js a00182.html a00182.js a00185.html a00185.js a00188.html a00188.js a00206.html a00206.js a00209.html a00209.js a00212.html a00212.js a00215.html a00215.js a00218.html a00218.js a00221.html a00221.js a00224.html a00224.js a00227.html a00227.js a00230.html a00230.js a00233.html a00233.js a00236.html a00236.js a00239.html a00239.js a00242.html a00242.js a00245.html a00245.js a00248.html a00248.js a00266.html a00266.js a00269.html a00269.js a00272.html a00272.js a00275.html a00275.js a00278.html a00278.js a00281.html a00281.js a00284.html a00284.js a00287.html a00287.js a00329.html a00329.js a00332.html a00332.js a00335.html a00335.js a00338_source.html a00341_source.html a00344.html a00344_source.html a00350.html a00350_source.html a00353_source.html a00356.html a00356.js a00356_source.html a00359.html a00359.js a00359_source.html a00362.html a00362.js a00362_source.html a00365.html a00365.js a00365_source.html a00368.html a00368_source.html a00371_source.html a00374.html a00374.js a00374_source.html a00377.html a00377.js a00377_source.html a00380.html a00380.js a00380_source.html a00383.html a00383.js a00383_source.html a00386.html a00386.js a00386_source.html a00389.html a00389_source.html a00392.html a00392.js a00392_source.html a00395.html a00395_source.html a00398_source.html a00401.html a00401.js a00401_source.html a00404.html a00404_source.html a00407.html a00407.js a00407_source.html a00410.html a00410.js a00410_source.html a00413_source.html a00416.html a00416.js a00416_source.html a00419.html a00419_source.html a00422_source.html a00425_source.html a00428.html a00428.js a00428_source.html a00431.html a00431_source.html a00434.html a00434.js a00434_source.html a00437.html a00437.js a00437_source.html a00440.html a00440.js a00440_source.html a00443.html a00443.js a00443_source.html a00446.html a00446_source.html a00449.html a00449.js a00449_source.html a00452.html a00452.js a00452_source.html a00455.html a00455.js a00455_source.html a00458.html a00458.js a00458_source.html a00461.html a00461.js a00461_source.html a00464.html a00464.js a00464_source.html a00467.html a00467.js a00467_source.html a00470.html a00470.js a00470_source.html a00473.html a00473.js a00473_source.html a00476.html a00476.js a00476_source.html a00479.html a00479.js a00479_source.html a00482.html a00482.js a00482_source.html a00485.html a00485.js a00485_source.html a00488_source.html a00491_source.html a00494_source.html a00497_source.html a00500_source.html a00503_source.html a00506.html a00506.js a00506_source.html a00509.html a00509_source.html a00512_source.html a00515.html a00515.js a00515_source.html a00518.html a00518.js a00518_source.html a00521_source.html a00524.html a00524.js a00524_source.html a00527.html a00527.js a00527_source.html a00530.html a00530.js a00530_source.html a00533_source.html a00536.html a00536.js a00536_source.html a00539.html a00539.js a00539_source.html a00542.html a00542.js a00542_source.html a00545.html a00545.js a00545_source.html a00548.html a00548_source.html a00551.html a00551.js a00551_source.html a00554.html a00554_source.html a00557.html a00557.js a00557_source.html a00560.html a00560.js a00560_source.html a00563.html a00563.js a00563_source.html a00566.html a00566.js a00566_source.html a00569.html a00569.js a00569_source.html a00572_source.html a00575.html a00575.js a00575_source.html a00578.html a00578_source.html a00581_source.html a00584.html a00584.js a00584_source.html a00587.html a00587_source.html a00590_source.html a00593.html a00593_source.html a00596.html a00596.js a00596_source.html a00599.html a00599.js a00599_source.html a00602.html a00602_source.html a00605.html a00605.js a00605_source.html a00608_source.html a00611.html a00611_source.html a00614.html a00614.js a00614_source.html a00617.html a00617.js a00617_source.html a00620.html a00620.js a00620_source.html a00623.html a00623.js a00623_source.html a00626.html a00626.js a00626_source.html a00629.html a00629.js a00629_source.html a00632.html a00632.js a00632_source.html a00635.html a00635.js a00635_source.html a00638.html a00638_source.html a00641.html a00641_source.html a00644.html a00644_source.html a00647.html a00647_source.html a00650_source.html a00653.html a00653_source.html a00656.html a00656_source.html a00659_source.html a00662.html a00662_source.html a00665.html a00665.js a00665_source.html a00668.html a00668.js a00668_source.html a00671.html a00671_source.html a00674.html a00674_source.html a00677.html a00677_source.html a00680.html a00680.js a00680_source.html a00683_source.html a00686.html a00686.js a00686_source.html a00689_source.html a00692_source.html a00695_source.html a00698.html a00698.js a00698_source.html a00701.html a00701_source.html a00704.html a00704_source.html a00707.html a00707_source.html a00710.html a00710.js a00710_source.html a00713.html a00713_source.html a00716.html a00716.js a00716_source.html a00719.html a00719.js a00719_source.html a00722.html a00722_source.html a00725.html a00725_source.html a00728.html a00728.js a00728_source.html a00731.html a00731_source.html a00734.html a00734.js a00734_source.html a00737.html a00737_source.html a00740.html a00740_source.html a00743.html a00743.js a00743_source.html a00746.html a00746.js a00746_source.html a00749.html a00749_source.html a00752.html a00752.js a00752_source.html a00755.html a00755.js a00755_source.html a00758.html a00758_source.html a00761.html a00761.js a00761_source.html a00764.html a00764.js a00764_source.html a00767.html a00767_source.html a00770.html a00770_source.html a00773.html a00773.js a00773_source.html a00776_source.html a00779_source.html a00782.html a00782.js a00782_source.html a00785.html a00785.js a00785_source.html a00788.html a00788.js a00788_source.html a00791.html a00791_source.html a00794.html a00794.js a00794_source.html a00797.html a00797.js a00797_source.html a00800.html a00800.js a00800_source.html a00803_source.html a00806.html a00806.js a00806_source.html a00809.html a00809_source.html a00812.html a00812.js a00812_source.html a00815.html a00815.js a00815_source.html a00818_source.html a00821_source.html a00824_source.html a00827_source.html a00830.html a00830.js a00830_source.html a00833_source.html a00836.html a00836_source.html a00839.html a00839.js a00839_source.html a00842.html a00842.js a00842_source.html a00845.html a00845_source.html a00848.html a00848.js a00848_source.html a00851.html a00851.js a00851_source.html a00854.html a00854.js a00854_source.html a00857.html a00857_source.html a00860.html a00860_source.html a00863.html a00863.js a00863_source.html a00866.html a00866.js a00866_source.html a00869.html a00869_source.html a00872.html a00872.js a00872_source.html a00875.html a00875.js a00875_source.html a00878.html a00878.js a00878_source.html a00881.html a00881.js a00881_source.html a00884.html a00884.js a00884_source.html a00887.html a00887.js a00887_source.html a00890.html a00890.js a00890_source.html a00893.html a00893.js a00893_source.html a00896.html a00896.js a00896_source.html a00899.html a00899_source.html a00902.html a00902.js a00902_source.html a00905.html a00905.js a00905_source.html a00908.html a00908.js a00908_source.html a00911_source.html a00914.html a00914.js a00914_source.html a00917.html a00917.js a00917_source.html a00920.html a00920.js a00920_source.html a00923.html a00923_source.html a00926.html a00926_source.html a00929.html a00929_source.html a00932.html a00932_source.html a00935.html a00935_source.html a00938.html a00938_source.html a00941.html a00941_source.html a00944.html a00944.js a00944_source.html a00947.html a00947.js a00947_source.html a00950.html a00950_source.html a00953.html a00953.js a00953_source.html a00956.html a00956_source.html a00959.html a00959_source.html a00970.html a00970.js a00971.html a00971.js a00972.html a00972.js a00973.html a00973.js a00974.html a00974.js a00975.html a00975.js a00976.html a00977.html a00977.js a00978.html a00978.js a00979.html a00979.js a00980.html a00980.js a00981.html a00981.js a00982.html a00982.js a00983.html a00983.js a00984.html a00984.js a00985.html a00985.js a00986.html a00987.html a00987.js a00988.html a00988.js a00989.html a00990.html a00991.html a00992.html a00992.js a00993.html a00993.js a00994.html a00994.js a00995.html a00995.js a00996.html a00996.js a00997.html a00997.js a00998.html a00998.js a00999.html a00999.js a01000.html a01000.js a01001.html a01001.js a01002.html a01002.js a01003.html a01004.html a01005.html a01005.js a01006.html a01006.js a01007.html a01007.js a01008.html a01008.js a01009.html a01009.js a01010.html a01010.js a01011.html a01011.js a01012.html a01012.js a01013.html a01013.js a01014.html a01014.js a01015.html a01015.js a01016.html a01016.js a01017.html a01017.js a01018.html a01018.js a01019.html a01019.js a01020.html a01020.js a01021.html a01021.js a01022.html a01022.js a01023.html a01023.js a01024.html a01024.js a01025.html a01025.js a01026.html a01026.js a01027.html a01027.js a01028.html a01028.js a01029.html a01029.js a01030.html a01030.js a01031.html a01031.js a01032.html a01032.js a01033.html a01033.js a01034.html a01034.js a01035.html a01035.js a01036.html a01036.js a01037.html a01037.js a01038.html a01038.js a01039.html a01039.js a01040.html a01040.js a01041.html a01041.js a01042.html a01042.js a01043.html a01043.js a01044.html a01044.js a01045.html a01045.js a01046.html a01046.js a01047.html a01047.js a01048.html a01048.js a01049.html a01049.js a01050.html a01050.js a01051.html a01051.js a01052.html a01052.js a01053.html a01053.js a01054.html a01054.js a01055.html a01055.js a01056.html a01056.js a01057.html a01057.js a01058.html a01058.js a01059.html a01059.js a01060.html a01060.js a01061.html a01061.js a01062.html a01062.js a01063.html a01063.js a01064.html a01064.js a01065.html a01065.js a01066.html a01066.js a01067.html a01067.js a01068.html a01068.js a01069.html a01069.js a01070.html a01070.js a01071.html a01071.js a01072.html a01072.js a01073.html a01073.js a01074.html a01074.js a01075.html a01075.js a01076.html a01076.js a01077.html a01077.js a01078.html a01078.js a01079.html a01079.js a01080.html a01080.js a01081.html a01081.js a01082.html a01082.js a01083.html a01083.js a01084.html a01084.js a01085.html a01085.js a01086.html a01086.js a01087.html a01087.js a01088.html a01088.js a01089.html a01089.js a01090.html a01090.js a01091.html a01091.js a01092.html a01092.js a01093.html a01093.js a01094.html a01094.js a01095.html a01095.js a01096.html a01096.js a01097.html a01097.js a01098.html a01098.js a01099.html a01099.js a01100.html a01101.html a01101.js a01102.html a01102.js a01103.html a01103.js a01104.html a01104.js a01105.html a01105.js a01106.html a01106.js a01107.html a01107.js a01108.html a01108.js a01109.html a01109.js a01110.html a01110.js a01111.html a01112.html a01112.js a01113.html a01113.js a01114.html a01114.js a01115.html a01115.js a01116.html a01116.js a01117.html a01117.js a01118.html a01119.html a01119.js a01120.html a01120.js a01121.html a01121.js a01122.html a01122.js a01123.html a01123.js a01124.html a01124.js a01125.html a01125.js a01126.html a01126.js a01127.html a01127.js a01128.html a01128.js a01129.html a01129.js a01130.html a01130.js a01131.html a01131.js a01132.html a01132.js a01133.html a01133.js a01134.html a01134.js a01135.html a01136.html a01137.html a01138.html a01138.js a01139.html a01139.js a01140.html a01140.js a01141.html a01142.html a01142.js a01143.html a01143.js a01144.html a01144.js a01145.html a01145.js a01146.html a01146.js a01147.html a01147.js a01148.html a01148.js a01149.html a01149.js a01150.html a01151.html a01152.html a01153.html a01153.js a01154.html a01154.js a01155.html a01155.js a01156.html a01156.js a01157.html a01157.js a01158.html a01158.js a01159.html a01159.js a01160.html a01160.js a01161.html a01161.js a01162.html a01162.js a01163.html a01163.js a01164.html a01164.js a01165.html a01165.js a01166.html a01167.html a01168.html a01169.html a01170.html a01170.js a01171.html a01171.js a01172.html a01172.js a01173.html a01173.js a01174.html a01174.js a01175.html a01176.html a01176.js a01177.html a01177.js a01178.html a01178.js a01179.html a01179.js a01180.html a01180.js a01181.html a01181.js a01182.html a01182.js a01183.html a01183.js a01184.html a01184.js a01185.html a01185.js a01186.html a01186.js a01187.html a01187.js a01188.html a01188.js a01189.html a01189.js a01190.html a01190.js a01191.html a01191.js a01192.html a01192.js a01193.html a01193.js a01194.html a01194.js a01195.html a01195.js a01196.html a01196.js a01197.html a01197.js a01198.html a01198.js a01199.html a01199.js a01200.html a01200.js a01201.html a01202.html a01202.js a01203.html a01203.js a01204.html a01204.js a01205.html a01205.js a01206.html a01206.js a01207.html a01207.js a01208.html a01208.js a01209.html a01209.js a01210.html a01210.js a01211.html a01211.js a01212.html a01212.js a01213.html a01213.js a01214.html a01214.js a01215.html a01215.js a01216.html a01216.js a01217.html a01217.js a01218.html a01218.js a01219.html a01219.js a01220.html a01220.js a01221.html a01221.js a01222.html a01222.js a01223.html a01223.js a01224.html a01224.js a01225.html a01225.js a01226.html a01226.js a01227.html a01227.js a01228.html a01228.js a01229.html a01229.js a01230.html a01230.js a01231.html a01231.js a01232.html a01232.js a01233.html a01233.js a01234.html a01234.js a01235.html a01235.js a01236.html a01236.js a01237.html a01237.js a01238.html a01238.js a01239.html a01239.js a01240.html a01240.js a01241.html a01241.js a01242.html a01242.js a01243.html a01243.js a01244.html a01244.js a01245.html a01245.js a01246.html a01246.js a01247.html a01247.js a01248.html a01248.js a01249.html a01249.js a01250.html a01250.js a01251.html a01252.html a01253.html a01254.html a01255.html a01256.html a01256.js a01257.html a01257.js a01258.html a01258.js a01259.html a01260.html a01260.js a01261.html a01261.js a01262.html a01262.js a01263.html a01263.js a01264.html a01264.js a01265.html a01265.js a01266.html a01267.html a01268.html a01269.html a01270.html a01271.html a01272.html a01273.html a01274.html a01275.html a01276.html a01277.html a01278.html a01279.html a01280.html a01281.html a01282.html a01283.html a01284.html a01285.html a01286.html a01287.html a01288.html a01289.html a01290.html a01291.html a01292.html a01293.html a01294.html a01295.html a01296.html a01297.html a01298.html a01298.js a01299.html a01299.js a01300.html a01301.html a01301.js a01302.html a01302.js a01303.html a01303.js a01304.html a01304.js a01305.html a01305.js a01306.html a01306.js a01307.html a01307.js a01308.html a01308.js a01309.html a01309.js a01310.html a01310.js a01311.html a01311.js a01312.html a01312.js a01313.html a01313.js a01314.html a01314.js a01315.html a01315.js a01316.html a01316.js a01317.html a01317.js a01318.html a01318.js a01319.html a01319.js a01320.html a01320.js a01321.html a01321.js a01325.html a01325.js a01329.html a01329.js a01333.html a01333.js a01337.html a01337.js a01341.html a01341.js a01345.html a01345.js a01357.html a01357.js a01369.html a01369.js a01381.html a01381.js a01393.html a01393.js a01405.html a01405.js a01417.html a01417.js a01429.html a01429.js a01441.html a01441.js a01453.html a01453.js a01465.html a01465.js a01477.html a01477.js a01489.html a01489.js a01501.html a01501.js a01513.html a01513.js a01525.html a01525.js a01537.html a01537.js a01549.html a01549.js a01561.html a01561.js a01573.html a01573.js a01585.html a01585.js a01597.html a01601.html a01601.js a01605.html a01609.html a01609.js a01613.html a01613.js a01617.html a01617.js a01621.html a01621.js a01625.html a01625.js a01629.html a01629.js a01633.html a01633.js a01637.html a01637.js a01638.html a01639.html a01640.html a01641.html a01642.html a01643.html a01644.html a01645.html a01646.html a01647.html a01648.html a01649.html a01650.html a01651.html a01652.html a01653.html a01654.html a01655.html a01656.html a01657.html a01658.html a01659.html a01660.html a01662.html a01663.html a01664.html a01665.html a01666.html a01667.html a01668.html a01669.html a01670.html a01671.html a01672.html a01673.html a01674.html a01675.html a01676.html a01677.html a01678.html a01679.html a01680.html a01681.html a01682.html a01683.html a01684.html a01685.html a01686.html annotated.html annotated_dup.js bc_s.png bc_sd.png classes.html closed.png dir_01728041b73b35212f9c70304fbd6941.html dir_01728041b73b35212f9c70304fbd6941.js dir_048916002fb1c65ba9d6be0a28513389.html dir_048916002fb1c65ba9d6be0a28513389.js dir_0797c94a3da61d3c30c38ad4bebd123e.html dir_0797c94a3da61d3c30c38ad4bebd123e.js dir_1bdd4212147753c6857c0181b7ff2c83.html dir_1d78cde6907429fc7ff3faa0e60e1934.html dir_1d78cde6907429fc7ff3faa0e60e1934.js dir_28d394395be6bc3a119407e2b960b555.html dir_28d394395be6bc3a119407e2b960b555.js dir_2eb425afb7d84500d7d3970f078e88fc.html dir_342d2a19aef8359edc7607760d6dc660.html dir_342d2a19aef8359edc7607760d6dc660.js dir_6bc0e71ed988cab81816d0ae80bcd053.html dir_6bc0e71ed988cab81816d0ae80bcd053.js dir_74e71b644c96d6e40d1ff18482a65c9e.html dir_74e71b644c96d6e40d1ff18482a65c9e.js dir_82a750f2c24be1f5a16cb4c1f565aee2.html dir_82a750f2c24be1f5a16cb4c1f565aee2.js dir_8cffc6cb708128322c9c72a5522018bb.html dir_93a3d8210c4daeaca4440151be6f086e.html dir_93a3d8210c4daeaca4440151be6f086e.js dir_960199fd2ed508bf6c2be3d0bebbc8bf.html dir_960199fd2ed508bf6c2be3d0bebbc8bf.js dir_9ece74090cf126cc8b2bfd98a6ff42cf.html dir_9f351d46ce3cc29445a41dc3a31e6919.html dir_a13d40520f8ae985d4d198cfc5d51e6a.html dir_a13d40520f8ae985d4d198cfc5d51e6a.js dir_b8182ea4e1b37372cef76e76561b1ea4.html dir_b8182ea4e1b37372cef76e76561b1ea4.js dir_ba0fb44945174e3a1dfee9a70216b8a3.html dir_ba0fb44945174e3a1dfee9a70216b8a3.js dir_bdcd83523a4251c9ada1d1bef5f265cd.html dir_cee807ca30de410121475dc4149d4f70.html dir_cf2e22cc336d983ff0a40174c32a781b.html dir_d3c412a3a9fc56c33ad18d5c7279a9f5.html dir_d3c412a3a9fc56c33ad18d5c7279a9f5.js dir_dc0d5cf89cffc2a09430f9942ae4ccc9.html dir_dc0d5cf89cffc2a09430f9942ae4ccc9.js dir_e84ed773fd520e7d80aa0f353515f48b.html dir_e84ed773fd520e7d80aa0f353515f48b.js dir_e96f948b0bc7224829512b9972af9922.html dir_e96f948b0bc7224829512b9972af9922.js dir_f46bfce375c7c9364cb686067c441ab2.html dir_fa7c90738c61d7024a5411d35b756043.html dir_fd7d019e50012d537437a082fa41cad3.html dir_fd7d019e50012d537437a082fa41cad3.js doc.svg docd.svg doxygen.css doxygen.svg dynsections.js examples.html examples.js files.html files_dup.js folderclosed.svg folderclosedd.svg folderopen.svg folderopend.svg functions.html functions_a.html functions_b.html functions_c.html functions_d.html functions_dup.js functions_e.html functions_f.html functions_g.html functions_h.html functions_i.html functions_k.html functions_l.html functions_m.html functions_o.html functions_p.html functions_q.html functions_r.html functions_s.html functions_t.html functions_u.html functions_v.html functions_vars.html functions_vars.js functions_vars_a.html functions_vars_b.html functions_vars_c.html functions_vars_d.html functions_vars_e.html functions_vars_f.html functions_vars_g.html functions_vars_h.html functions_vars_i.html functions_vars_k.html functions_vars_l.html functions_vars_m.html functions_vars_o.html functions_vars_p.html functions_vars_q.html functions_vars_r.html functions_vars_s.html functions_vars_t.html functions_vars_u.html functions_vars_v.html functions_vars_w.html functions_w.html globals.html globals_a.html globals_d.html globals_defs.html globals_defs.js globals_defs_i.html globals_defs_m.html globals_defs_r.html globals_defs_s.html globals_defs_u.html globals_dup.js globals_e.html globals_func.html globals_func.js globals_func_m.html globals_g.html globals_i.html globals_m.html globals_p.html globals_r.html globals_s.html globals_type.html globals_u.html globals_vars.html globals_vars.js globals_vars_d.html globals_vars_e.html globals_vars_g.html globals_vars_m.html globals_vars_p.html globals_vars_r.html globals_vars_s.html index.html index.js jquery.js modules.html modules.js nav_f.png nav_fd.png nav_g.png nav_h.png nav_hd.png navtree.css navtree.js navtreedata.js navtreeindex0.js navtreeindex1.js navtreeindex10.js navtreeindex11.js navtreeindex2.js navtreeindex3.js navtreeindex4.js navtreeindex5.js navtreeindex6.js navtreeindex7.js navtreeindex8.js navtreeindex9.js open.png pages.html resize.js splitbar.png splitbard.png sync_off.png sync_on.png tab_a.png tab_ad.png tab_b.png tab_bd.png tab_h.png tab_hd.png tab_s.png tab_sd.png tabs.css
  group component/els_pkc/doc/mimxrt/html/search
    ../../../../../../components/els_pkc/doc/mimxrt/html/search/: all_0.js all_1.js all_10.js all_11.js all_12.js all_13.js all_14.js all_15.js all_2.js all_3.js all_4.js all_5.js all_6.js all_7.js all_8.js all_9.js all_a.js all_b.js all_c.js all_d.js all_e.js all_f.js classes_0.js close.svg defines_0.js defines_1.js defines_2.js defines_3.js files_0.js functions_0.js functions_1.js groups_0.js groups_1.js groups_2.js groups_3.js groups_4.js groups_5.js groups_6.js groups_7.js groups_8.js groups_9.js groups_a.js groups_b.js groups_c.js groups_d.js mag.svg mag_d.svg mag_sel.svg mag_seld.svg pages_0.js pages_1.js search.css search.js searchdata.js typedefs_0.js variables_0.js variables_1.js variables_10.js variables_11.js variables_12.js variables_13.js variables_14.js variables_15.js variables_2.js variables_3.js variables_4.js variables_5.js variables_6.js variables_7.js variables_8.js variables_9.js variables_a.js variables_b.js variables_c.js variables_d.js variables_e.js variables_f.js
  group component/els_pkc
    ../../../../../../components/els_pkc/: LICENSE.txt softwareContentRegister.txt ReleaseNotes.txt
  group component/els_pkc/static_library/mimxrt
    ../../../../../../components/els_pkc/static_library/mimxrt/: libclns.a libclns.a.libsize libclns.a.objsize
  group component/els_pkc/src/comps/common/src
    ../../../../../../components/els_pkc/src/comps/common/src/: mcuxClOscca_CommonOperations.c
  group component/els_pkc/src/comps/common/inc
    ../../../../../../components/els_pkc/src/comps/common/inc/: mcuxClOscca_FunctionIdentifiers.h mcuxClOscca_Memory.h mcuxClOscca_PlatformTypes.h mcuxClOscca_Types.h
  group component/els_pkc/src/comps/mcuxClAead/src
    ../../../../../../components/els_pkc/src/comps/mcuxClAead/src/: mcuxClAead.c
  group component/els_pkc/src/comps/mcuxClAead/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClAead/inc/: mcuxClAead.h mcuxClAead_Constants.h mcuxClAead_Functions.h mcuxClAead_Types.h
  group component/els_pkc/src/comps/mcuxClAead/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClAead/inc/internal/: mcuxClAead_Ctx.h mcuxClAead_Descriptor.h mcuxClAead_Internal_Functions.h
  group component/els_pkc/src/comps/mcuxClAeadModes/src
    ../../../../../../components/els_pkc/src/comps/mcuxClAeadModes/src/: mcuxClAeadModes_Els_AesCcm.c mcuxClAeadModes_Els_AesCcmEngine.c mcuxClAeadModes_Els_AesGcm.c mcuxClAeadModes_Els_AesGcmEngine.c mcuxClAeadModes_Els_Modes.c mcuxClAeadModes_Els_Multipart.c mcuxClAeadModes_Els_Oneshot.c
  group component/els_pkc/src/comps/mcuxClAeadModes/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClAeadModes/inc/: mcuxClAeadModes.h mcuxClAeadModes_Modes.h
  group component/els_pkc/src/comps/mcuxClAeadModes/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClAeadModes/inc/internal/: mcuxClAeadModes_Common.h mcuxClAeadModes_Common_Constants.h mcuxClAeadModes_Common_Functions.h mcuxClAeadModes_Els_Algorithms.h mcuxClAeadModes_Els_Functions.h mcuxClAeadModes_Els_Types.h
  group component/els_pkc/src/comps/mcuxClAes/src
    ../../../../../../components/els_pkc/src/comps/mcuxClAes/src/: mcuxClAes_KeyTypes.c
  group component/els_pkc/src/comps/mcuxClAes/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClAes/inc/: mcuxClAes.h mcuxClAes_Constants.h mcuxClAes_KeyTypes.h mcuxClAes_Types.h
  group component/els_pkc/src/comps/mcuxClAes/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClAes/inc/internal/: mcuxClAes_Ctx.h mcuxClAes_Internal_Constants.h mcuxClAes_Internal_Functions.h mcuxClAes_Wa.h
  group component/els_pkc/src/comps/mcuxClBuffer/src
    ../../../../../../components/els_pkc/src/comps/mcuxClBuffer/src/: mcuxClBuffer.c
  group component/els_pkc/src/comps/mcuxClBuffer/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/: mcuxClBuffer.h mcuxClBuffer_Cfg.h mcuxClBuffer_Constants.h mcuxClBuffer_Impl.h mcuxClBuffer_Pointer.h
  group component/els_pkc/src/comps/mcuxClBuffer/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/internal/: mcuxClBuffer_Internal.h mcuxClBuffer_Internal_Pointer.h
  group component/els_pkc/src/comps/mcuxClCipher/src
    ../../../../../../components/els_pkc/src/comps/mcuxClCipher/src/: mcuxClCipher.c
  group component/els_pkc/src/comps/mcuxClCipher/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClCipher/inc/: mcuxClCipher.h mcuxClCipher_Constants.h mcuxClCipher_Functions.h mcuxClCipher_Types.h
  group component/els_pkc/src/comps/mcuxClCipher/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClCipher/inc/internal/: mcuxClCipher_Internal.h mcuxClCipher_Internal_Constants.h mcuxClCipher_Internal_Functions.h mcuxClCipher_Internal_Types.h
  group component/els_pkc/src/comps/mcuxClCipherModes/src
    ../../../../../../components/els_pkc/src/comps/mcuxClCipherModes/src/: mcuxClCipherModes_Common_Helper.c mcuxClCipherModes_Crypt_Els_Modes.c mcuxClCipherModes_Els_Aes.c mcuxClCipherModes_Els_AesEngine.c mcuxClCipherModes_Els_Aes_Internal.c
  group component/els_pkc/src/comps/mcuxClCipherModes/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClCipherModes/inc/: mcuxClCipherModes.h mcuxClCipherModes_Modes.h
  group component/els_pkc/src/comps/mcuxClCipherModes/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClCipherModes/inc/internal/: mcuxClCipherModes_Common.h mcuxClCipherModes_Common_Constants.h mcuxClCipherModes_Common_Helper.h mcuxClCipherModes_Common_Wa.h mcuxClCipherModes_Els_Algorithms.h mcuxClCipherModes_Els_Functions.h mcuxClCipherModes_Els_Types.h
  group component/els_pkc/src/comps/mcuxClCore/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClCore/inc/: mcuxClCore_Examples.h mcuxClCore_FunctionIdentifiers.h mcuxClCore_Macros.h mcuxClCore_Platform.h mcuxClCore_Toolchain.h
  group component/els_pkc/src/comps/mcuxClCrc/src
    ../../../../../../components/els_pkc/src/comps/mcuxClCrc/src/: mcuxClCrc.c mcuxClCrc_Sw.c
  group component/els_pkc/src/comps/mcuxClCrc/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClCrc/inc/: mcuxClCrc.h
  group component/els_pkc/src/comps/mcuxClCrc/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClCrc/inc/internal/: mcuxClCrc_Internal_Constants.h mcuxClCrc_Internal_Functions.h
  group component/els_pkc/src/comps/mcuxClEcc/src
    ../../../../../../components/els_pkc/src/comps/mcuxClEcc/src/: mcuxClEcc_Constants.c mcuxClEcc_ECDSA_GenerateProtocolDescriptor.c mcuxClEcc_ECDSA_Internal_BlindedSecretKeyGen.c mcuxClEcc_ECDSA_Internal_BlindedSecretKeyGen_FUP.c mcuxClEcc_EdDSA_GenerateKeyPair.c mcuxClEcc_EdDSA_GenerateKeyPair_FUP.c mcuxClEcc_EdDSA_GenerateSignature.c mcuxClEcc_EdDSA_GenerateSignatureMode.c mcuxClEcc_EdDSA_GenerateSignature_FUP.c mcuxClEcc_EdDSA_InitPrivKeyInputMode.c mcuxClEcc_EdDSA_Internal_CalcHashModN.c mcuxClEcc_EdDSA_Internal_CalcHashModN_FUP.c mcuxClEcc_EdDSA_Internal_DecodePoint_Ed25519.c mcuxClEcc_EdDSA_Internal_DecodePoint_FUP.c mcuxClEcc_EdDSA_Internal_EncodePoint.c mcuxClEcc_EdDSA_Internal_SetupEnvironment.c mcuxClEcc_EdDSA_Internal_SignatureMechanisms.c mcuxClEcc_EdDSA_VerifySignature.c mcuxClEcc_Internal_BlindedScalarMult.c mcuxClEcc_Internal_Convert_FUP.c mcuxClEcc_Internal_GenerateMultiplicativeBlinding.c mcuxClEcc_Internal_InterleaveScalar.c mcuxClEcc_Internal_InterleaveTwoScalars.c mcuxClEcc_Internal_Interleave_FUP.c mcuxClEcc_Internal_PointComparison_FUP.c mcuxClEcc_Internal_RecodeAndReorderScalar.c mcuxClEcc_Internal_SetupEnvironment.c mcuxClEcc_Internal_SetupEnvironment_FUP.c mcuxClEcc_Internal_Types.c mcuxClEcc_KeyTypes.c mcuxClEcc_MontDH_GenerateKeyPair.c mcuxClEcc_MontDH_KeyAgreement.c mcuxClEcc_Mont_Internal_DhSetupEnvironment.c mcuxClEcc_Mont_Internal_MontDhX.c mcuxClEcc_Mont_Internal_MontDhX_FUP.c mcuxClEcc_Mont_Internal_SecureScalarMult_XZMontLadder.c mcuxClEcc_Mont_Internal_SecureScalarMult_XZMontLadder_FUP.c mcuxClEcc_TwEd_Internal_FixScalarMult.c mcuxClEcc_TwEd_Internal_PlainFixScalarMult25519.c mcuxClEcc_TwEd_Internal_PlainPtrSelectComb.c mcuxClEcc_TwEd_Internal_PlainPtrSelectML.c mcuxClEcc_TwEd_Internal_PlainVarScalarMult.c mcuxClEcc_TwEd_Internal_PointArithmetic.c mcuxClEcc_TwEd_Internal_PointArithmetic_FUP.c mcuxClEcc_TwEd_Internal_PointArithmeticEd25519.c mcuxClEcc_TwEd_Internal_PointArithmeticEd25519_FUP.c mcuxClEcc_TwEd_Internal_PointSubtraction_FUP.c mcuxClEcc_TwEd_Internal_PointValidation_FUP.c mcuxClEcc_TwEd_Internal_PrecPointImportAndValidate.c mcuxClEcc_TwEd_Internal_VarScalarMult.c mcuxClEcc_TwEd_Internal_VarScalarMult_FUP.c mcuxClEcc_WeierECC_Internal_BlindedSecretKeyGen.c mcuxClEcc_WeierECC_Internal_BlindedSecretKeyGen_FUP.c mcuxClEcc_WeierECC_Internal_GenerateKeyPair.c mcuxClEcc_WeierECC_Internal_SetupEnvironment.c mcuxClEcc_Weier_Internal_ConvertPoint_FUP.c mcuxClEcc_Weier_Internal_FUP.c mcuxClEcc_Weier_Internal_PointArithmetic.c mcuxClEcc_Weier_Internal_PointArithmetic_FUP.c mcuxClEcc_Weier_Internal_PointCheck.c mcuxClEcc_Weier_Internal_PointCheck_FUP.c mcuxClEcc_Weier_Internal_PointMult.c mcuxClEcc_Weier_Internal_SecurePointMult_CoZMontLadder.c mcuxClEcc_Weier_Internal_SecurePointMult_CoZMontLadder_FUP.c mcuxClEcc_Weier_Internal_SetupEnvironment.c mcuxClEcc_Weier_KeyGen.c mcuxClEcc_Weier_KeyGen_FUP.c mcuxClEcc_Weier_PointMult.c mcuxClEcc_Weier_PointMult_FUP.c mcuxClEcc_Weier_Sign.c mcuxClEcc_Weier_Sign_FUP.c mcuxClEcc_Weier_Verify.c mcuxClEcc_Weier_Verify_FUP.c
  group component/els_pkc/src/comps/mcuxClEcc/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClEcc/inc/: mcuxClEcc.h mcuxClEcc_Constants.h mcuxClEcc_EdDSA_GenerateKeyPair_FUP.h mcuxClEcc_EdDSA_GenerateSignature_FUP.h mcuxClEcc_EdDSA_Internal_CalcHashModN_FUP.h mcuxClEcc_EdDSA_Internal_DecodePoint_FUP.h mcuxClEcc_Functions.h mcuxClEcc_Internal_Convert_FUP.h mcuxClEcc_Internal_Interleave_FUP.h mcuxClEcc_Internal_PointComparison_FUP.h mcuxClEcc_Internal_SetupEnvironment_FUP.h mcuxClEcc_KeyTypes.h mcuxClEcc_Mont_Internal_MontDhX_FUP.h mcuxClEcc_Mont_Internal_SecureScalarMult_XZMontLadder_FUP.h mcuxClEcc_TwEd_Internal_PointArithmeticEd25519_FUP.h mcuxClEcc_TwEd_Internal_PointSubtraction_FUP.h mcuxClEcc_TwEd_Internal_PointArithmetic_FUP.h mcuxClEcc_TwEd_Internal_PointValidation_FUP.h mcuxClEcc_TwEd_Internal_VarScalarMult_FUP.h mcuxClEcc_Types.h mcuxClEcc_WeierECC_Internal_BlindedSecretKeyGen_FUP.h mcuxClEcc_Weier_Internal_ConvertPoint_FUP.h mcuxClEcc_Weier_Internal_FUP.h mcuxClEcc_Weier_Internal_PointArithmetic_FUP.h mcuxClEcc_Weier_Internal_PointCheck_FUP.h mcuxClEcc_Weier_Internal_SecurePointMult_CoZMontLadder_FUP.h mcuxClEcc_Weier_KeyGen_FUP.h mcuxClEcc_Weier_PointMult_FUP.h mcuxClEcc_Weier_Sign_FUP.h mcuxClEcc_Weier_Verify_FUP.h
  group component/els_pkc/src/comps/mcuxClEcc/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClEcc/inc/internal/: mcuxClEcc_ECDH_Internal.h mcuxClEcc_ECDSA_Internal.h mcuxClEcc_ECDSA_Internal_FUP.h mcuxClEcc_EdDSA_Internal.h mcuxClEcc_EdDSA_Internal_FUP.h mcuxClEcc_EdDSA_Internal_Hash.h mcuxClEcc_Internal.h mcuxClEcc_Internal_FUP.h mcuxClEcc_Internal_PkcWaLayout.h mcuxClEcc_Internal_Random.h mcuxClEcc_Internal_SecurePointSelect.h mcuxClEcc_Internal_UPTRT_access.h mcuxClEcc_Mont_Internal.h mcuxClEcc_Mont_Internal_FUP.h mcuxClEcc_Mont_Internal_PkcWaLayout.h mcuxClEcc_TwEd_Internal.h mcuxClEcc_TwEd_Internal_FUP.h mcuxClEcc_TwEd_Internal_PkcWaLayout.h mcuxClEcc_WeierEcc_KeyGenerate_Internal.h mcuxClEcc_Weier_Internal.h mcuxClEcc_Weier_Internal_FP.h mcuxClEcc_Weier_Internal_FUP.h mcuxClEcc_Weier_Internal_PkcWaLayout.h
  group component/els_pkc/src/comps/mcuxClEls/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClEls/inc/: mcuxClEls.h mcuxClEls_Aead.h mcuxClEls_Cipher.h mcuxClEls_Cmac.h mcuxClEls_Crc.h mcuxClEls_Ecc.h mcuxClEls_Hash.h mcuxClEls_Hmac.h mcuxClEls_Kdf.h mcuxClEls_mapping.h mcuxClEls_Rng.h mcuxClEls_Types.h mcuxClEls_KeyManagement.h mcuxClEls_Common.h
  group component/els_pkc/src/comps/mcuxClEls/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClEls/inc/internal/: mcuxClEls_Internal.h mcuxClEls_Internal_mapping.h mcuxClEls_SfrAccess.h mcuxClEls_Internal_Common.h
  group component/els_pkc/src/comps/mcuxClEls/src
    ../../../../../../components/els_pkc/src/comps/mcuxClEls/src/: mcuxClEls_Common.c mcuxClEls_Aead.c mcuxClEls_Cipher.c mcuxClEls_Cmac.c mcuxClEls_Ecc.c mcuxClEls_Hash.c mcuxClEls_Hmac.c mcuxClEls_Kdf.c mcuxClEls_Rng.c mcuxClEls_KeyManagement.c
  group component/els_pkc/src/comps/mcuxClGlikey/src
    ../../../../../../components/els_pkc/src/comps/mcuxClGlikey/src/: mcuxClGlikey.c
  group component/els_pkc/src/comps/mcuxClGlikey/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClGlikey/inc/: mcuxClGlikey.h
  group component/els_pkc/src/comps/mcuxClGlikey/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClGlikey/inc/internal/: mcuxClGlikey_SfrAccess.h
  group component/els_pkc/src/comps/mcuxClHash/src
    ../../../../../../components/els_pkc/src/comps/mcuxClHash/src/: mcuxClHash_api_multipart_common.c mcuxClHash_api_multipart_compute.c mcuxClHash_api_oneshot_compute.c mcuxClHash_Internal.c
  group component/els_pkc/src/comps/mcuxClHash/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClHash/inc/: mcuxClHash.h mcuxClHash_Constants.h mcuxClHash_Functions.h mcuxClHash_Types.h
  group component/els_pkc/src/comps/mcuxClHash/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClHash/inc/internal/: mcuxClHash_Internal.h mcuxClHash_Internal_Memory.h
  group component/els_pkc/src/comps/mcuxClHashModes/src
    ../../../../../../components/els_pkc/src/comps/mcuxClHashModes/src/: mcuxClHashModes_Core_c_sha1.c mcuxClHashModes_Core_els_sha2.c mcuxClHashModes_Internal_c_sha1.c mcuxClHashModes_Internal_els_sha2.c
  group component/els_pkc/src/comps/mcuxClHashModes/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClHashModes/inc/: mcuxClHashModes.h mcuxClHashModes_Algorithms.h mcuxClHashModes_Constants.h mcuxClHashModes_Functions.h
  group component/els_pkc/src/comps/mcuxClHashModes/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClHashModes/inc/internal/: mcuxClHashModes_Core_c_sha1.h mcuxClHashModes_Core_els_sha2.h mcuxClHashModes_Internal.h mcuxClHashModes_Internal_els_sha2.h mcuxClHashModes_Internal_Memory.h
  group component/els_pkc/src/comps/mcuxClHmac/src
    ../../../../../../components/els_pkc/src/comps/mcuxClHmac/src/: mcuxClHmac_Els.c mcuxClHmac_Functions.c mcuxClHmac_Helper.c mcuxClHmac_KeyTypes.c mcuxClHmac_Modes.c mcuxClHmac_Sw.c
  group component/els_pkc/src/comps/mcuxClHmac/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClHmac/inc/: mcuxClHmac.h mcuxClHmac_Constants.h mcuxClHmac_Functions.h mcuxClHmac_KeyTypes.h mcuxClHmac_Modes.h
  group component/els_pkc/src/comps/mcuxClHmac/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClHmac/inc/internal/: mcuxClHmac_Core_Functions_Els.h mcuxClHmac_Core_Functions_Sw.h mcuxClHmac_Internal_Functions.h mcuxClHmac_Internal_Memory.h mcuxClHmac_Internal_Types.h
  group component/els_pkc/src/comps/mcuxClKey/src
    ../../../../../../components/els_pkc/src/comps/mcuxClKey/src/: mcuxClKey_agreement.c mcuxClKey_agreement_selftest.c mcuxClKey_Derivation.c mcuxClKey_Derivation_HKDF.c mcuxClKey_Derivation_NIST_SP800_108.c mcuxClKey_Derivation_NIST_SP800_56C.c mcuxClKey_Derivation_PBKDF2.c mcuxClKey_generate_keypair.c mcuxClKey.c mcuxClKey_Protection.c
  group component/els_pkc/src/comps/mcuxClKey/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClKey/inc/: mcuxClKey_DerivationAlgorithms.h mcuxClKey_DerivationAlgorithms_HKDF.h mcuxClKey_DerivationAlgorithms_NIST_SP800_108.h mcuxClKey_DerivationAlgorithms_NIST_SP800_56C.h mcuxClKey_DerivationAlgorithms_PBKDF2.h mcuxClKey.h mcuxClKey_Constants.h mcuxClKey_Functions.h mcuxClKey_ProtectionMechanisms.h mcuxClKey_Types.h
  group component/els_pkc/src/comps/mcuxClKey/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClKey/inc/internal/: mcuxClKey_Derivation_Helper.h mcuxClKey_DerivationAlgorithms_NIST_SP800_108_Internal.h mcuxClKey_Functions_Internal.h mcuxClKey_Internal.h mcuxClKey_Protection_Internal.h mcuxClKey_Types_Internal.h
  group component/els_pkc/src/comps/mcuxClMac/src
    ../../../../../../components/els_pkc/src/comps/mcuxClMac/src/: mcuxClMac.c
  group component/els_pkc/src/comps/mcuxClMac/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClMac/inc/: mcuxClMac.h mcuxClMac_Constants.h mcuxClMac_Functions.h mcuxClMac_Types.h
  group component/els_pkc/src/comps/mcuxClMac/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClMac/inc/internal/: mcuxClMac_Ctx.h mcuxClMac_Internal_Constants.h mcuxClMac_Internal_Functions.h mcuxClMac_Internal_Types.h
  group component/els_pkc/src/comps/mcuxClMacModes/src
    ../../../../../../components/els_pkc/src/comps/mcuxClMacModes/src/: mcuxClMacModes_Common.c mcuxClMacModes_Common_Modes.c mcuxClMacModes_Els_Cbcmac.c mcuxClMacModes_Els_Cmac.c mcuxClMacModes_Els_Functions.c
  group component/els_pkc/src/comps/mcuxClMacModes/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClMacModes/inc/: mcuxClMacModes.h mcuxClMacModes_Constants.h mcuxClMacModes_Functions.h mcuxClMacModes_Modes.h
  group component/els_pkc/src/comps/mcuxClMacModes/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClMacModes/inc/internal/: mcuxClMacModes_Common_Algorithms.h mcuxClMacModes_Common_Constants.h mcuxClMacModes_Common_Functions.h mcuxClMacModes_Common_Memory.h mcuxClMacModes_Common_Types.h mcuxClMacModes_Common_Wa.h mcuxClMacModes_Els_Cbcmac.h mcuxClMacModes_Els_Cmac.h mcuxClMacModes_Els_Ctx.h mcuxClMacModes_Els_Types.h
  group component/els_pkc/src/comps/mcuxClMath/src
    ../../../../../../components/els_pkc/src/comps/mcuxClMath/src/: mcuxClMath_ExactDivide.c mcuxClMath_ExactDivideOdd.c mcuxClMath_ExactDivideOdd_FUP.c mcuxClMath_ModExp_SqrMultL2R.c mcuxClMath_ModInv.c mcuxClMath_ModInv_FUP.c mcuxClMath_NDash.c mcuxClMath_NDash_FUP.c mcuxClMath_QDash.c mcuxClMath_QDash_FUP.c mcuxClMath_ReduceModEven.c mcuxClMath_SecModExp.c mcuxClMath_SecModExp_FUP.c mcuxClMath_Utils.c
  group component/els_pkc/src/comps/mcuxClMath/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClMath/inc/: mcuxClMath.h mcuxClMath_ExactDivideOdd_FUP.h mcuxClMath_Functions.h mcuxClMath_ModInv_FUP.h mcuxClMath_NDash_FUP.h mcuxClMath_QDash_FUP.h mcuxClMath_SecModExp_FUP.h mcuxClMath_Types.h
  group component/els_pkc/src/comps/mcuxClMath/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClMath/inc/internal/: mcuxClMath_ExactDivideOdd_FUP.h mcuxClMath_Internal_ExactDivideOdd.h mcuxClMath_Internal_ModInv.h mcuxClMath_Internal_NDash.h mcuxClMath_Internal_QDash.h mcuxClMath_Internal_SecModExp.h mcuxClMath_Internal_Utils.h mcuxClMath_ModInv_FUP.h mcuxClMath_NDash_FUP.h mcuxClMath_QDash_FUP.h mcuxClMath_SecModExp_FUP.h
  group component/els_pkc/src/comps/mcuxClMemory/src
    ../../../../../../components/els_pkc/src/comps/mcuxClMemory/src/: mcuxClMemory.c
  group component/els_pkc/src/comps/mcuxClMemory/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/: mcuxClMemory.h mcuxClMemory_Clear.h mcuxClMemory_Constants.h mcuxClMemory_Copy.h mcuxClMemory_Copy_Reversed.h mcuxClMemory_Endianness.h mcuxClMemory_Set.h mcuxClMemory_Types.h mcuxClMemory_Xor.h
  group component/els_pkc/src/comps/mcuxClMemory/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/internal/: mcuxClMemory_Internal.h
  group component/els_pkc/src/comps/mcuxCsslMemory/src
    ../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/src/: mcuxCsslMemory_Clear.c mcuxCsslMemory_Compare.c mcuxCsslMemory_Copy.c mcuxCsslMemory_Set.c
  group component/els_pkc/src/comps/mcuxCsslMemory/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/: mcuxCsslMemory.h mcuxCsslMemory_Clear.h mcuxCsslMemory_Compare.h mcuxCsslMemory_Constants.h mcuxCsslMemory_Copy.h mcuxCsslMemory_Set.h mcuxCsslMemory_Types.h
  group component/els_pkc/src/comps/mcuxCsslMemory/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/internal/: mcuxCsslMemory_Internal_Compare_asm.h mcuxCsslMemory_Internal_Copy_asm.h
  group component/els_pkc/src/comps/mcuxClOsccaAeadModes/src
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaAeadModes/src/: mcuxClOsccaAeadModes_Ccm_Common.c mcuxClOsccaAeadModes_Constants.c mcuxClOsccaAeadModes_EngineCcm.c mcuxClOsccaAeadModes_SkeletonCcm.c mcuxClOsccaAeadModes_SM4Ctr.c mcuxClOsccaAeadModes_SM4_Multipart.c mcuxClOsccaAeadModes_SM4_OneShot.c
  group component/els_pkc/src/comps/mcuxClOsccaAeadModes/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaAeadModes/inc/: mcuxClOsccaAeadModes.h mcuxClOsccaAeadModes_Modes.h
  group component/els_pkc/src/comps/mcuxClOsccaAeadModes/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaAeadModes/inc/internal/: mcuxClOsccaAeadModes_Internal_Algorithms.h mcuxClOsccaAeadModes_Internal_Functions.h mcuxClOsccaAeadModes_Internal_Types.h
  group component/els_pkc/src/comps/mcuxClOsccaCipherModes/src
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaCipherModes/src/: mcuxClOsccaCipherModes_Constants.c mcuxClOsccaCipherModes_SM4_Crypt.c mcuxClOsccaCipherModes_SM4_Crypt_Internal.c
  group component/els_pkc/src/comps/mcuxClOsccaCipherModes/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaCipherModes/inc/: mcuxClOsccaCipherModes.h mcuxClOsccaCipherModes_Constants.h
  group component/els_pkc/src/comps/mcuxClOsccaCipherModes/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaCipherModes/inc/internal/: mcuxClOsccaCipherModes_Algorithms.h mcuxClOsccaCipherModes_Internal_Functions.h mcuxClOsccaCipherModes_Internal_Types.h
  group component/els_pkc/src/comps/mcuxClOsccaMacModes/src
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaMacModes/src/: mcuxClOsccaMacModes.c mcuxClOsccaMacModes_CBCMac.c mcuxClOsccaMacModes_CMac.c mcuxClOsccaMacModes_Helper.c mcuxClOsccaMacModes_KeyTypes.c mcuxClOsccaMacModes_Modes.c
  group component/els_pkc/src/comps/mcuxClOsccaMacModes/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaMacModes/inc/: mcuxClOsccaMacModes.h mcuxClOsccaMacModes_Constants.h mcuxClOsccaMacModes_KeyTypes.h mcuxClOsccaMacModes_Modes.h
  group component/els_pkc/src/comps/mcuxClOsccaMacModes/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaMacModes/inc/internal/: mcuxClOsccaMacModes_Algorithms.h mcuxClOsccaMacModes_Ctx.h mcuxClOsccaMacModes_Internal_Functions.h mcuxClOsccaMacModes_SM4_CBCMAC.h mcuxClOsccaMacModes_SM4_CMAC.h mcuxClOsccaMacModes_Types.h
  group component/els_pkc/src/comps/mcuxClOsccaPkc/src
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaPkc/src/: mcuxClOsccaPkc.c
  group component/els_pkc/src/comps/mcuxClOsccaPkc/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaPkc/inc/: mcuxClOsccaPkc.h mcuxClOsccaPkc_Functions.h mcuxClOsccaPkc_Types.h
  group component/els_pkc/src/comps/mcuxClOsccaPkc/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaPkc/inc/internal/: mcuxClOsccaPkc_FupMacros.h mcuxClOsccaPkc_Macros.h mcuxClOsccaPkc_Operations.h mcuxClOsccaPkc_SfrAccess.h
  group component/els_pkc/src/comps/mcuxClOsccaRandomModes/src
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaRandomModes/src/: mcuxClOsccaRandomModes_OsccaMode.c
  group component/els_pkc/src/comps/mcuxClOsccaRandomModes/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaRandomModes/inc/: mcuxClOsccaRandomModes.h mcuxClOsccaRandomModes_Constants.h
  group component/els_pkc/src/comps/mcuxClOsccaRandomModes/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaRandomModes/inc/internal/: mcuxClOsccaRandomModes_Private_RNG.h mcuxClOsccaRandomModes_Private_Types.h mcuxClOsccaRandomModes_SfrAccess.h
  group component/els_pkc/src/comps/mcuxClOsccaSafo/src
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaSafo/src/: mcuxClOsccaSafo_Drv.c
  group component/els_pkc/src/comps/mcuxClOsccaSafo/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaSafo/inc/: mcuxClOsccaSafo.h mcuxClOsccaSafo_Constants.h mcuxClOsccaSafo_Functions.h mcuxClOsccaSafo_SfrAccess.h mcuxClOsccaSafo_Sfr_Ctrl.h mcuxClOsccaSafo_Sfr_RegBank.h mcuxClOsccaSafo_Sfr_Status.h mcuxClOsccaSafo_Types.h
  group component/els_pkc/src/comps/mcuxClOsccaSm2/src
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm2/src/: mcuxClOsccaSm2_Cipher_Crypt.c mcuxClOsccaSm2_ComputePrehash.c mcuxClOsccaSm2_Constants.c mcuxClOsccaSm2_CryptoUtils.c mcuxClOsccaSm2_Decrypt.c mcuxClOsccaSm2_Ecc.c mcuxClOsccaSm2_EccUtils.c mcuxClOsccaSm2_EncDec_Internal.c mcuxClOsccaSm2_Encrypt.c mcuxClOsccaSm2_FUP.c mcuxClOsccaSm2_GenerateKeyPair.c mcuxClOsccaSm2_Helper.c mcuxClOsccaSm2_InvertPrivateKey.c mcuxClOsccaSm2_Keyagreement.c mcuxClOsccaSm2_Keyagreement_SelfTest.c mcuxClOsccaSm2_KeyExchange.c mcuxClOsccaSm2_KeyTypes.c mcuxClOsccaSm2_SelfTest.c mcuxClOsccaSm2_Sign.c mcuxClOsccaSm2_Signature_Internal.c mcuxClOsccaSm2_Signature_PreHash.c mcuxClOsccaSm2_Signature_SelfTest.c mcuxClOsccaSm2_Verify.c
  group component/els_pkc/src/comps/mcuxClOsccaSm2/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm2/inc/: mcuxClOsccaSm2.h mcuxClOsccaSm2_Constants.h mcuxClOsccaSm2_Functions.h mcuxClOsccaSm2_FUP.h mcuxClOsccaSm2_KeyTypes.h mcuxClOsccaSm2_ModeConstants.h mcuxClOsccaSm2_SelfTest.h mcuxClOsccaSm2_Types.h
  group component/els_pkc/src/comps/mcuxClOsccaSm2/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm2/inc/internal/: mcuxClOsccaSm2_Internal.h mcuxClOsccaSm2_Internal_ConstructTypes.h mcuxClOsccaSm2_Internal_CryptoUtils.h mcuxClOsccaSm2_Internal_Ecc.h mcuxClOsccaSm2_Internal_FP.h mcuxClOsccaSm2_Internal_Functions.h mcuxClOsccaSm2_Internal_FUP.h mcuxClOsccaSm2_Internal_Hash.h mcuxClOsccaSm2_Internal_Helper.h mcuxClOsccaSm2_Internal_PkcWaLayout.h mcuxClOsccaSm2_Internal_Types.h
  group component/els_pkc/src/comps/mcuxClOsccaSm3/src
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm3/src/: mcuxClOsccaSm3_core_sm3.c mcuxClOsccaSm3_internal_sm3.c
  group component/els_pkc/src/comps/mcuxClOsccaSm3/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm3/inc/: mcuxClOsccaSm3.h mcuxClOsccaSm3_Algorithms.h mcuxClOsccaSm3_Constants.h
  group component/els_pkc/src/comps/mcuxClOsccaSm3/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm3/inc/internal/: mcuxClOsccaSm3_Core_sm3.h mcuxClOsccaSm3_Internal.h mcuxClOsccaSm3_Internal_sm3.h
  group component/els_pkc/src/comps/mcuxClOsccaSm4/src
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm4/src/: mcuxClOsccaSm4_CommonOperations.c mcuxClOsccaSm4_Core.c mcuxClOsccaSm4_KeyTypes.c mcuxClOsccaSm4_LoadKey.c
  group component/els_pkc/src/comps/mcuxClOsccaSm4/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm4/inc/: mcuxClOsccaSm4.h mcuxClOsccaSm4_KeyTypes.h
  group component/els_pkc/src/comps/mcuxClOsccaSm4/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm4/inc/internal/: mcuxClOsccaSm4_Internal.h mcuxClOsccaSm4_Internal_Constants.h mcuxClOsccaSm4_Internal_Functions.h
  group component/els_pkc/src/comps/mcuxClPadding/src
    ../../../../../../components/els_pkc/src/comps/mcuxClPadding/src/: mcuxClPadding.c
  group component/els_pkc/src/comps/mcuxClPadding/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClPadding/inc/: mcuxClPadding.h mcuxClPadding_Constants.h mcuxClPadding_Types.h
  group component/els_pkc/src/comps/mcuxClPadding/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClPadding/inc/internal/: mcuxClPadding_Functions_Internal.h mcuxClPadding_Internal.h mcuxClPadding_Types_Internal.h
  group component/els_pkc/src/comps/mcuxClPkc/src
    ../../../../../../components/els_pkc/src/comps/mcuxClPkc/src/: mcuxClPkc_Calculate.c mcuxClPkc_ImportExport.c mcuxClPkc_Initialize.c mcuxClPkc_UPTRT.c
  group component/els_pkc/src/comps/mcuxClPkc/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClPkc/inc/: mcuxClPkc.h mcuxClPkc_Functions.h mcuxClPkc_Types.h
  group component/els_pkc/src/comps/mcuxClPkc/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClPkc/inc/internal/: mcuxClPkc_FupMacros.h mcuxClPkc_ImportExport.h mcuxClPkc_Inline_Functions.h mcuxClPkc_Macros.h mcuxClPkc_Operations.h mcuxClPkc_Resource.h mcuxClPkc_SfrAccess.h
  group component/els_pkc/src/comps/mcuxClPrng/src
    ../../../../../../components/els_pkc/src/comps/mcuxClPrng/src/: mcuxClPrng_ELS.c
  group component/els_pkc/src/comps/mcuxClPrng/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClPrng/inc/internal/: mcuxClPrng_Internal.h mcuxClPrng_Internal_Constants.h mcuxClPrng_Internal_ELS.h mcuxClPrng_Internal_Functions.h mcuxClPrng_Internal_Types.h
  group component/els_pkc/src/comps/mcuxClPsaDriver/src
    ../../../../../../components/els_pkc/src/comps/mcuxClPsaDriver/src/: mcuxClPsaDriver_Aead.c mcuxClPsaDriver_Cipher.c mcuxClPsaDriver_DER_functions.c mcuxClPsaDriver_export_public_key.c mcuxClPsaDriver_generate_ecp_key.c mcuxClPsaDriver_Hash.c mcuxClPsaDriver_Key.c mcuxClPsaDriver_Mac.c mcuxClPsaDriver_Rsa.c mcuxClPsaDriver_Sign.c mcuxClPsaDriver_UpdateKeyStatus.c mcuxClPsaDriver_Verify.c
  group component/els_pkc/src/comps/mcuxClPsaDriver/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClPsaDriver/inc/: mcuxClPsaDriver.h mcuxClPsaDriver_Constants.h mcuxClPsaDriver_MemoryConsumption.h mcuxClPsaDriver_Oracle.h els_pkc_crypto_primitives.h els_pkc_crypto_composites.h
  group component/els_pkc/src/comps/mcuxClPsaDriver/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClPsaDriver/inc/internal/: mcuxClPsaDriver_ExternalMacroWrappers.h mcuxClPsaDriver_Functions.h mcuxClPsaDriver_Internal.h mcuxClPsaDriver_Types.h
  group component/els_pkc/src/comps/mcuxClRandom/src
    ../../../../../../components/els_pkc/src/comps/mcuxClRandom/src/: mcuxClRandom_DRBG.c mcuxClRandom_PRNG.c
  group component/els_pkc/src/comps/mcuxClRandom/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClRandom/inc/: mcuxClRandom.h mcuxClRandom_Constants.h mcuxClRandom_Functions.h mcuxClRandom_Types.h
  group component/els_pkc/src/comps/mcuxClRandom/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClRandom/inc/internal/: mcuxClRandom_Internal_Functions.h mcuxClRandom_Internal_Memory.h mcuxClRandom_Internal_Types.h
  group component/els_pkc/src/comps/mcuxClRandomModes/src
    ../../../../../../components/els_pkc/src/comps/mcuxClRandomModes/src/: mcuxClRandomModes_HmacDrbg.c mcuxClRandomModes_CtrDrbg_Els.c mcuxClRandomModes_ElsMode.c mcuxClRandomModes_PatchMode.c mcuxClRandomModes_TestMode.c mcuxClRandomModes_CtrDrbg.c mcuxClRandomModes_CtrDrbg_PrDisabled.c mcuxClRandomModes_NormalMode.c mcuxClRandomModes_PrDisabled.c mcuxClRandomModes_NormalMode.c
  group component/els_pkc/src/comps/mcuxClRandomModes/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClRandomModes/inc/internal/: mcuxClRandomModes_Internal_HmacDrbg_Functions.h mcuxClRandomModes_Private_HmacDrbg.h mcuxClRandomModes_Internal_SizeDefinitions.h mcuxClRandomModes_Private_CtrDrbg.h mcuxClRandomModes_Private_CtrDrbg_BlockCipher.h mcuxClRandomModes_Private_Drbg.h mcuxClRandomModes_Private_NormalMode.h mcuxClRandomModes_Private_PatchMode.h mcuxClRandomModes_Private_PrDisabled.h mcuxClRandomModes_Private_TestMode.h
  group component/els_pkc/src/comps/mcuxClRandomModes/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClRandomModes/inc/: mcuxClRandomModes.h mcuxClRandomModes_Constants.h mcuxClRandomModes_Functions_PatchMode.h mcuxClRandomModes_Functions_TestMode.h
  group component/els_pkc/src/comps/mcuxClRsa/src
    ../../../../../../components/els_pkc/src/comps/mcuxClRsa/src/: mcuxClRsa_KeyTypes.c mcuxClRsa_ModeConstructors.c mcuxClRsa_OaepDecode.c mcuxClRsa_OaepEncode.c mcuxClRsa_pkcs1v15Decode_decrypt.c mcuxClRsa_Pkcs1v15Encode_encrypt.c mcuxClRsa_Util_Decrypt.c mcuxClRsa_Util_Encrypt.c mcuxClRsa_ComputeD.c mcuxClRsa_ComputeD_FUP.c mcuxClRsa_GenerateProbablePrime.c mcuxClRsa_getMillerRabinTestIterations.c mcuxClRsa_KeyGeneration_Crt.c mcuxClRsa_KeyGeneration_Crt_FUP.c mcuxClRsa_KeyGeneration_Helper.c mcuxClRsa_KeyGeneration_Plain.c mcuxClRsa_Mgf1.c mcuxClRsa_MillerRabinTest.c mcuxClRsa_MillerRabinTest_FUP.c mcuxClRsa_ModInv.c mcuxClRsa_Pkcs1v15Encode_sign.c mcuxClRsa_Pkcs1v15Verify.c mcuxClRsa_PrivateCrt.c mcuxClRsa_PrivateCrt_FUP.c mcuxClRsa_PrivatePlain.c mcuxClRsa_PssEncode.c mcuxClRsa_PssVerify.c mcuxClRsa_Public.c mcuxClRsa_PublicExp.c mcuxClRsa_RemoveBlinding.c mcuxClRsa_RemoveBlinding_FUP.c mcuxClRsa_Sign.c mcuxClRsa_Sign_NoEMSA.c mcuxClRsa_TestPQDistance.c mcuxClRsa_TestPQDistance_FUP.c mcuxClRsa_TestPrimeCandidate.c mcuxClRsa_TestPrimeCandidate_FUP.c mcuxClRsa_Verify.c mcuxClRsa_VerifyE.c mcuxClRsa_Verify_NoEMSA.c
  group component/els_pkc/src/comps/mcuxClRsa/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClRsa/inc/: mcuxClRsa_KeyTypes.h mcuxClRsa_ModeConstructors.h mcuxClRsa.h mcuxClRsa_ComputeD_FUP.h mcuxClRsa_Constants.h mcuxClRsa_Functions.h mcuxClRsa_KeyGeneration_Crt_FUP.h mcuxClRsa_MillerRabinTest_FUP.h mcuxClRsa_PrivateCrt_FUP.h mcuxClRsa_RemoveBlinding_FUP.h mcuxClRsa_TestPQDistance_FUP.h mcuxClRsa_TestPrimeCandidate_FUP.h mcuxClRsa_Types.h
  group component/els_pkc/src/comps/mcuxClRsa/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClRsa/inc/internal/: mcuxClRsa_ComputeD_FUP.h mcuxClRsa_Internal_Functions.h mcuxClRsa_Internal_Macros.h mcuxClRsa_Internal_MemoryConsumption.h mcuxClRsa_Internal_PkcDefs.h mcuxClRsa_Internal_PkcTypes.h mcuxClRsa_Internal_Types.h mcuxClRsa_KeyGeneration_Crt_FUP.h mcuxClRsa_MillerRabinTest_FUP.h mcuxClRsa_PrivateCrt_FUP.h mcuxClRsa_RemoveBlinding_FUP.h mcuxClRsa_TestPQDistance_FUP.h mcuxClRsa_TestPrimeCandidate_FUP.h
  group component/els_pkc/src/comps/mcuxClSession/src
    ../../../../../../components/els_pkc/src/comps/mcuxClSession/src/: mcuxClSession.c
  group component/els_pkc/src/comps/mcuxClSession/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClSession/inc/: mcuxClSession.h mcuxClSession_Functions.h mcuxClSession_Types.h
  group component/els_pkc/src/comps/mcuxClSession/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClSession/inc/internal/: mcuxClSession_Internal.h mcuxClSession_Internal_EntryExit.h mcuxClSession_Internal_EntryExit_RegularReturn.h mcuxClSession_Internal_Functions.h
  group component/els_pkc/src/comps/mcuxClSignature/src
    ../../../../../../components/els_pkc/src/comps/mcuxClSignature/src/: mcuxClSignature.c
  group component/els_pkc/src/comps/mcuxClSignature/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClSignature/inc/: mcuxClSignature.h mcuxClSignature_Constants.h mcuxClSignature_Functions.h mcuxClSignature_Types.h
  group component/els_pkc/src/comps/mcuxClSignature/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClSignature/inc/internal/: mcuxClSignature_Internal.h
  group component/els_pkc/src/comps/mcuxClTrng/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClTrng/inc/internal/: mcuxClTrng_Internal.h mcuxClTrng_Internal_Constants.h mcuxClTrng_Internal_Functions.h mcuxClTrng_Internal_SA_TRNG.h mcuxClTrng_Internal_Types.h mcuxClTrng_SfrAccess.h
  group component/els_pkc/src/comps/mcuxClTrng/src
    ../../../../../../components/els_pkc/src/comps/mcuxClTrng/src/: mcuxClTrng_ELS.c
  group component/els_pkc/src/comps/mcuxCsslCPreProcessor/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslCPreProcessor/inc/: mcuxCsslAnalysis.h mcuxCsslCPreProcessor.h
  group component/els_pkc/src/comps/mcuxCsslDataIntegrity/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslDataIntegrity/inc/: mcuxCsslDataIntegrity.h mcuxCsslDataIntegrity_Cfg.h mcuxCsslDataIntegrity_Impl.h mcuxCsslDataIntegrity_None.h
  group component/els_pkc/src/comps/mcuxCsslFlowProtection/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/inc/: mcuxCsslFlowProtection.h mcuxCsslFlowProtection_Cfg.h mcuxCsslFlowProtection_FunctionIdentifiers.h mcuxCsslFlowProtection_Impl.h mcuxCsslFlowProtection_SecureCounter_Common.h mcuxCsslFlowProtection_SecureCounter_Local.h
  group component/els_pkc/src/comps/mcuxCsslParamIntegrity/src
    ../../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/src/: mcuxCsslParamIntegrity32.c
  group component/els_pkc/src/comps/mcuxCsslParamIntegrity/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/inc/: mcuxCsslParamIntegrity.h
  group component/els_pkc/src/comps/mcuxCsslSecureCounter/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslSecureCounter/inc/: mcuxCsslSecureCounter.h mcuxCsslSecureCounter_Cfg.h mcuxCsslSecureCounter_Impl.h mcuxCsslSecureCounter_None.h mcuxCsslSecureCounter_SW_Local.h
  group component/els_pkc/src/inc
    ../../../../../../components/els_pkc/src/inc/: mcuxCl_clns.h
  group component/els_pkc/src/compiler
    ../../../../../../components/els_pkc/src/compiler/: mcuxClToolchain.h
  group component/els_pkc/src/platforms/mimxrt
    ../../../../../../components/els_pkc/src/platforms/mimxrt/: platform_specific_headers.h mcuxClConfig.h mcux_els.c mcux_els.h mcux_pkc.c mcux_pkc.h
  group component/els_pkc/src/platforms/mimxrt/inc
    ../../../../../../components/els_pkc/src/platforms/mimxrt/inc/: ip_css_constants.h ip_css_design_configuration.h ip_platform.h
  group component/els_pkc/includes/platform/mimxrt
    ../../../../../../components/els_pkc/includes/platform/mimxrt/: mcuxClAeadModes_MemoryConsumption.h mcuxClCipherModes_MemoryConsumption.h mcuxClEcc_MemoryConsumption.h mcuxClHash_MemoryConsumption.h mcuxClHashModes_MemoryConsumption.h mcuxClHmac_MemoryConsumption.h mcuxClKey_MemoryConsumption.h mcuxClMacModes_MemoryConsumption.h mcuxClOsccaAeadModes_MemoryConsumption.h mcuxClOsccaCipherModes_MemoryConsumption.h mcuxClOsccaMacModes_MemoryConsumption.h mcuxClOsccaRandomModes_MemoryConsumption.h mcuxClOsccaSm2_MemoryConsumption.h mcuxClOsccaSm3_MemoryConsumption.h mcuxClRandomModes_MemoryConsumption.h mcuxClRsa_MemoryConsumption.h mcuxClSession_MemoryConsumption.h mcuxClSignature_MemoryConsumption.h
  group component/psa_crypto_driver/osal
    ../../../../../../components/psa_crypto_driver/osal/: osal_mutex.h
  group component/psa_crypto_driver/osal/baremetal
    ../../../../../../components/psa_crypto_driver/osal/baremetal/: osal_mutex.c osal_mutex_platform.h
  group component/psa_crypto_driver/els_pkc/oracle/platforms/mimxrt
    ../../../../../../components/psa_crypto_driver/els_pkc/oracle/platforms/mimxrt/: mcuxClPsaDriver_Oracle_KeyRecipes.h
  group component/psa_crypto_driver/els_pkc/oracle/inc
    ../../../../../../components/psa_crypto_driver/els_pkc/oracle/inc/: mcuxClPsaDriver_Oracle_Interface_builtin_key_ids.h mcuxClPsaDriver_Oracle_Interface_key_locations.h mcuxClPsaDriver_Oracle_ElsUtils.h mcuxClPsaDriver_Oracle_Macros.h mcuxClPsaDriver_Oracle_Utils.h
  group component/psa_crypto_driver/els_pkc/oracle/src
    ../../../../../../components/psa_crypto_driver/els_pkc/oracle/src/: mcuxClPsaDriver_Oracle.c mcuxClPsaDriver_Oracle_ElsUtils.c mcuxClPsaDriver_Oracle_Utils.c
  group component/psa_crypto_driver/els_pkc/include/common
    ../../../../../../components/psa_crypto_driver/els_pkc/include/common/: mcux_psa_els_pkc_common_init.h mcux_psa_els_pkc_entropy.h
  group component/psa_crypto_driver/els_pkc/src/common
    ../../../../../../components/psa_crypto_driver/els_pkc/src/common/: mcux_psa_els_pkc_common_init.c mcux_psa_els_pkc_entropy.c
  group component/psa_crypto_driver/els_pkc/include/transparent
    ../../../../../../components/psa_crypto_driver/els_pkc/include/transparent/: mcux_psa_els_pkc_aead.h mcux_psa_els_pkc_asymmetric_signature.h mcux_psa_els_pkc_cipher.h mcux_psa_els_pkc_hash.h mcux_psa_els_pkc_init.h mcux_psa_els_pkc_key_generation.h mcux_psa_els_pkc_mac.h
  group component/psa_crypto_driver/els_pkc/src/transparent
    ../../../../../../components/psa_crypto_driver/els_pkc/src/transparent/: mcux_psa_els_pkc_aead.c mcux_psa_els_pkc_asymmetric_signature.c mcux_psa_els_pkc_cipher.c mcux_psa_els_pkc_hash.c mcux_psa_els_pkc_init.c mcux_psa_els_pkc_key_generation.c mcux_psa_els_pkc_mac.c
  group component/psa_crypto_driver/els_pkc/include/opaque
    ../../../../../../components/psa_crypto_driver/els_pkc/include/opaque/: mcux_psa_els_pkc_opaque_aead.h mcux_psa_els_pkc_opaque_asymmetric_signature.h mcux_psa_els_pkc_opaque_cipher.h mcux_psa_els_pkc_opaque_init.h mcux_psa_els_pkc_opaque_key_generation.h mcux_psa_els_pkc_opaque_mac.h
  group component/psa_crypto_driver/els_pkc/src/opaque
    ../../../../../../components/psa_crypto_driver/els_pkc/src/opaque/: mcux_psa_els_pkc_opaque_aead.c mcux_psa_els_pkc_opaque_asymmetric_signature.c mcux_psa_els_pkc_opaque_cipher.c mcux_psa_els_pkc_opaque_init.c mcux_psa_els_pkc_opaque_key_generation.c mcux_psa_els_pkc_opaque_mac.c
  group component/psa_crypto_driver/els_pkc
    ../../../../../../components/psa_crypto_driver/els_pkc/: els_pkc_driver.h
  group flash/mflash
    ../../../../../../components/flash/mflash/: mflash_common.h mflash_file.c mflash_file.h
  group flash/mflash/mimxrt700
    ../../../../../../components/flash/mflash/mimxrt700/: mflash_drv.c mflash_drv.h
  group wifi/port/osa
    ../../../../../../middleware/wifi_nxp/port/osa/: osa_freertos.h osa_freertos.c osa.c mem_pool.c mem_pool_config.c slist.c stack_simple.c osa_cli.c
  group wifi/incl/port/osa
    ../../../../../../middleware/wifi_nxp/incl/port/osa/: osa.h mem_pool.h mem_pool_config.h slist.h stack_simple.h
  group wifi/incl
    ../../../../../../middleware/wifi_nxp/incl/: wifi_config_default.h wifi_cal_data_ext.h wm_utils.h wmerrno.h wmlog.h wmtypes.h wifi_cal_data_frdmrw61x_1ant.h wifi_cal_data_rw61x_1ant.h wifi_cal_data_rw61x_1ant_diversity.h wifi_cal_data_rw61x_2ant.h wifi_cal_data_rw61x_3ant_diversity.h wifi_cal_data_override.h WIFI_IW416_BOARD_AW_AM457_CAL_DATA_EXT.h dhcp-server.h nxp_wifi.h wmstats.h cli.h cli_utils.h iperf.h wifi_ping.h
  group wifi/incl/wifidriver
    ../../../../../../middleware/wifi_nxp/incl/wifidriver/: wifi-decl.h wifi.h wifi_events.h wifi_nxp.h
  group wifi/wifidriver/incl
    ../../../../../../middleware/wifi_nxp/wifidriver/incl/: mlan_decl.h mlan_ioctl.h type_decls.h mlan_main_defs.h mlan.h mlan_11ac.h mlan_11ax.h mlan_11h.h mlan_11n.h mlan_11n_aggr.h mlan_11n_rxreorder.h mlan_11v.h mlan_action.h mlan_11k.h mlan_mbo.h mlan_api.h mlan_fw.h mlan_ieee.h mlan_init.h mlan_join.h mlan_main.h mlan_meas.h mlan_remap_mem_operations.h mlan_uap.h mlan_util.h mlan_wmm.h
  group wifi/wifi_bt_firmware
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/: wlan_bt_fw.h
  group wifi/wifi_bt_firmware/IW416
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/IW416/: sduartIW416_wlan_bt.bin.inc sdIW416_wlan.bin.inc uartIW416_bt.bin.inc sduartIW416_wlan_bt.h sdIW416_wlan.h uartIW416_bt.h IW416_cpu12.c IW416_cpu1.c IW416_cpu2.c
  group wifi/wifi_bt_firmware/8987
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/8987/: sduart8987_wlan_bt.bin.inc sd8987_wlan.bin.inc uart8987_bt.bin.inc sduart8987_wlan_bt.h sd8987_wlan.h uart8987_bt.h 8987_cpu12.c 8987_cpu1.c 8987_cpu2.c
  group wifi/wifi_bt_firmware/nw61x
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/nw61x/: sduart_nw61x.bin.se.inc sd_nw61x.bin.se.inc uart_nw61x.bin.se.inc sduart_nw61x_se.h sd_nw61x_se.h uart_nw61x_se.h nw61x_cpu12_se.c nw61x_cpu1_se.c nw61x_cpu2_se.c
  group wifi/wifi_bt_firmware/iw610
    ../../../../../../middleware/wifi_nxp/wifi_bt_firmware/iw610/: sduartspi_iw610.bin.se.inc sd_iw610.bin.se.inc uartspi_iw610.bin.se.inc sduart_iw610.bin.se.inc uart_iw610_bt.bin.se.inc sduart_iw610_se.h sd_iw610_se.h uart_iw610_se.h iw610_cpu12_se.c iw610_cpu2_se.c iw610_cpu1_se.c
  group wifi/wifidriver
    ../../../../../../middleware/wifi_nxp/wifidriver/: sdio.c sdio.h mlan_11ac.c mlan_11ax.c mlan_11d.c mlan_11h.c mlan_11n.c mlan_11n_aggr.c mlan_11n_rxreorder.c mlan_11v.c mlan_action.c mlan_11k.c mlan_mbo.c mlan_api.c mlan_cfp.c mlan_cmdevt.c mlan_glue.c mlan_init.c mlan_join.c mlan_misc.c mlan_scan.c mlan_shim.c mlan_sta_cmd.c mlan_sta_cmdresp.c mlan_sta_event.c mlan_sta_ioctl.c mlan_sta_rx.c mlan_txrx.c mlan_wmm.c wifi-debug.c wifi-debug.h wifi-internal.h wifi-mem.c wifi.c wifi_common.h wifi_pwrmgr.c wifi-wps.c wifi-uap.c mlan_uap_ioctl.c mlan_uap_cmdevent.c wifi-sdio.c wifi-sdio.h
  group wifi/firmware_dnld
    ../../../../../../middleware/wifi_nxp/firmware_dnld/: firmware_dnld.c firmware_dnld.h
  group wifi/incl/port/net
    ../../../../../../middleware/wifi_nxp/incl/port/net/: wm_net.h wm_net.h wm_net.h
  group wifi/port/net
    ../../../../../../middleware/wifi_nxp/port/net/: net.c netif_decl.h wifi_netif.c net.c netif_decl.h wifi_netif.c
  group wifi/incl/port/net/hooks
    ../../../../../../middleware/wifi_nxp/incl/port/net/hooks/: lwip_default_hooks.h
  group wifi/port/net/hooks
    ../../../../../../middleware/wifi_nxp/port/net/hooks/: lwip_default_hooks.c
  group wifi/dhcpd
    ../../../../../../middleware/wifi_nxp/dhcpd/: dhcp-bootp.h dhcp-priv.h dhcp-server-main.c dhcp-server.c dns-server.c dns.h dhcp-bootp.h dhcp-priv.h dhcp-server-main.c dhcp-server.c dns-server.c dns.h dhcp-server-cli.c
  group wifi/incl/wlcmgr
    ../../../../../../middleware/wifi_nxp/incl/wlcmgr/: wlan.h wlan_11d.h wlan_tests.h
  group wifi/wifidriver/wpa_supp_if/incl
    ../../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if/incl/: rtos_wpa_supp_if.h wifi_nxp_internal.h
  group wifi/wifidriver/wpa_supp_if
    ../../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if/: wifi_nxp.c rtos_wpa_supp_if.c wifi_nxp_internal.c
  group wifi/certs
    ../../../../../../middleware/wifi_nxp/certs/: ca-cert.h client-cert.h client-key.h server-cert.h server-key.h dh-param.h
  group wifi/wlcmgr
    ../../../../../../middleware/wifi_nxp/wlcmgr/: wlan.c wlan_txpwrlimit_cfg.c wlan_basic_cli.c wlan_enhanced_tests.c wlan_tests.c wlan_test_mode_tests.c
  group wifi
    ../../../../../../middleware/wifi_nxp/: ChangeLogKSDK.txt CMakeLists.txt
  group wifi/sdio_nxp_abs
    ../../../../../../middleware/wifi_nxp/sdio_nxp_abs/: mlan_sdio.c fwdnld_sdio.c
  group wifi/sdio_nxp_abs/incl
    ../../../../../../middleware/wifi_nxp/sdio_nxp_abs/incl/: fwdnld_sdio.h mlan_sdio_defs.h mlan_sdio.h mlan_sdio_api.h
  group wifi/fwdnld_intf_abs
    ../../../../../../middleware/wifi_nxp/fwdnld_intf_abs/: fwdnld_intf_abs.c fwdnld_intf_abs.h
  group wifi/cli
    ../../../../../../middleware/wifi_nxp/cli/: cli_mem.h cli.c cli_mem_simple.c cli_utils.c wifi_shell.h wifi_shell.c
  group wifi/nw_utils
    ../../../../../../middleware/wifi_nxp/nw_utils/: wifi_ping.c iperf.c network_cfg.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group usb/host
    ../../../../../../middleware/usb/host/: usb_host.h usb_host_hci.h usb_host_devices.h usb_host_framework.h usb_host_ehci.c usb_host_ehci.h usb_host_hci.c usb_host_devices.c usb_host_framework.c
  group usb/host/class
    ../../../../../../middleware/usb/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_msd.c usb_host_msd.h usb_host_msd_ufi.c
  group usb/phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group fatfs/source
    ../../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_usb_disk
    ../../../../../../middleware/fatfs/source/fsl_usb_disk/: fsl_usb_disk.h fsl_usb_disk_freertos.c
  group littlefs
    ../../../../../../middleware/littlefs/: lfs.c lfs.h lfs_util.c lfs_util.h
  group lwip/port/arch
    ../../../../../../middleware/lwip/port/arch/: cc.h perf.h
  group lwip/src/api
    ../../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/core
    ../../../../../../middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/src/core/ipv4
    ../../../../../../middleware/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/src/core/ipv6
    ../../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip/src/include/compat/posix
    ../../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/compat/posix/net
    ../../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/sys
    ../../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/stdc
    ../../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/lwip
    ../../../../../../middleware/lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/priv
    ../../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h memp_priv.h memp_std.h mem_priv.h nd6_priv.h raw_priv.h sockets_priv.h tcpip_priv.h tcp_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../../middleware/lwip/src/include/lwip/prot/: acd.h autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip/src/include/netif
    ../../../../../../middleware/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lwip/src/include/netif/ppp
    ../../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h ppp_impl.h ppp_opts.h upap.h vj.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip/src/netif
    ../../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lwip/src/netif/ppp/polarssl
    ../../../../../../middleware/lwip/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
  group lwip/port/sys_arch/dynamic/arch
    ../../../../../../middleware/lwip/port/sys_arch/dynamic/arch/: sys_arch.h
  group lwip/port/sys_arch/dynamic
    ../../../../../../middleware/lwip/port/sys_arch/dynamic/: sys_arch.c
  group lwip/src/apps/lwiperf
    ../../../../../../middleware/lwip/src/apps/lwiperf/: lwiperf.c
  group lwip/src/include/lwip/apps
    ../../../../../../middleware/lwip/src/include/lwip/apps/: lwiperf.h
  group mbedtls3x/include/mbedtls
    ../../../../../../middleware/mbedtls3x/include/mbedtls/: aes.h aria.h asn1.h asn1write.h base64.h bignum.h block_cipher.h build_info.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cipher.h cmac.h compat-2.x.h config_adjust_legacy_crypto.h config_adjust_legacy_from_psa.h config_adjust_psa_from_legacy.h config_adjust_psa_superset_legacy.h config_adjust_ssl.h config_adjust_x509.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h error.h gcm.h hkdf.h hmac_drbg.h lms.h mbedtls_config.h md.h md5.h memory_buffer_alloc.h nist_kw.h oid.h pem.h pk.h pkcs5.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h private_access.h psa_util.h ripemd160.h rsa.h sha1.h sha3.h sha256.h sha512.h threading.h timing.h version.h pkcs7.h x509.h x509_crl.h x509_crt.h x509_csr.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_ticket.h net_sockets.h
  group mbedtls3x/include/psa
    ../../../../../../middleware/mbedtls3x/include/psa/: build_info.h crypto.h crypto_adjust_auto_enabled.h crypto_adjust_config_dependencies.h crypto_adjust_config_key_pair_types.h crypto_adjust_config_synonyms.h crypto_builtin_composites.h crypto_builtin_key_derivation.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_key_derivation.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_legacy.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group mbedtls3x/library
    ../../../../../../middleware/mbedtls3x/library/: aes.c aesni.c aesni.h alignment.h aesce.c aesce.h aria.c asn1parse.c asn1write.c base64.c base64_internal.h bignum.c bignum_core.h bignum_core.c bignum_core_invasive.h bignum_internal.h bignum_mod.c bignum_mod.h bignum_mod_raw.c bignum_mod_raw.h bignum_mod_raw_invasive.h block_cipher.c block_cipher_internal.h bn_mul.h camellia.c ccm.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cipher_wrap.h cmac.c common.h constant_time.c constant_time_impl.h constant_time_internal.h ctr_drbg.c ctr.h des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_curves_new.c ecp_internal_alt.h ecp_invasive.h entropy.c entropy_poll.c entropy_poll.h error.c gcm.c hkdf.c hmac_drbg.c lmots.c lmots.h lms.c md.c md_psa.h md_wrap.h md5.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c padlock.h pem.c pk.c pk_ecc.c pk_internal.h pk_wrap.c pk_wrap.h pkcs5.c pkcs12.c pkparse.c pkwrite.c pkwrite.h platform.c platform_util.c poly1305.c psa_crypto_aead.h psa_crypto_cipher.h psa_crypto_core.h psa_crypto_core_common.h psa_crypto_driver_wrappers_no_static.h psa_crypto_driver_wrappers.h psa_crypto_ecp.h psa_crypto_ffdh.h psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.h psa_crypto_pake.h psa_crypto_random_impl.h psa_crypto_rsa.h psa_crypto_se.h psa_crypto_slot_management.h psa_crypto_storage.h psa_util_internal.h psa_util.c ripemd160.c rsa.c rsa_alt_helpers.c rsa_alt_helpers.h rsa_internal.h sha1.c sha3.c sha256.c sha512.c threading.c timing.c version.c version_features.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers_no_static.c psa_crypto_ecp.c psa_crypto_ffdh.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_pake.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write.c x509write_crt.c x509write_csr.c x509_internal.h pkcs7.c debug.c debug_internal.h mps_common.h mps_error.h mps_reader.c mps_reader.h mps_trace.c mps_trace.h net_sockets.c ssl_cache.c ssl_ciphersuites.c ssl_ciphersuites_internal.h ssl_client.c ssl_client.h ssl_cookie.c ssl_debug_helpers.h ssl_debug_helpers_generated.c ssl_misc.h ssl_msg.c ssl_ticket.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_invasive.h ssl_tls13_keys.c ssl_tls13_keys.h ssl_tls13_server.c
  group mbedtls3x/port
    ../../../../../../middleware/mbedtls3x/port/: mcux_mbedtls_config.h mcux_mbedtls_accelerator_config.h mcux_mbedtls_psa_crypto_config.h mcux_mbedtls_accelerator_config.h mcux_psa_defines.h
  group sdmmc/common
    ../../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h fsl_sdmmc_common.c
  group sdmmc/osa
    ../../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group sdmmc/sdio
    ../../../../../../middleware/sdmmc/sdio/: fsl_sdio.c fsl_sdio.h
  group sdmmc/host/usdhc
    ../../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h fsl_sdmmc_host.h
  group sdmmc/host/usdhc/non_blocking
    ../../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group edgefast/bluetooth
    ../../../../../../middleware/edgefast_bluetooth/: readme.txt
  group bt_ble/bluetooth/export/eOSAL
    ../../../../../../middleware/wireless/ethermind/bluetooth/export/eOSAL/: eBT_assert.h eBT_config.h eBT_debug_api.h eBT_fops.h eBT_os.h eBT_serial.h eBT_timer.h
  group bt_ble/bluetooth/export/include
    ../../../../../../middleware/wireless/ethermind/bluetooth/export/include/: BT_a2dp_api.h BT_analyzer.h BT_api.h BT_assigned_numbers.h BT_at_parser_api.h BT_att_api.h BT_avctp_api.h BT_avdtp_api.h BT_avrcp_api.h BT_avrcp_ca_api.h BT_bip_api.h BT_bnep_api.h BT_bottom_half.h BT_bpp_api.h BT_common.h BT_ctn_api.h BT_dbase_api.h BT_device_queue.h BT_error.h BT_ftp_api.h BT_gap_api.h BT_gatt_db_api.h BT_hci_api.h BT_hdp_api.h BT_hfp_ag_api.h BT_hfp_unit_api.h BT_hid_device_api.h BT_hid_host_api.h BT_irobex_api.h BT_jpl_api.h BT_map_api.h BT_mcap_api.h BT_obex_api.h BT_opp_api.h BT_pan_api.h BT_pbap_api.h BT_racp.h BT_rfcomm_api.h BT_sap_api.h BT_sdp_api.h BT_security.h BT_sm_api.h BT_smp_api.h BT_snoop.h BT_spp_api.h BT_status.h BT_storage.h BT_version.h fsm_defines.h fsm_engine.h gatt_defines.h hci_transport.h l2cap.h write_task.h
  group bt_ble/bluetooth/export/vendor
    ../../../../../../middleware/wireless/ethermind/bluetooth/export/vendor/: vendor_specific_commands.h vendor_specific_init.c vendor_specific_init.h
  group bt_ble/bluetooth/private/protocols/att
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/att/: att.h
  group bt_ble/bluetooth/private/protocols/avctp
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avctp/: avctp.h
  group bt_ble/bluetooth/private/protocols/avdtp
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/avdtp/: avdtp.h
  group bt_ble/bluetooth/private/protocols/bnep
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/bnep/: bnep.h
  group bt_ble/bluetooth/private/protocols/dbase
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/dbase/: database.h
  group bt_ble/bluetooth/private/protocols/hci_1.2
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/hci_1.2/: hci_h.h
  group bt_ble/bluetooth/private/protocols/mcap
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/mcap/: mcap.h
  group bt_ble/bluetooth/private/protocols/obex
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/obex/: obex.h
  group bt_ble/bluetooth/private/protocols/rfcomm
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/rfcomm/: rfcomm.h
  group bt_ble/bluetooth/private/protocols/sdp
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sdp/: sdp.h
  group bt_ble/bluetooth/private/protocols/sm
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/sm/: sm.h sm_extern.h sm_internal.h
  group bt_ble/bluetooth/private/protocols/smp
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/protocols/smp/: smp.h smp_extern.h smp_fsm.h smp_fsm_engine.h smp_internal.h
  group bt_ble/bluetooth/private/utils/aes_cmac
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/aes_cmac/: aes_cmac.h
  group bt_ble/bluetooth/private/utils/at_parser
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/at_parser/: at_parser_hsp_hfp.h
  group bt_ble/bluetooth/private/utils/object_parser
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/object_parser/: object_parser_api.h tokenizer.h
  group bt_ble/bluetooth/private/utils/racp
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/racp/: racp.h
  group bt_ble/bluetooth/private/utils/storage
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/storage/: storage.h
  group bt_ble/bluetooth/private/utils/xml_parser
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/xml_parser/: xml_common_defines.h xml_encoder.h xml_parser.h
  group bt_ble/port/osal/src/freertos
    ../../../../../../middleware/wireless/ethermind/port/osal/src/freertos/: EM_assert.h EM_config.c EM_config.h EM_debug.c EM_debug.h EM_debug_api.h EM_debug_internal.h EM_fops.c EM_fops.h EM_os.c EM_os.h EM_serial.c EM_serial.h EM_timer.c EM_timer.h EM_timer_internal.h
  group bt_ble/port/pal/mcux/bluetooth
    ../../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth/: BT_assert.h BT_config.h BT_debug.h BT_debug_api.h BT_fops.h BT_os.h BT_status_pl.c BT_storage_pl.c BT_storage_pl.h BT_timer.h btsnoop_pl.c btsnoop_pl.h sco_audio_pl.c sco_audio_pl.h ctn_pl.c ctn_pl.h ftp_pl.c ftp_pl.h hci_uart_internal.h ht_read_task_pl.c map_pl.c map_pl.h obex_pl.c obex_pl.h pbap_pl.c pbap_pl.h write_task_extern_pl.h write_task_pl.c write_task_pl.h littlefs_pl.c littlefs_pl.h fw_loader_uart.c fw_loader_uart.h hci_uart.c hci_uart.h hci_uart_internal.h
  group bt_ble/port/pal/mcux/ethal
    ../../../../../../middleware/wireless/ethermind/port/pal/mcux/ethal/: ethal_assert.h ethal_config.c ethal_config.h ethal_debug.c ethal_debug.h ethal_debug_api.h ethal_debug_internal.h ethal_fops.c ethal_fops.h ethal_os.c ethal_os.h ethal_serial.c ethal_serial.h ethal_timer.c ethal_timer.h ethal_timer_internal.h
  group bt_ble/port/pal/mcux/sbc
    ../../../../../../middleware/wireless/ethermind/port/pal/mcux/sbc/: sbc_os.h
  group bt_ble/port/pal/mcux
    ../../../../../../middleware/wireless/ethermind/port/pal/mcux/: EM_platform.c EM_platform.h
  group bt_ble/bluetooth/private/utils/sbc
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/utils/sbc/: sbc_api.h
  group bt_ble/bluetooth/export/extension
    ../../../../../../middleware/wireless/ethermind/bluetooth/export/extension/: aes_cmac_pl.c aes_cmac_pl.h BT_common_pl.c BT_common_pl.h device_queue_pl.c device_queue_pl.h sm_pl.c sm_pl.h sm_ssp_pl.c sm_ssp_pl.h smp_pl.c smp_pl.h gatt_db_pl.c gatt_db_pl.h
  group bt_ble/bluetooth/private/lib/config
    ../../../../../../middleware/wireless/ethermind/bluetooth/private/lib/mcux/default/config/: BT_features.h BT_limits.h db_gen.h
  group edgefast/bluetooth/source/impl/ethermind/host
    ../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/host/: bt_pal_att.c bt_pal_eatt.c bt_pal_att_internal.h bt_pal_conn.c bt_pal_conn_internal.h bt_pal_data.c bt_pal_ead.c bt_pal_crypto.c bt_pal_aes_ccm.c bt_pal_crypto_internal.h bt_pal_gatt.c bt_pal_gatt_internal.h bt_pal_hci_core.c bt_pal_hci_core.h bt_pal_adv.c bt_pal_adv.h bt_pal_br.c bt_pal_br.h bt_pal_id.c bt_pal_id.h bt_pal_long_wq.c bt_pal_long_wq.h bt_pal_iso.c bt_pal_iso_internal.h bt_pal_scan.c bt_pal_scan.h bt_pal_ecc.c bt_pal_ecc.h bt_pal_addr.c bt_pal_addr_internal.h bt_pal_buf.c bt_pal_buf_view.h bt_pal_direction.c bt_pal_direction_internal.h bt_pal_hci_ecc.h bt_pal_keys.c bt_pal_keys.h bt_pal_l2cap.c bt_pal_l2cap_internal.h bt_pal_l2cap_br_internal.h bt_pal_l2cap_br_interface.h bt_pal_monitor.c bt_pal_monitor.h bt_pal_rpa.c bt_pal_rpa.h bt_pal_settings.h bt_pal_settings.c bt_pal_smp.c bt_pal_smp_null.c bt_pal_smp.h bt_pal_ssp.h bt_pal_uuid.c
  group edgefast/bluetooth/include/bluetooth
    ../../../../../../middleware/edgefast_bluetooth/include/bluetooth/: addr.h att.h bluetooth.h direction.h buf.h l2cap.h conn.h crypto.h gap.h gatt.h hci.h hci_types.h ead.h byteorder.h hci_raw.h hci_vs.h iso.h testing.h uuid.h
  group edgefast/bluetooth/source/impl/ethermind/common
    ../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/common/: addr.c
  group source/source/impl/ethermind/controller/configs/mbedtls
    ../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/controller/configs/mbedtls/: mbedtls_config_client.h
  group edgefast/bluetooth/source/impl/ethermind/crypto
    ../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/crypto/: bt_crypto.c bt_crypto.h
  group bt_ble/source/impl/ethermind/platform
    ../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/platform/: bt_ble_platform.c bt_ble_platform.h bt_ble_settings.c bt_ble_settings.h host_msd_fatfs.c host_msd_fatfs.h
  group bt_ble/source/impl/ethermind
    ../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/: bt_db_gen.c
  group edgefast/bluetooth/source/impl/ethermind/platform/configs
    ../../../../../../middleware/edgefast_bluetooth/source/impl/ethermind/platform/configs/: ffconf.h
  group edgefast/bluetooth/include/sys
    ../../../../../../middleware/edgefast_bluetooth/include/sys/: util.h util_internal.h util_loops.h util_macro.h printk.h check.h byteorder.h ring_buffer.h ffs.h slist.h dlist.h atomic.h
  group edgefast/bluetooth/include/zephyr
    ../../../../../../middleware/edgefast_bluetooth/include/zephyr/: types.h
  group edgefast/bluetooth/source/porting
    ../../../../../../middleware/edgefast_bluetooth/source/porting/: ring_buffer.c porting.c porting.h system_c.h utf8.c
  group edgefast/bluetooth/source/porting/errno
    ../../../../../../middleware/edgefast_bluetooth/source/porting/errno/: errno.h
  group edgefast/bluetooth/source/porting/fifo
    ../../../../../../middleware/edgefast_bluetooth/source/porting/fifo/: fifo.c fifo.h
  group edgefast/bluetooth/source/porting/lifo
    ../../../../../../middleware/edgefast_bluetooth/source/porting/lifo/: lifo.c lifo.h
  group edgefast/bluetooth/source/porting/poll
    ../../../../../../middleware/edgefast_bluetooth/source/porting/poll/: poll.c poll.h
  group edgefast/bluetooth/source/porting/queue
    ../../../../../../middleware/edgefast_bluetooth/source/porting/queue/: queue.c queue.h
  group edgefast/bluetooth/source/porting/sem
    ../../../../../../middleware/edgefast_bluetooth/source/porting/sem/: sem.c sem.h
  group edgefast/bluetooth/source/porting/slab
    ../../../../../../middleware/edgefast_bluetooth/source/porting/slab/: slab.c slab.h
  group edgefast/bluetooth/source/porting/slist
    ../../../../../../middleware/edgefast_bluetooth/source/porting/slist/: slist.c
  group edgefast/bluetooth/source/porting/spinlock
    ../../../../../../middleware/edgefast_bluetooth/source/porting/spinlock/: spinlock.h
  group edgefast/bluetooth/source/porting/thread
    ../../../../../../middleware/edgefast_bluetooth/source/porting/thread/: thread.c thread.h
  group edgefast/bluetooth/source/porting/work
    ../../../../../../middleware/edgefast_bluetooth/source/porting/work/: work.c work.h
  group edgefast/bluetooth/include/toolchain
    ../../../../../../middleware/edgefast_bluetooth/include/toolchain/: common.h gcc.h iar.h armcc.h
  group edgefast/bluetooth/include
    ../../../../../../middleware/edgefast_bluetooth/include/: toolchain.h
  group edgefast/bluetooth/source/porting/net
    ../../../../../../middleware/edgefast_bluetooth/source/porting/net/: buf.c buf_simple.c
  group edgefast/bluetooth/include/net
    ../../../../../../middleware/edgefast_bluetooth/include/net/: buf.h
  group edgefast/bluetooth/porting
    ../../../../../../middleware/edgefast_bluetooth/source/porting/: atomic_c.c
  group bt_ble/port/pal/mcux/bluetooth/controller
    ../../../../../../middleware/wireless/ethermind/port/pal/mcux/bluetooth/controller/: controller.h controller_wifi_nxp.c controller_hci_uart.h
  group edgefast/bluetooth/source/services
    ../../../../../../middleware/edgefast_bluetooth/source/services/: wu.c
  group edgefast/bluetooth/include/bluetooth/services
    ../../../../../../middleware/edgefast_bluetooth/include/bluetooth/services/: wu.h
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure
    ../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.c port.c portasm.c portasm.h portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/template/ARM_CM33_3_priority_bits
    ../../../../../../rtos/freertos/freertos-kernel/template/ARM_CM33_3_priority_bits/: FreeRTOSConfig_Gen.h
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
target wifi_cli_over_ble_wu_cm33_core0 flash_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT798SGFOB:cm33_core0 NXP
  pack: NXP.MIMXRT798S_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: wifi_cli_over_ble_wu_cm33_core0.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CFG_BLE, LPUART_RING_BUFFER_SIZE=1024U, PRINTF_ADVANCED_ENABLE=1, SDK_DEBUGCONSOLE_UART=1, SDK_OS_FREE_RTOS, USE_RTOS=1, APPL_USE_STANDARD_IO, CONFIG_ARM=1, DATA_SECTION_IS_CACHEABLE=1, EDGEFAST_BT_LITTLEFS_MFLASH, FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0, FSL_FEATURE_FLASH_PAGE_SIZE_BYTES=4096, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, GATT_CLIENT, GATT_DB, HAL_UART_ADAPTER_FIFO=1, IOT_WIFI_ENABLE_SAVE_NETWORK=1, LFS_NO_ERROR=1, LFS_NO_INTRINSICS=1, USB_HOST_CONFIG_BUFFER_PROPERTY_CACHEABLE=1, gMemManagerLight=0, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT798SGFOB_cm33_core0, MIMXRT798S_cm33_core0_SERIES, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING=1, OSA_USED, BOOT_HEADER_ENABLE=1, SERIAL_PORT_TYPE_UART=1, TIMER_PORT_TYPE_MRT=1, CONFIG_WIFI_BT_CMOBO_DNLD, CONFIG_WIFI_IND_DNLD=0, CONFIG_WIFI_IND_RESET=0, WIFI_IW612_BOARD_MURATA_2EL_M2, PSA_CRYPTO_DRIVER_ELS_PKC, MFLASH_FILE_BASEADDR=7340032, CONFIG_NXP_WIFI_SOFTAP_SUPPORT=1, PRINTF_FLOAT_ENABLE=1, SO_REUSE=1, MBEDTLS_CONFIG_FILE='\"mcux_mbedtls_config.h\"', SDIO_ENABLED=1, LFS_THREADSAFE=1, LOG_ENABLE_ASYNC_MODE=1, LOG_MAX_ARGUMENT_COUNT=10, LOG_ENABLE_OVERWRITE=1
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20080000 size 0x280000
  memory RVCT7: RAM 0x30080000 size 0x280000
  memory RVCT8: RAM 0x680000 size 0x100000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x10080000 size 0x280000
  scatter file: MIMXRT798Sxxxx_cm33_core0_flash.scf
  link misc: as above
