# Keil uVision project tflm_label_image_ext_mem_cm33_core0.uvprojx, settings and files
target tflm_label_image_ext_mem_cm33_core0 flash_debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT798SGFOB:cm33_core0 NXP
  pack: NXP.MIMXRT798S_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tflm_label_image_ext_mem_cm33_core0.out
  AfterMake: fromelf.exe --output "$Ltflm_label_image_ext_mem.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, SDK_DEBUGCONSOLE_UART, ARM_MATH_CM33, EXTERNAL_MEM=1, SCRATCH_WEIGHTS_SRAM_ADDR=0x20400000, __FPU_PRESENT=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT798SGFOB_cm33_core0, MIMXRT798S_cm33_core0_SERIES, BOOT_HEADER_ENABLE=1, SDK_I2C_BASED_COMPONENT_USED=1, TF_LITE_STATIC_MEMORY, KERNELS_OPTIMIZED_FOR_SPEED
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb -fno-exceptions
  c include: ..;../../../../flash_config;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MIMXRT798S;../../../../../../devices/MIMXRT798S/periph;../../../../../../devices/MIMXRT798S/drivers;../../../../../../devices/MIMXRT798S/utilities/debug_console_lite;../../../../../../devices/MIMXRT798S/utilities/str;../../../../../../components/uart;../../../../../../components/pmic/pca9422;../../../../../../middleware/eiq/tensorflow-lite;../../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include;../../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp;../../../../../../middleware/eiq/tensorflow-lite/third_party/kissfft;../../../../../../middleware/eiq/tensorflow-lite/third_party/ruy;../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn;../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn/Include;../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/neutron;../../../../../../middleware/eiq/tensorflow-lite/third_party/neutron/common/include;../../../../../../middleware/eiq/tensorflow-lite/third_party/neutron/driver/include
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT798SGFOB_cm33_core0, MIMXRT798S_cm33_core0_SERIES
  asm misc: -include ../mcux_config.h
  asm include: ..;../../../../flash_config;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MIMXRT798S;../../../../../../devices/MIMXRT798S/periph;../../../../../../devices/periph;../../../../../../devices/MIMXRT798S/drivers;../../../../../../devices/MIMXRT798S/utilities/debug_console_lite;../../../../../../devices/MIMXRT798S/utilities/str;../../../../../../components/uart;../../../../../../components/pmic/pca9422;../../../../../../middleware/eiq/tensorflow-lite;../../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include;../../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp;../../../../../../middleware/eiq/tensorflow-lite/third_party/kissfft;../../../../../../middleware/eiq/tensorflow-lite/third_party/ruy;../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn;../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn/Include;../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/neutron;../../../../../../middleware/eiq/tensorflow-lite/third_party/neutron/common/include;../../../../../../middleware/eiq/tensorflow-lite/third_party/neutron/driver/include
  library: MicroLIB
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20080000 size 0x280000
  memory RVCT7: RAM 0x30080000 size 0x280000
  memory RVCT8: RAM 0x680000 size 0x100000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x10080000 size 0x280000
  scatter file: MIMXRT798Sxxxx_cm33_core0_flash.scf
  link misc: ../../../../../../middleware/eiq/tensorflow-lite/lib/cm33/mdk/tflm.lib ../../../../../../middleware/eiq/tensorflow-lite/third_party/neutron/rt700/libNeutronDriver.a ../../../../../../middleware/eiq/tensorflow-lite/third_party/neutron/rt700/libNeutronFirmware.a --remove --predefine=-D__heap_size__=0x8000 --predefine=-D__stack_size__=0x2000 --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: get_top_n.cpp get_top_n.h model.cpp model.h demo_info.cpp demo_info.h timer.h timer.c main.cpp image.h board_init.h image_decode_raw.c image_utils.h image_load.c image_data.h demo_config.h labels.h grace_hopper.bmp output_postproc.h output_postproc.cpp xspi_octal_flash_edma_ops.c model_mobilenet_ops_npu.cpp model_data.h mobilenet_v1_1.0_224_int8_npu.tflite model_data.S pmic_support.c pmic_support.h mcux_config.h mcux_config.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv8m_mpu.h
  group device
    ../../../../../../devices/MIMXRT798S/: fsl_device_registers.h MIMXRT798S_cm33_core0.h MIMXRT798S_cm33_core0_COMMON.h MIMXRT798S_cm33_core0_features.h system_MIMXRT798S_cm33_core0.c system_MIMXRT798S_cm33_core0.h
  group device/periph
    ../../../../../../devices/MIMXRT798S/periph/: PERI_ADC.h PERI_AHBSC0.h PERI_AHBSC3.h PERI_AHBSC4.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CDOG.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CLKCTL2.h PERI_CLKCTL3.h PERI_CLKCTL4.h PERI_CMP.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUG_MAILBOX.h PERI_DMA.h PERI_ELS.h PERI_FLEXIO.h PERI_FREQME.h PERI_FRO.h PERI_GDET.h PERI_GLIKEY.h PERI_GPIO.h PERI_I2S.h PERI_I3C.h PERI_INPUTMUX0.h PERI_INPUTMUX1.h PERI_IOPCTL0.h PERI_IOPCTL1.h PERI_IOPCTL2.h PERI_ITRC.h PERI_JPEGDEC.h PERI_JPGDECWRP.h PERI_LCDIF.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_LP_FLEXCOMM.h PERI_MIPI_DSI_HOST.h PERI_MMU.h PERI_MRT.h PERI_MU.h PERI_NIC.h PERI_OCOTP.h PERI_OSC32KNP.h PERI_OSCCA.h PERI_OSTIMER.h PERI_PDM.h PERI_PINT.h PERI_PKC.h PERI_PMC.h PERI_PNGDEC.h PERI_PUF.h PERI_PVTS.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RSTCTL2.h PERI_RSTCTL3.h PERI_RSTCTL4.h PERI_RTC.h PERI_SCT.h PERI_SDADC.h PERI_SEMA42.h PERI_SLEEPCON0.h PERI_SLEEPCON1.h PERI_SYSCON0.h PERI_SYSCON1.h PERI_SYSCON2.h PERI_SYSCON3.h PERI_SYSCON4.h PERI_SYSPM.h PERI_TRNG.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_UTICK.h PERI_WWDT.h PERI_XCACHE.h PERI_XSPI.h
  group startup
    ../../../../../../devices/MIMXRT798S/: startup_MIMXRT798S_cm33_core0.c
  group drivers
    ../../../../../../devices/MIMXRT798S/drivers/: fsl_clock.c fsl_clock.h fsl_edma_soc.c fsl_edma_soc.h fsl_iopctl.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_edma.h fsl_edma_core.h fsl_edma.c fsl_glikey.h fsl_glikey.c fsl_gpio.h fsl_gpio.c fsl_lpflexcomm.h fsl_lpflexcomm.c fsl_lpuart.h fsl_lpuart.c fsl_lpi2c.h fsl_lpi2c.c fsl_xspi_edma.c fsl_xspi_edma.h fsl_xspi.c fsl_xspi.h
  group utilities
    ../../../../../../devices/MIMXRT798S/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
    ../../../../../../devices/MIMXRT798S/utilities/: fsl_memcpy.S
  group utilities/str
    ../../../../../../devices/MIMXRT798S/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MIMXRT798S/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/pmic/pca9422
    ../../../../../../components/pmic/pca9422/: fsl_pca9422.c fsl_pca9422.h
  group eiq/tensorflow-lite/tensorflow/compiler/mlir/lite/kernels/internal
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/compiler/mlir/lite/kernels/internal/: compatibility_macros.h
  group eiq/tensorflow-lite/tensorflow/compiler/mlir/lite/schema
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/compiler/mlir/lite/schema/: schema_generated.h schema_utils.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/: kernel_util.h op_macros.h padding.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/: common.h compatibility.h cppmath.h max.h min.h portable_tensor.h portable_tensor_utils.h quantization_util.h runtime_shape.h strided_slice_logic.h tensor_ctypes.h types.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/: add.h add_n.h arg_min_max.h batch_matmul.h batch_to_space_nd.h binary_function.h broadcast_args.h broadcast_to.h ceil.h comparisons.h concatenation.h conv.h cumsum.h depth_to_space.h depthwiseconv_float.h depthwiseconv_uint8.h dequantize.h div.h elu.h exp.h fill.h floor.h floor_div.h floor_mod.h fully_connected.h hard_swish.h l2normalization.h leaky_relu.h log_softmax.h logistic.h lstm_cell.h maximum_minimum.h mul.h neg.h pad.h pooling.h portable_tensor_utils.h portable_tensor_utils_impl.h prelu.h process_broadcast_shapes.h quantize.h reduce.h requantize.h resize_bilinear.h resize_nearest_neighbor.h round.h select.h slice.h softmax.h space_to_batch_nd.h space_to_depth.h strided_slice.h sub.h tanh.h transpose.h transpose_conv.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops/: add.h conv.h depthwise_conv.h fully_connected.h l2normalization.h logistic.h mean.h mul.h pooling.h tanh.h transpose_conv.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized/: neon_check.h
  group eiq/tensorflow-lite/tensorflow/lite/experimental/microfrontend/lib
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/experimental/microfrontend/lib/: bits.h fft.h fft_util.h filterbank.h filterbank_util.h frontend.h frontend_util.h kiss_fft_common.h kiss_fft_int16.h log_lut.h log_scale.h log_scale_util.h noise_reduction.h noise_reduction_util.h pcan_gain_control.h pcan_gain_control_util.h window.h window_util.h
  group eiq/tensorflow-lite/tensorflow/lite/schema
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/schema/: schema_generated.h schema_utils.h
  group eiq/tensorflow-lite/tensorflow/lite
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/: array.h builtin_op_data.h builtin_ops.h context_util.h portable_type_to_tflitetype.h
  group eiq/tensorflow-lite/tensorflow/lite/core/api
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/api/: error_reporter.h flatbuffer_conversions.h tensor_utils.h
  group eiq/tensorflow-lite/tensorflow/lite/core
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/: macros.h
  group eiq/tensorflow-lite/tensorflow/lite/core/c
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/c/: builtin_op_data.h c_api_types.h common.h
  group eiq/tensorflow-lite/tensorflow/lite/micro
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/: compatibility.h compression.h debug_log.h fake_micro_context.h flatbuffer_utils.h hexdump.h memory_helpers.h micro_allocation_info.h micro_allocator.h micro_arena_constants.h micro_common.h micro_context.h micro_graph.h micro_interpreter.h micro_interpreter_context.h micro_interpreter_graph.h micro_log.h micro_mutable_op_resolver.h micro_op_resolver.h micro_profiler.h micro_profiler_interface.h micro_resource_variable.h micro_time.h micro_utils.h mock_micro_graph.h recording_micro_allocator.h recording_micro_interpreter.h span.h static_vector.h system_setup.h test_helper_custom_ops.h test_helpers.h debug_log.cpp
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/: activation_utils.h activations.h add.h batch_matmul.h circular_buffer.h circular_buffer_flexbuffers_generated_data.h conv.h conv_test.h decompress.h depthwise_conv.h dequantize.h detection_postprocess_flexbuffers_generated_data.h ethosu.h fully_connected.h hard_swish.h kernel_runner.h kernel_util.h leaky_relu.h logical.h logistic.h lstm_eval.h lstm_eval_test.h lstm_shared.h maximum_minimum.h micro_ops.h micro_tensor_utils.h mul.h pad.h pooling.h prelu.h quantize.h reduce.h reshape.h softmax.h strided_slice.h sub.h svdf.h transpose.h transpose_conv.h unidirectional_sequence_lstm.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels/xtensa
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/xtensa/: lstm_eval.h xtensa.h xtensa_add.h xtensa_conv.h xtensa_depthwise_conv.h xtensa_fully_connected.h xtensa_pad.h xtensa_pooling.h xtensa_reduce.h xtensa_reshape.h xtensa_softmax.h xtensa_svdf.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/compression
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/compression/: metadata_saved.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/memory_planner
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.h linear_memory_planner.h memory_plan_struct.h micro_memory_planner.h non_persistent_buffer_planner_shim.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/arena_allocator
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/arena_allocator/: ibuffer_allocator.h non_persistent_arena_buffer_allocator.h persistent_arena_buffer_allocator.h recording_single_arena_buffer_allocator.h single_arena_buffer_allocator.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/tflite_bridge
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/tflite_bridge/: flatbuffer_conversions_bridge.h micro_error_reporter.h
  group eiq/tensorflow-lite/tensorflow/lite/c
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/c/: builtin_op_data.h c_api_types.h common.h
  group eiq/tensorflow-lite/tensorflow/compiler/mlir/lite/core/api
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/compiler/mlir/lite/core/api/: error_reporter.h
  group eiq/tensorflow-lite/tensorflow/compiler/mlir/lite/core/c
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/compiler/mlir/lite/core/c/: builtin_op_data.h tflite_types.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels/xtensa/hifimini
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/xtensa/hifimini/: fixedpoint_utils.h
  group eiq/tensorflow-lite/signal/micro/kernels
    ../../../../../../middleware/eiq/tensorflow-lite/signal/micro/kernels/: delay_flexbuffers_generated_data.h energy_flexbuffers_generated_data.h fft_auto_scale_kernel.h fft_flexbuffers_generated_data.h filter_bank_flexbuffers_generated_data.h filter_bank_log_flexbuffers_generated_data.h filter_bank_spectral_subtraction_flexbuffers_generated_data.h filter_bank_square_root.h framer_flexbuffers_generated_data.h irfft.h overlap_add_flexbuffers_generated_data.h pcan_flexbuffers_generated_data.h rfft.h stacker_flexbuffers_generated_data.h window_flexbuffers_generated_data.h
  group eiq/tensorflow-lite/signal/src
    ../../../../../../middleware/eiq/tensorflow-lite/signal/src/: circular_buffer.h complex.h energy.h fft_auto_scale.h filter_bank.h filter_bank_log.h filter_bank_spectral_subtraction.h filter_bank_square_root.h irfft.h log.h max_abs.h msb.h overlap_add.h pcan_argc_fixed.h rfft.h square_root.h window.h
  group eiq/tensorflow-lite/signal/src/kiss_fft_wrappers
    ../../../../../../middleware/eiq/tensorflow-lite/signal/src/kiss_fft_wrappers/: kiss_fft_common.h kiss_fft_float.h kiss_fft_int16.h kiss_fft_int32.h
  group eiq/tensorflow-lite/third_party/cmsis_nn/Include
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn/Include/: arm_nn_math_types.h arm_nn_tables.h arm_nn_types.h arm_nnfunctions.h arm_nnsupportfunctions.h
  group eiq/tensorflow-lite/third_party/cmsis_nn/Include/Internal
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn/Include/Internal/: arm_nn_compiler.h
  group eiq/tensorflow-lite/third_party/fft2d
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/fft2d/: fft.h fft2d.h
  group eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/: allocator.h array.h base.h buffer.h buffer_ref.h code_generator.h code_generators.h default_allocator.h detached_buffer.h file_manager.h flatbuffer_builder.h flatbuffers.h flatc.h flex_flat_util.h flexbuffers.h grpc.h hash.h idl.h minireflect.h reflection.h reflection_generated.h registry.h stl_emulation.h string.h struct.h table.h util.h vector.h vector_downward.h verifier.h
  group eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/pch
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/pch/: flatc_pch.h pch.h
  group eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint/: fixedpoint.h fixedpoint_neon.h fixedpoint_sse.h
  group eiq/tensorflow-lite/third_party/gemmlowp/internal
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/internal/: detect_platform.h
  group eiq/tensorflow-lite/third_party/ruy/ruy/profiler
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/ruy/profiler/: instrumentation.h
  group eiq/tensorflow-lite/third_party/kissfft
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/kissfft/: _kiss_fft_guts.h kiss_fft.h
  group eiq/tensorflow-lite/third_party/kissfft/tools
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/kissfft/tools/: kfc.h kiss_fftnd.h kiss_fftndr.h kiss_fftr.h
  group eiq/common/toolchains/mdk
    ../../../../../../middleware/eiq/common/toolchains/mdk/: retarget.c
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels/neutron
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/neutron/: neutron.cpp neutron.h
  group eiq/tensorflow-lite/third_party/neutron/common/include
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/neutron/common/include/: NeutronErrors.h
  group eiq/tensorflow-lite/third_party/neutron/driver/include
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/neutron/driver/include/: NeutronDriver.h
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
target tflm_label_image_ext_mem_cm33_core0 flash_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT798SGFOB:cm33_core0 NXP
  pack: NXP.MIMXRT798S_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: tflm_label_image_ext_mem_cm33_core0.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, SDK_DEBUGCONSOLE_UART, ARM_MATH_CM33, EXTERNAL_MEM=1, SCRATCH_WEIGHTS_SRAM_ADDR=0x20400000, __FPU_PRESENT=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT798SGFOB_cm33_core0, MIMXRT798S_cm33_core0_SERIES, BOOT_HEADER_ENABLE=1, SDK_I2C_BASED_COMPONENT_USED=1, TF_LITE_STATIC_MEMORY, KERNELS_OPTIMIZED_FOR_SPEED
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20080000 size 0x280000
  memory RVCT7: RAM 0x30080000 size 0x280000
  memory RVCT8: RAM 0x680000 size 0x100000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x10080000 size 0x280000
  scatter file: MIMXRT798Sxxxx_cm33_core0_flash.scf
  link misc: as above
