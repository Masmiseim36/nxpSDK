# Keil uVision project tflm_lib_cm33_core0.uvprojx, settings and files
target tflm_lib_cm33_core0 Debug (ARM-ADS)
  device: MIMXRT798SGFOB:cm33_core0 NXP
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU)  DSP
  output: tflm_lib_cm33_core0.a (library)
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, NDEBUG, CPU_MIMXRT798SGFOB_cm33_core0, MIMXRT798S_cm33_core0_SERIES, TF_LITE_STATIC_MEMORY, KERNELS_OPTIMIZED_FOR_SPEED, CMSIS_NN
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -mthumb  -fno-builtin -fno-exceptions
  c include: ../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../middleware/eiq/tensorflow-lite;../../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include;../../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp;../../../../../../middleware/eiq/tensorflow-lite/third_party/kissfft;../../../../../../middleware/eiq/tensorflow-lite/third_party/ruy;../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn;../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn/Include
  asm define: DEBUG, CPU_MIMXRT798SGFOB_cm33_core0, MIMXRT798S_cm33_core0_SERIES
  asm misc: -include ../mcux_config.h
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv8m_mpu.h
  group eiq/tensorflow-lite/tensorflow/compiler/mlir/lite/kernels/internal
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/compiler/mlir/lite/kernels/internal/: compatibility_macros.h
  group eiq/tensorflow-lite/tensorflow/compiler/mlir/lite/schema
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/compiler/mlir/lite/schema/: schema_generated.h schema_utils.h schema_utils.cpp
  group eiq/tensorflow-lite/tensorflow/lite/kernels
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/: kernel_util.h op_macros.h padding.h kernel_util.cpp
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/: common.h compatibility.h cppmath.h max.h min.h portable_tensor.h portable_tensor_utils.h quantization_util.h runtime_shape.h strided_slice_logic.h tensor_ctypes.h types.h portable_tensor_utils.cpp quantization_util.cpp common.cpp tensor_utils.cpp tensor_ctypes.cpp runtime_shape.cpp
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/: add.h add_n.h arg_min_max.h batch_matmul.h batch_to_space_nd.h binary_function.h broadcast_args.h broadcast_to.h ceil.h comparisons.h concatenation.h conv.h cumsum.h depth_to_space.h depthwiseconv_float.h depthwiseconv_uint8.h dequantize.h div.h elu.h exp.h fill.h floor.h floor_div.h floor_mod.h fully_connected.h hard_swish.h l2normalization.h leaky_relu.h log_softmax.h logistic.h lstm_cell.h maximum_minimum.h mul.h neg.h pad.h pooling.h portable_tensor_utils.h portable_tensor_utils_impl.h prelu.h process_broadcast_shapes.h quantize.h reduce.h requantize.h resize_bilinear.h resize_nearest_neighbor.h round.h select.h slice.h softmax.h space_to_batch_nd.h space_to_depth.h strided_slice.h sub.h tanh.h transpose.h transpose_conv.h portable_tensor_utils.cpp comparisons.cpp
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops/: add.h conv.h depthwise_conv.h fully_connected.h l2normalization.h logistic.h mean.h mul.h pooling.h tanh.h transpose_conv.h
  group eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized/: neon_check.h
  group eiq/tensorflow-lite/tensorflow/lite/experimental/microfrontend/lib
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/experimental/microfrontend/lib/: bits.h fft.h fft_util.h filterbank.h filterbank_util.h frontend.h frontend_util.h kiss_fft_common.h kiss_fft_int16.h log_lut.h log_scale.h log_scale_util.h noise_reduction.h noise_reduction_util.h pcan_gain_control.h pcan_gain_control_util.h window.h window_util.h
  group eiq/tensorflow-lite/tensorflow/lite/schema
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/schema/: schema_generated.h schema_utils.h
  group eiq/tensorflow-lite/tensorflow/lite
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/: array.h builtin_op_data.h builtin_ops.h context_util.h portable_type_to_tflitetype.h
  group eiq/tensorflow-lite/tensorflow/lite/core/api
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/api/: error_reporter.h flatbuffer_conversions.h tensor_utils.h tensor_utils.cpp flatbuffer_conversions.cpp
  group eiq/tensorflow-lite/tensorflow/lite/core
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/: macros.h
  group eiq/tensorflow-lite/tensorflow/lite/core/c
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/core/c/: builtin_op_data.h c_api_types.h common.h common.cpp
  group eiq/tensorflow-lite/tensorflow/lite/micro
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/: compatibility.h compression.h debug_log.h fake_micro_context.h flatbuffer_utils.h hexdump.h memory_helpers.h micro_allocation_info.h micro_allocator.h micro_arena_constants.h micro_common.h micro_context.h micro_graph.h micro_interpreter.h micro_interpreter_context.h micro_interpreter_graph.h micro_log.h micro_mutable_op_resolver.h micro_op_resolver.h micro_profiler.h micro_profiler_interface.h micro_resource_variable.h micro_time.h micro_utils.h mock_micro_graph.h recording_micro_allocator.h recording_micro_interpreter.h span.h static_vector.h system_setup.h test_helper_custom_ops.h test_helpers.h micro_context.cpp micro_resource_variable.cpp mock_micro_graph.cpp micro_profiler.cpp memory_helpers.cpp micro_log.cpp micro_interpreter_context.cpp micro_interpreter_graph.cpp system_setup.cpp test_helper_custom_ops.cpp micro_time.cpp test_helpers.cpp recording_micro_allocator.cpp micro_interpreter.cpp micro_allocator.cpp micro_allocation_info.cpp flatbuffer_utils.cpp micro_op_resolver.cpp fake_micro_context.cpp micro_utils.cpp
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/: activation_utils.h activations.h add.h batch_matmul.h circular_buffer.h circular_buffer_flexbuffers_generated_data.h conv.h conv_test.h decompress.h depthwise_conv.h dequantize.h detection_postprocess_flexbuffers_generated_data.h ethosu.h fully_connected.h hard_swish.h kernel_runner.h kernel_util.h leaky_relu.h logical.h logistic.h lstm_eval.h lstm_eval_test.h lstm_shared.h maximum_minimum.h micro_ops.h micro_tensor_utils.h mul.h pad.h pooling.h prelu.h quantize.h reduce.h reshape.h softmax.h strided_slice.h sub.h svdf.h transpose.h transpose_conv.h unidirectional_sequence_lstm.h if.cpp logical_common.cpp squeeze.cpp assign_variable.cpp read_variable.cpp unpack.cpp reshape_common.cpp logistic_common.cpp quantize_common.cpp dequantize.cpp zeros_like.cpp depth_to_space.cpp concatenation.cpp slice.cpp shape.cpp space_to_batch_nd.cpp strided_slice_common.cpp batch_to_space_nd.cpp round.cpp micro_tensor_utils.cpp squared_difference.cpp split_v.cpp split.cpp ceil.cpp mul_common.cpp select.cpp log_softmax.cpp add_n.cpp arg_min_max.cpp activations.cpp broadcast_to.cpp pack.cpp while.cpp fully_connected_common.cpp resize_nearest_neighbor.cpp floor_mod.cpp gather_nd.cpp embedding_lookup.cpp expand_dims.cpp pooling_common.cpp fill.cpp conv_common.cpp l2_pool_2d.cpp space_to_depth.cpp elu.cpp depthwise_conv_common.cpp logical.cpp kernel_util.cpp dequantize_common.cpp gather.cpp tanh.cpp softmax_common.cpp call_once.cpp hard_swish.cpp comparisons.cpp svdf_common.cpp hard_swish_common.cpp var_handle.cpp circular_buffer.cpp circular_buffer_common.cpp broadcast_args.cpp floor_div.cpp elementwise.cpp prelu.cpp detection_postprocess.cpp kernel_runner.cpp add_common.cpp mirror_pad.cpp reduce_common.cpp prelu_common.cpp lstm_eval_common.cpp floor.cpp cumsum.cpp leaky_relu_common.cpp div.cpp activations_common.cpp sub_common.cpp exp.cpp neg.cpp cast.cpp resize_bilinear.cpp l2norm.cpp batch_matmul_common.cpp circular_buffer_flexbuffers_generated_data.cpp decompress.cpp decompress_common.cpp pad_common.cpp transpose_common.cpp sub.cpp logistic.cpp reduce.cpp strided_slice.cpp quantize.cpp lstm_eval.cpp reshape.cpp leaky_relu.cpp
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels/xtensa
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/xtensa/: lstm_eval.h xtensa.h xtensa_add.h xtensa_conv.h xtensa_depthwise_conv.h xtensa_fully_connected.h xtensa_pad.h xtensa_pooling.h xtensa_reduce.h xtensa_reshape.h xtensa_softmax.h xtensa_svdf.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/compression
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/compression/: metadata_saved.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/memory_planner
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.h linear_memory_planner.h memory_plan_struct.h micro_memory_planner.h non_persistent_buffer_planner_shim.h linear_memory_planner.cpp greedy_memory_planner.cpp non_persistent_buffer_planner_shim.cpp
  group eiq/tensorflow-lite/tensorflow/lite/micro/arena_allocator
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/arena_allocator/: ibuffer_allocator.h non_persistent_arena_buffer_allocator.h persistent_arena_buffer_allocator.h recording_single_arena_buffer_allocator.h single_arena_buffer_allocator.h single_arena_buffer_allocator.cpp non_persistent_arena_buffer_allocator.cpp persistent_arena_buffer_allocator.cpp recording_single_arena_buffer_allocator.cpp
  group eiq/tensorflow-lite/tensorflow/lite/micro/tflite_bridge
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/tflite_bridge/: flatbuffer_conversions_bridge.h micro_error_reporter.h flatbuffer_conversions_bridge.cpp micro_error_reporter.cpp
  group eiq/tensorflow-lite/tensorflow/lite/c
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/c/: builtin_op_data.h c_api_types.h common.h
  group eiq/tensorflow-lite/tensorflow/compiler/mlir/lite/core/api
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/compiler/mlir/lite/core/api/: error_reporter.h error_reporter.cpp
  group eiq/tensorflow-lite/tensorflow/compiler/mlir/lite/core/c
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/compiler/mlir/lite/core/c/: builtin_op_data.h tflite_types.h
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels/xtensa/hifimini
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/xtensa/hifimini/: fixedpoint_utils.h
  group eiq/tensorflow-lite/signal/micro/kernels
    ../../../../../../middleware/eiq/tensorflow-lite/signal/micro/kernels/: delay_flexbuffers_generated_data.h energy_flexbuffers_generated_data.h fft_auto_scale_kernel.h fft_flexbuffers_generated_data.h filter_bank_flexbuffers_generated_data.h filter_bank_log_flexbuffers_generated_data.h filter_bank_spectral_subtraction_flexbuffers_generated_data.h filter_bank_square_root.h framer_flexbuffers_generated_data.h irfft.h overlap_add_flexbuffers_generated_data.h pcan_flexbuffers_generated_data.h rfft.h stacker_flexbuffers_generated_data.h window_flexbuffers_generated_data.h delay.cpp energy.cpp fft_auto_scale_kernel.cpp fft_auto_scale_common.cpp filter_bank.cpp filter_bank_log.cpp filter_bank_square_root.cpp filter_bank_square_root_common.cpp filter_bank_spectral_subtraction.cpp stacker.cpp pcan.cpp framer.cpp irfft.cpp overlap_add.cpp rfft.cpp window.cpp
  group eiq/tensorflow-lite/signal/src
    ../../../../../../middleware/eiq/tensorflow-lite/signal/src/: circular_buffer.h complex.h energy.h fft_auto_scale.h filter_bank.h filter_bank_log.h filter_bank_spectral_subtraction.h filter_bank_square_root.h irfft.h log.h max_abs.h msb.h overlap_add.h pcan_argc_fixed.h rfft.h square_root.h window.h circular_buffer.cpp energy.cpp fft_auto_scale.cpp filter_bank.cpp filter_bank_log.cpp filter_bank_spectral_subtraction.cpp filter_bank_square_root.cpp irfft_float.cpp irfft_int16.cpp irfft_int32.cpp log.cpp max_abs.cpp msb_32.cpp msb_64.cpp overlap_add.cpp pcan_argc_fixed.cpp rfft_float.cpp rfft_int16.cpp rfft_int32.cpp square_root_32.cpp square_root_64.cpp window.cpp
  group eiq/tensorflow-lite/signal/src/kiss_fft_wrappers
    ../../../../../../middleware/eiq/tensorflow-lite/signal/src/kiss_fft_wrappers/: kiss_fft_common.h kiss_fft_float.h kiss_fft_int16.h kiss_fft_int32.h kiss_fft_float.cpp kiss_fft_int16.cpp kiss_fft_int32.cpp
  group eiq/tensorflow-lite/third_party/cmsis_nn/Include
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn/Include/: arm_nn_math_types.h arm_nn_tables.h arm_nn_types.h arm_nnfunctions.h arm_nnsupportfunctions.h
  group eiq/tensorflow-lite/third_party/cmsis_nn/Include/Internal
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn/Include/Internal/: arm_nn_compiler.h
  group eiq/tensorflow-lite/third_party/fft2d
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/fft2d/: fft.h fft2d.h fftsg.c
  group eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/: allocator.h array.h base.h buffer.h buffer_ref.h code_generator.h code_generators.h default_allocator.h detached_buffer.h file_manager.h flatbuffer_builder.h flatbuffers.h flatc.h flex_flat_util.h flexbuffers.h grpc.h hash.h idl.h minireflect.h reflection.h reflection_generated.h registry.h stl_emulation.h string.h struct.h table.h util.h vector.h vector_downward.h verifier.h
  group eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/pch
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/pch/: flatc_pch.h pch.h
  group eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint/: fixedpoint.h fixedpoint_neon.h fixedpoint_sse.h
  group eiq/tensorflow-lite/third_party/gemmlowp/internal
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/gemmlowp/internal/: detect_platform.h
  group eiq/tensorflow-lite/third_party/ruy/ruy/profiler
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/ruy/ruy/profiler/: instrumentation.h
  group eiq/tensorflow-lite/third_party/kissfft
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/kissfft/: _kiss_fft_guts.h kiss_fft.h kiss_fft.c kiss_fft.c
  group eiq/tensorflow-lite/third_party/kissfft/tools
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/kissfft/tools/: kfc.h kiss_fftnd.h kiss_fftndr.h kiss_fftr.h kfc.c kiss_fastfir.c kiss_fftnd.c kiss_fftndr.c kiss_fftr.c kfc.c kiss_fastfir.c kiss_fftnd.c kiss_fftndr.c kiss_fftr.c
  group eiq/common/toolchains/mdk
    ../../../../../../middleware/eiq/common/toolchains/mdk/: retarget.c
  group eiq/tensorflow-lite/tensorflow/lite/micro/kernels/cmsis_nn
    ../../../../../../middleware/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/cmsis_nn/: depthwise_conv.cpp pooling.cpp fully_connected.cpp add.cpp mul.cpp conv.cpp softmax.cpp unidirectional_sequence_lstm.cpp svdf.cpp batch_matmul.cpp maximum_minimum.cpp pad.cpp transpose.cpp transpose_conv.cpp
  group eiq/tensorflow-lite/third_party/cmsis_nn/Source/LSTMFunctions
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn/Source/LSTMFunctions/: arm_lstm_unidirectional_s16.c arm_lstm_unidirectional_s8.c
  group eiq/tensorflow-lite/third_party/cmsis_nn/Source/BasicMathFunctions
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn/Source/BasicMathFunctions/: arm_elementwise_mul_acc_s16.c arm_elementwise_add_s16.c arm_elementwise_mul_s16_batch_offset.c arm_elementwise_add_s8.c arm_elementwise_mul_s16_s8.c arm_elementwise_mul_s8.c arm_elementwise_mul_s16.c arm_minimum_s8.c arm_maximum_s8.c
  group eiq/tensorflow-lite/third_party/cmsis_nn/Source/SVDFunctions
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn/Source/SVDFunctions/: arm_svdf_get_buffer_sizes_s8.c arm_svdf_s8.c arm_svdf_state_s16_s8.c
  group eiq/tensorflow-lite/third_party/cmsis_nn/Source/ConcatenationFunctions
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn/Source/ConcatenationFunctions/: arm_concatenation_s8_z.c arm_concatenation_s8_w.c arm_concatenation_s8_x.c arm_concatenation_s8_y.c
  group eiq/tensorflow-lite/third_party/cmsis_nn/Source/ReshapeFunctions
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn/Source/ReshapeFunctions/: arm_reshape_s8.c
  group eiq/tensorflow-lite/third_party/cmsis_nn/Source/ConvolutionFunctions
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn/Source/ConvolutionFunctions/: arm_transpose_conv_s8.c arm_transpose_conv_wrapper_s8.c arm_convolve_wrapper_s4.c arm_nn_mat_mult_kernel_row_offset_s8_s16.c arm_convolve_get_buffer_sizes_s4.c arm_convolve_wrapper_s8.c arm_convolve_wrapper_s16.c arm_convolve_get_buffer_sizes_s8.c arm_depthwise_conv_s4.c arm_nn_mat_mult_kernel_s16.c arm_convolve_s4.c arm_depthwise_conv_fast_s16.c arm_convolve_1x1_s4.c arm_nn_mat_mult_s8.c arm_depthwise_conv_wrapper_s8.c arm_convolve_1x1_s4_fast.c arm_depthwise_conv_3x3_s8.c arm_depthwise_conv_s8.c arm_nn_mat_mult_kernel_s8_s16.c arm_convolve_get_buffer_sizes_s16.c arm_convolve_s16.c arm_depthwise_conv_get_buffer_sizes_s16.c arm_nn_mat_mult_kernel_s4_s16.c arm_convolve_1_x_n_s4.c arm_convolve_1_x_n_s8.c arm_depthwise_conv_wrapper_s16.c arm_nn_depthwise_conv_s8_core.c arm_depthwise_conv_s8_opt.c arm_depthwise_conv_s4_opt.c arm_convolve_1x1_s8.c arm_depthwise_conv_get_buffer_sizes_s4.c arm_convolve_1x1_s8_fast.c arm_depthwise_conv_wrapper_s4.c arm_depthwise_conv_s16.c arm_transpose_conv_get_buffer_sizes_s8.c arm_depthwise_conv_get_buffer_sizes_s8.c arm_convolve_s8.c
  group eiq/tensorflow-lite/third_party/cmsis_nn/Source/FullyConnectedFunctions
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn/Source/FullyConnectedFunctions/: arm_fully_connected_s16.c arm_fully_connected_wrapper_s8.c arm_fully_connected_per_channel_s8.c arm_batch_matmul_s16.c arm_batch_matmul_s8.c arm_vector_sum_s8_s64.c arm_fully_connected_get_buffer_sizes_s8.c arm_fully_connected_s4.c arm_fully_connected_s8.c arm_vector_sum_s8.c arm_fully_connected_get_buffer_sizes_s16.c
  group eiq/tensorflow-lite/third_party/cmsis_nn/Source/ActivationFunctions
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn/Source/ActivationFunctions/: arm_relu_q7.c arm_relu_q15.c arm_nn_activation_s16.c arm_relu6_s8.c
  group eiq/tensorflow-lite/third_party/cmsis_nn/Source/NNSupportFunctions
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn/Source/NNSupportFunctions/: arm_nn_vec_mat_mult_t_per_ch_s8.c arm_nn_lstm_step_s16.c arm_nn_mat_mul_core_1x_s8.c arm_q7_to_q15_with_offset.c arm_s8_to_s16_unordered_with_offset.c arm_nn_mat_mult_nt_t_s8_s32.c arm_nn_lstm_calculate_gate_s8_s16.c arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nn_mat_mult_nt_t_s16.c arm_nn_mat_mul_core_4x_s8.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_mat_mul_core_1x_s4.c arm_nn_vec_mat_mult_t_svdf_s8.c arm_nn_depthwise_conv_nt_t_s16.c arm_nntables.c arm_nn_mat_mult_nt_t_s8.c arm_nn_mat_mult_nt_t_s4.c arm_nn_lstm_step_s8.c arm_nn_vec_mat_mul_result_acc_s16.c arm_nn_vec_mat_mult_t_s16.c arm_nn_vec_mat_mult_t_s8.c arm_nn_lstm_calculate_gate_s16.c arm_nn_depthwise_conv_nt_t_s4.c arm_nn_vec_mat_mul_result_acc_s8_s16.c arm_nn_vec_mat_mult_t_s4.c arm_nn_transpose_conv_row_s8_s32.c arm_nn_vec_mat_mult_t_s16_s16.c
  group eiq/tensorflow-lite/third_party/cmsis_nn/Source/SoftmaxFunctions
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn/Source/SoftmaxFunctions/: arm_softmax_u8.c arm_nn_softmax_common_s8.c arm_softmax_s8.c arm_softmax_s16.c arm_softmax_s8_s16.c
  group eiq/tensorflow-lite/third_party/cmsis_nn/Source/PoolingFunctions
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn/Source/PoolingFunctions/: arm_max_pool_s16.c arm_avgpool_s16.c arm_avgpool_s8.c arm_avgpool_get_buffer_sizes_s8.c arm_avgpool_get_buffer_sizes_s16.c arm_max_pool_s8.c
  group eiq/tensorflow-lite/third_party/cmsis_nn/Source/PadFunctions
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn/Source/PadFunctions/: arm_pad_s8.c
  group eiq/tensorflow-lite/third_party/cmsis_nn/Source/TransposeFunctions
    ../../../../../../middleware/eiq/tensorflow-lite/third_party/cmsis_nn/Source/TransposeFunctions/: arm_transpose_s8.c
  group source
    ../: mcux_config.h mcux_config.h mcux_config.h
  group doc
    ../: readme.md examples_shared_readme.md
target tflm_lib_cm33_core0 Release (ARM-ADS)
  device: MIMXRT798SGFOB:cm33_core0 NXP
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU)  DSP
  output: tflm_lib_cm33_core0.a (library)
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT798SGFOB_cm33_core0, MIMXRT798S_cm33_core0_SERIES, TF_LITE_STATIC_MEMORY, KERNELS_OPTIMIZED_FOR_SPEED, CMSIS_NN
  c misc: as above
  c include: as above
  asm define: NDEBUG, CPU_MIMXRT798SGFOB_cm33_core0, MIMXRT798S_cm33_core0_SERIES
  asm misc: -include ../mcux_config.h
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
