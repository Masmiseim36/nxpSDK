# IAR project emwin_gui_demo_cm33_core0.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT798S_M33_0 NXP MIMXRT798S_M33_0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; MCUX_DBI_LEGACY=0; DBI_USE_MIPI_PANEL=1; SDK_DEBUGCONSOLE_UART=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT798SGFOB_cm33_core0; MIMXRT798S_cm33_core0_SERIES; BOOT_HEADER_ENABLE=1
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MIMXRT798S/drivers; ../../../../../../middleware/emwin/emWin_header; ../../../../../../middleware/emwin/emWin_Config; ../../../../flash_config; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT798S; ../../../../../../devices/MIMXRT798S/periph; ../../../../../../devices/MIMXRT798S/utilities/debug_console_lite; ../../../../../../devices/MIMXRT798S/utilities/str; ../../../../../../components/uart; ../../../../../../components/video; ../../../../../../components/video/display/dc; ../../../../../../components/video/display; ../../../../../../components/video/display/dbi; ../../../../../../components/video/display/dbi/flexio; ../../../../../../components/video/display/dbi/lcdif; ../../../../../../components/video/display/dc/dsi_cmd; ../../../../../../components/video/display/dc/lcdif; ../../../../../../components/video/display/dc/dbi; ../../../../../../components/video/display/mipi_dsi_cmd; ../../../../../../components/video/display/hx8394; ../../../../../../components/video/display/rm68191; ../../../../../../components/video/display/rm68200; ../../../../../../components/video/display/rm67162; ../../../../../../components/video/display/co5300; ../../../../../../components/video/display/rpi; ../../../../../../components/touch/gt911; ../../../../../../components/touch/ft3267; ../../../../../../components/touch/ft5406_rt; ../../../../../../components/touch/tma525b; ../../../../../../components/display/ssd1963
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT798SGFOB_cm33_core0; MIMXRT798S_cm33_core0_SERIES
  AARM.AUserIncludes: ..; ../../../../../../devices/MIMXRT798S/drivers; ../../../../flash_config; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT798S; ../../../../../../devices/MIMXRT798S/periph; ../../../../../../devices/periph; ../../../../../../devices/MIMXRT798S/utilities/debug_console_lite; ../../../../../../devices/MIMXRT798S/utilities/str; ../../../../../../components/uart; ../../../../../../components/video; ../../../../../../components/video/display/dc; ../../../../../../components/video/display; ../../../../../../components/video/display/dbi; ../../../../../../components/video/display/dbi/flexio; ../../../../../../components/video/display/dbi/lcdif; ../../../../../../components/video/display/dc/dsi_cmd; ../../../../../../components/video/display/dc/lcdif; ../../../../../../components/video/display/dc/dbi; ../../../../../../components/video/display/mipi_dsi_cmd; ../../../../../../components/video/display/hx8394; ../../../../../../components/video/display/rm68191; ../../../../../../components/video/display/rm68200; ../../../../../../components/video/display/rm67162; ../../../../../../components/video/display/co5300; ../../../../../../components/video/display/rpi; ../../../../../../components/touch/gt911; ../../../../../../components/touch/ft3267; ../../../../../../components/touch/ft5406_rt; ../../../../../../components/touch/tma525b; ../../../../../../components/display/ssd1963
  AARM.PreInclude: ../mcux_config.h
  OBJCOPY.OOCOutputFile: emwin_gui_demo.bin
  ILINK.IlinkOutputFile: emwin_gui_demo_cm33_core0.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000
  ILINK.IlinkIcfFile: MIMXRT798Sxxxx_cm33_core0_ram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../middleware/emwin/emWin_library/IAR/emWin_M33.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: MIMXRT798Sxxxx_cm33_core0_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; MCUX_DBI_LEGACY=0; DBI_USE_MIPI_PANEL=1; SDK_DEBUGCONSOLE_UART=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT798SGFOB_cm33_core0; MIMXRT798S_cm33_core0_SERIES; BOOT_HEADER_ENABLE=1
  ICCARM.CCOptLevel: 3
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT798Sxxxx_cm33_core0_flash.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h board.h board.c clock_config.h clock_config.c
  group source
    ../: emwin_gui_demo.c emwin_support.c emwin_support.h pin_mux.c pin_mux.h hardware_init.c app.h display_support.h display_support.c mcux_config.h mcux_config.h mcux_config.h
  group drivers
    ../../../../../../devices/MIMXRT798S/drivers/: fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.c fsl_clock.h fsl_edma_soc.c fsl_edma_soc.h fsl_inputmux_connections.h fsl_iopctl.h fsl_soc_mipi_dsi.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_cache.c fsl_cache.h fsl_edma.h fsl_edma_core.h fsl_edma.c fsl_flexio.c fsl_flexio.h fsl_flexio_mculcd_edma.c fsl_flexio_mculcd_edma.h fsl_flexio_mculcd.c fsl_flexio_mculcd.h fsl_glikey.h fsl_glikey.c fsl_gpio.h fsl_gpio.c fsl_inputmux.h fsl_inputmux.c fsl_lcdif.h fsl_lcdif.c fsl_lpflexcomm.h fsl_lpflexcomm.c fsl_lpuart.h fsl_lpuart.c fsl_lpi2c.h fsl_lpi2c.c fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_xspi.c fsl_xspi.h
  group emwin/emWin_header
    ../../../../../../middleware/emwin/emWin_header/: AppWizard.h BUTTON.h BUTTON_Private.h CALENDAR.h CHECKBOX.h CHECKBOX_Private.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Type.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h GAUGE.h GAUGE_Private.h GRAPH.h GRAPH_Private.h GUI.h GUIDRV_BitPlains.h GUIDRV_DCache.h GUIDRV_DCache_Private.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_FlexColor_Private.h GUIDRV_IST3088.h GUIDRV_IST3088_Private.h GUIDRV_Lin.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_Null.h GUIDRV_S1D13748.h GUIDRV_S1D13748_Private.h GUIDRV_S1D13781.h GUIDRV_S1D13781_Private.h GUIDRV_S1D15G00.h GUIDRV_SH_MEM.h GUIDRV_SH_MEM_Private.h GUIDRV_SLin.h GUIDRV_SLin_Private.h GUIDRV_SPage.h GUIDRV_SPage_Private.h GUIDRV_SSD1926.h GUIDRV_SSD1926_Private.h GUITDRV_ADS7846.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GCache_Private.h GUI_GIF_Private.h GUI_JPEG_Private.h GUI_Private.h GUI_Resource.h GUI_SIM_Win32.h GUI_SPRITE_Private.h GUI_SPY_Private.h GUI_SVG_Global.h GUI_SVG_NanoVG.h GUI_SVG_NemaVG.h GUI_SVG_OpenVG.h GUI_SVG_Private.h GUI_SVG_VGLite.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_Type.h GUI_VNC.h GUI_Version.h GUI__BiDi_Brackets.h GUI__BiDi_Types.h Global.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h IMAGE.h IMAGE_Private.h IP_FS.h JPEGConf.h KEYBOARD.h KEYBOARD_Private.h KNOB.h KNOB_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LCD_X_8080_16.h LCD_X_8080_8.h LCD_X_I2C.h LCD_X_Serial_3Pin.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MOVIE.h MOVIE_Private.h MULTIEDIT.h MULTIEDIT_Private.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h QRCODE.h QRCODE_Private.h RADIO.h RADIO_Private.h ROTARY.h ROTARY_Private.h SCROLLBAR.h SCROLLBAR_Private.h SCROLLER.h SCROLLER_Private.h SEGGER.h SLIDER.h SLIDER_Private.h SPINBOX.h SPINBOX_Private.h SWIPELIST.h SWIPELIST_Private.h SWITCH.h SWITCH_Private.h TEXT.h TEXT_Private.h TICKER.h TICKER_Private.h TREEVIEW.h TREEVIEW_Private.h WHEEL.h WHEEL_Private.h WIDGET.h WIDGET_ID.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h WM_Layout.h
  group emwin/emWin_Config
    ../../../../../../middleware/emwin/emWin_Config/: GUIConf.h LCDConf.h
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group device
    ../../../../../../devices/MIMXRT798S/: fsl_device_registers.h MIMXRT798S_cm33_core0.h MIMXRT798S_cm33_core0_COMMON.h MIMXRT798S_cm33_core0_features.h system_MIMXRT798S_cm33_core0.c system_MIMXRT798S_cm33_core0.h
  group device/periph
    ../../../../../../devices/MIMXRT798S/periph/: PERI_ADC.h PERI_AHBSC0.h PERI_AHBSC3.h PERI_AHBSC4.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CDOG.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CLKCTL2.h PERI_CLKCTL3.h PERI_CLKCTL4.h PERI_CMP.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUG_MAILBOX.h PERI_DMA.h PERI_ELS.h PERI_FLEXIO.h PERI_FREQME.h PERI_FRO.h PERI_GDET.h PERI_GLIKEY.h PERI_GPIO.h PERI_I2S.h PERI_I3C.h PERI_INPUTMUX0.h PERI_INPUTMUX1.h PERI_IOPCTL0.h PERI_IOPCTL1.h PERI_IOPCTL2.h PERI_ITRC.h PERI_JPEGDEC.h PERI_JPGDECWRP.h PERI_LCDIF.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_LP_FLEXCOMM.h PERI_MIPI_DSI_HOST.h PERI_MMU.h PERI_MRT.h PERI_MU.h PERI_NIC.h PERI_OCOTP.h PERI_OSC32KNP.h PERI_OSCCA.h PERI_OSTIMER.h PERI_PDM.h PERI_PINT.h PERI_PKC.h PERI_PMC.h PERI_PNGDEC.h PERI_PUF.h PERI_PVTS.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RSTCTL2.h PERI_RSTCTL3.h PERI_RSTCTL4.h PERI_RTC.h PERI_SCT.h PERI_SDADC.h PERI_SEMA42.h PERI_SLEEPCON0.h PERI_SLEEPCON1.h PERI_SYSCON0.h PERI_SYSCON1.h PERI_SYSCON2.h PERI_SYSCON3.h PERI_SYSCON4.h PERI_SYSPM.h PERI_TRNG.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_UTICK.h PERI_WWDT.h PERI_XCACHE.h PERI_XSPI.h
  group startup
    ../../../../../../devices/MIMXRT798S/: startup_MIMXRT798S_cm33_core0.c
  group utilities
    ../../../../../../devices/MIMXRT798S/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../../devices/MIMXRT798S/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MIMXRT798S/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group video
    ../../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../../components/video/display/dc/: fsl_dc_fb.h
    ../../../../../../components/video/display/: fsl_display.h
    ../../../../../../components/video/display/dbi/: fsl_dbi.h fsl_dbi.c
    ../../../../../../components/video/display/dbi/flexio/: fsl_dbi_flexio_edma.h fsl_dbi_flexio_edma.c
    ../../../../../../components/video/display/dbi/lcdif/: fsl_dbi_lcdif.h fsl_dbi_lcdif.c
    ../../../../../../components/video/display/dc/dsi_cmd/: fsl_dc_fb_dsi_cmd.h fsl_dc_fb_dsi_cmd.c
    ../../../../../../components/video/display/dc/lcdif/: fsl_dc_fb_lcdif.h fsl_dc_fb_lcdif.c
    ../../../../../../components/video/display/dc/dbi/: fsl_dc_fb_dbi.h fsl_dc_fb_dbi.c
    ../../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
    ../../../../../../components/video/display/hx8394/: fsl_hx8394.h fsl_hx8394.c
    ../../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../../components/video/display/rm67162/: fsl_rm67162.h fsl_rm67162.c
    ../../../../../../components/video/display/co5300/: fsl_co5300.h fsl_co5300.c
    ../../../../../../components/video/display/rpi/: fsl_rpi.h fsl_rpi.c
  group touchpanel
    ../../../../../../components/touch/gt911/: fsl_gt911.h fsl_gt911.c
    ../../../../../../components/touch/ft3267/: fsl_ft3267.h fsl_ft3267.c
    ../../../../../../components/touch/ft5406_rt/: fsl_ft5406_rt.h fsl_ft5406_rt.c
    ../../../../../../components/touch/tma525b/: fsl_tma525b.h fsl_tma525b.c
  group lcdc
    ../../../../../../components/display/ssd1963/: fsl_ssd1963.h fsl_ssd1963.c
  group doc
    ../: readme.md
