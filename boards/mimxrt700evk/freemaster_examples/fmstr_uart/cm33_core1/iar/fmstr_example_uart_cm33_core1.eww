<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>fmstr_example_uart_cm33_core1</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>fmstr_example_uart_cm33_core1</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>fmstr_example_uart_cm33_core1</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>fmstr_example_uart_cm33_core1</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/fmstr_example_uart_cm33_core1.ewp</path>
  </project>
</workspace>
