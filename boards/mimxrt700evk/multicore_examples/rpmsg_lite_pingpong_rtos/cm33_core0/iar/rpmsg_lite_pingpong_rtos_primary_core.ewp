# IAR project rpmsg_lite_pingpong_rtos_primary_core.ewp, settings and files
configuration flash_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT798S_M33_0 NXP MIMXRT798S_M33_0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CORE1_IMAGE_COPY_TO_RAM; __USE_SHMEM; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT798SGFOB_cm33_core0; MIMXRT798S_cm33_core0_SERIES; BOOT_HEADER_ENABLE=1; MULTICORE_APP=1; SDK_OS_FREE_RTOS
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../flash_config; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT798S; ../../../../../../devices/MIMXRT798S/periph; ../../../../../../devices/MIMXRT798S/drivers; ../../../../../../devices/MIMXRT798S/utilities/debug_console_lite; ../../../../../../devices/MIMXRT798S/utilities/str; ../../../../../../components/uart; ../../../../../../middleware/multicore/rpmsg-lite/lib/include; ../../../../../../middleware/multicore/rpmsg-lite/lib/include/environment/freertos; ../../../../../../middleware/multicore/rpmsg-lite/lib/include/platform/imxrt700_m33; ../../../../../../middleware/multicore/mcmgr/inc; ../../../../../../middleware/multicore/mcmgr/inc/platform/imxrt700; ../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../../rtos/freertos/freertos-kernel/template
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT798SGFOB_cm33_core0; MIMXRT798S_cm33_core0_SERIES
  AARM.AUserIncludes: ..; ../../../../flash_config; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT798S; ../../../../../../devices/MIMXRT798S/periph; ../../../../../../devices/periph; ../../../../../../devices/MIMXRT798S/drivers; ../../../../../../devices/MIMXRT798S/utilities/debug_console_lite; ../../../../../../devices/MIMXRT798S/utilities/str; ../../../../../../components/uart; ../../../../../../middleware/multicore/rpmsg-lite/lib/include; ../../../../../../middleware/multicore/rpmsg-lite/lib/include/environment/freertos; ../../../../../../middleware/multicore/rpmsg-lite/lib/include/platform/imxrt700_m33; ../../../../../../middleware/multicore/mcmgr/inc; ../../../../../../middleware/multicore/mcmgr/inc/platform/imxrt700; ../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../../rtos/freertos/freertos-kernel/template
  AARM.PreInclude: ../mcux_config.h
  ILINK.IlinkOutputFile: rpmsg_lite_pingpong_rtos_primary_core.out
  ILINK.IlinkKeepSymbols: _core1_image; _core1_image
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __use_shmem__=1; __multicore__=1
  ILINK.IlinkIcfFile: MIMXRT798Sxxxx_cm33_core0_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CORE1_IMAGE_COPY_TO_RAM; __USE_SHMEM; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT798SGFOB_cm33_core0; MIMXRT798S_cm33_core0_SERIES; BOOT_HEADER_ENABLE=1; MULTICORE_APP=1; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  group source
    ../: dsp_config.h main.c dsp_support.c dsp_support.h FreeRTOSConfig_Gen.h mcux_config.h mcux_config.h mcux_config.h rpmsg_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group device
    ../../../../../../devices/MIMXRT798S/: fsl_device_registers.h MIMXRT798S_cm33_core0.h MIMXRT798S_cm33_core0_COMMON.h MIMXRT798S_cm33_core0_features.h system_MIMXRT798S_cm33_core0.c system_MIMXRT798S_cm33_core0.h
  group device/periph
    ../../../../../../devices/MIMXRT798S/periph/: PERI_ADC.h PERI_AHBSC0.h PERI_AHBSC3.h PERI_AHBSC4.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CDOG.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CLKCTL2.h PERI_CLKCTL3.h PERI_CLKCTL4.h PERI_CMP.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUG_MAILBOX.h PERI_DMA.h PERI_ELS.h PERI_FLEXIO.h PERI_FREQME.h PERI_FRO.h PERI_GDET.h PERI_GLIKEY.h PERI_GPIO.h PERI_I2S.h PERI_I3C.h PERI_INPUTMUX0.h PERI_INPUTMUX1.h PERI_IOPCTL0.h PERI_IOPCTL1.h PERI_IOPCTL2.h PERI_ITRC.h PERI_JPEGDEC.h PERI_JPGDECWRP.h PERI_LCDIF.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_LP_FLEXCOMM.h PERI_MIPI_DSI_HOST.h PERI_MMU.h PERI_MRT.h PERI_MU.h PERI_NIC.h PERI_OCOTP.h PERI_OSC32KNP.h PERI_OSCCA.h PERI_OSTIMER.h PERI_PDM.h PERI_PINT.h PERI_PKC.h PERI_PMC.h PERI_PNGDEC.h PERI_PUF.h PERI_PVTS.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RSTCTL2.h PERI_RSTCTL3.h PERI_RSTCTL4.h PERI_RTC.h PERI_SCT.h PERI_SDADC.h PERI_SEMA42.h PERI_SLEEPCON0.h PERI_SLEEPCON1.h PERI_SYSCON0.h PERI_SYSCON1.h PERI_SYSCON2.h PERI_SYSCON3.h PERI_SYSCON4.h PERI_SYSPM.h PERI_TRNG.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_UTICK.h PERI_WWDT.h PERI_XCACHE.h PERI_XSPI.h
  group startup
    ../../../../../../devices/MIMXRT798S/: startup_MIMXRT798S_cm33_core0.c
  group drivers
    ../../../../../../devices/MIMXRT798S/drivers/: fsl_clock.c fsl_clock.h fsl_dsp.c fsl_dsp.h fsl_ezhv.c fsl_ezhv.h fsl_iopctl.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_glikey.h fsl_glikey.c fsl_gpio.h fsl_gpio.c fsl_lpflexcomm.h fsl_lpflexcomm.c fsl_lpuart.h fsl_lpuart.c fsl_mu.h fsl_mu.c fsl_xspi.c fsl_xspi.h
  group utilities
    ../../../../../../devices/MIMXRT798S/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../../devices/MIMXRT798S/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MIMXRT798S/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group rpmsg-lite/rpmsg-lite/lib/include
    ../../../../../../middleware/multicore/rpmsg-lite/lib/include/: llist.h rpmsg_compiler.h rpmsg_default_config.h rpmsg_env.h rpmsg_lite.h virtio_ring.h virtqueue.h rpmsg_queue.h rpmsg_ns.h
  group rpmsg-lite/rpmsg-lite/lib/include/environment/freertos
    ../../../../../../middleware/multicore/rpmsg-lite/lib/include/environment/freertos/: rpmsg_env_specific.h
  group rpmsg-lite/rpmsg-lite/lib/include/platform/imxrt700_m33
    ../../../../../../middleware/multicore/rpmsg-lite/lib/include/platform/imxrt700_m33/: rpmsg_platform.h
  group rpmsg-lite/rpmsg-lite/lib/common
    ../../../../../../middleware/multicore/rpmsg-lite/lib/common/: llist.c
  group rpmsg-lite/rpmsg-lite/lib/rpmsg_lite
    ../../../../../../middleware/multicore/rpmsg-lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_queue.c rpmsg_ns.c
  group rpmsg-lite/rpmsg-lite/lib/rpmsg_lite/porting/environment
    ../../../../../../middleware/multicore/rpmsg-lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_freertos.c
  group rpmsg-lite/rpmsg-lite/lib/rpmsg_lite/porting/platform/imxrt700_m33
    ../../../../../../middleware/multicore/rpmsg-lite/lib/rpmsg_lite/porting/platform/imxrt700_m33/: rpmsg_platform.c
  group rpmsg-lite/rpmsg-lite/lib/virtio
    ../../../../../../middleware/multicore/rpmsg-lite/lib/virtio/: virtqueue.c
  group mcmgr/mcmgr/inc
    ../../../../../../middleware/multicore/mcmgr/inc/: mcmgr.h mcmgr_internal_core_api.h
  group mcmgr/mcmgr/inc/platform/imxrt700
    ../../../../../../middleware/multicore/mcmgr/inc/platform/imxrt700/: mcmgr_platform.h
  group mcmgr/mcmgr/src
    ../../../../../../middleware/multicore/mcmgr/src/: mcmgr.c mcmgr_internal_core_api_imxrt700.c mcmgr_mu_internal.c
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/template
    ../../../../../../rtos/freertos/freertos-kernel/template/: FreeRTOSConfig.h
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
