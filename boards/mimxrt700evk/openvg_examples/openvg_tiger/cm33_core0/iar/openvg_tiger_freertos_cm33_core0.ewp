# IAR project openvg_tiger_freertos_cm33_core0.ewp, settings and files
configuration flash_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT798S_M33_0 NXP MIMXRT798S_M33_0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; DBG=1; STATIC_LINK=1; gcdSTATIC_LINK=1; GCID_REV_CID=gc555/0x423_ECO; BOOT_ENABLE_XSPI1_PSRAM; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; SDK_I2C_BASED_COMPONENT_USED=1; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; CPU_MIMXRT798SGFOB_cm33_core0; MIMXRT798S_cm33_core0_SERIES; BOOT_HEADER_ENABLE=1; MCUX_DBI_LEGACY=0; SDK_OS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pe188,Pa089,Pa205
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../flash_config; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT798S; ../../../../../../devices/MIMXRT798S/periph; ../../../../../../devices/MIMXRT798S/drivers; ../../../../../../devices/MIMXRT798S/utilities/debug_console_lite; ../../../../../../devices/MIMXRT798S/utilities/str; ../../../../../../components/uart; ../../../../../../components/video; ../../../../../../components/video/display/dc; ../../../../../../components/video/display; ../../../../../../components/video/display/fbdev; ../../../../../../components/video/display/dbi; ../../../../../../components/video/display/dbi/flexio; ../../../../../../components/video/display/dbi/lcdif; ../../../../../../components/video/display/dc/dsi_cmd; ../../../../../../components/video/display/dc/lcdif; ../../../../../../components/video/display/dc/dbi; ../../../../../../components/video/display/mipi_dsi_cmd; ../../../../../../components/video/display/hx8394; ../../../../../../components/video/display/rm68191; ../../../../../../components/video/display/rm68200; ../../../../../../components/video/display/rm67162; ../../../../../../components/video/display/co5300; ../../../../../../components/video/display/rpi; ../../../../../../components/display/ssd1963; ../../../../../../middleware/vglite/driver/inc; ../../../../../../middleware/vglite/driver/VGLite; ../../../../../../middleware/vglite/driver/VGLite/rtos; ../../../../../../middleware/vglite/driver/VGLite/Series/gc555/0x423_ECO; ../../../../../../middleware/vglite/driver/VGLite/Series/gc355/0x0_1216; ../../../../../../middleware/vglite/driver/VGLite/Series/gc255/0x40A; ../../../../../../middleware/vglite/driver/VGLiteKernel; ../../../../../../middleware/vglite/driver/VGLiteKernel/rtos; ../../../../../../middleware/openvg/include; ../../../../../../middleware/openvg/include/Vivante; ../../../../../../middleware/openvg/include/EGL; ../../../../../../middleware/openvg/include/VG; ../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../../rtos/freertos/freertos-kernel/template
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT798SGFOB_cm33_core0; MIMXRT798S_cm33_core0_SERIES
  AARM.AUserIncludes: ..; ../../../../flash_config; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT798S; ../../../../../../devices/MIMXRT798S/periph; ../../../../../../devices/periph; ../../../../../../devices/MIMXRT798S/drivers; ../../../../../../devices/MIMXRT798S/utilities/debug_console_lite; ../../../../../../devices/MIMXRT798S/utilities/str; ../../../../../../components/uart; ../../../../../../components/video; ../../../../../../components/video/display/dc; ../../../../../../components/video/display; ../../../../../../components/video/display/fbdev; ../../../../../../components/video/display/dbi; ../../../../../../components/video/display/dbi/flexio; ../../../../../../components/video/display/dbi/lcdif; ../../../../../../components/video/display/dc/dsi_cmd; ../../../../../../components/video/display/dc/lcdif; ../../../../../../components/video/display/dc/dbi; ../../../../../../components/video/display/mipi_dsi_cmd; ../../../../../../components/video/display/hx8394; ../../../../../../components/video/display/rm68191; ../../../../../../components/video/display/rm68200; ../../../../../../components/video/display/rm67162; ../../../../../../components/video/display/co5300; ../../../../../../components/video/display/rpi; ../../../../../../components/display/ssd1963; ../../../../../../middleware/vglite/driver/inc; ../../../../../../middleware/vglite/driver/VGLite; ../../../../../../middleware/vglite/driver/VGLite/rtos; ../../../../../../middleware/vglite/driver/VGLite/Series/gc555/0x423_ECO; ../../../../../../middleware/vglite/driver/VGLite/Series/gc355/0x0_1216; ../../../../../../middleware/vglite/driver/VGLite/Series/gc255/0x40A; ../../../../../../middleware/vglite/driver/VGLiteKernel; ../../../../../../middleware/vglite/driver/VGLiteKernel/rtos; ../../../../../../middleware/openvg/include; ../../../../../../middleware/openvg/include/Vivante; ../../../../../../middleware/openvg/include/EGL; ../../../../../../middleware/openvg/include/VG; ../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../../rtos/freertos/freertos-kernel/template
  AARM.PreInclude: ../mcux_config.h
  OBJCOPY.OOCOutputFile: openvg_tiger_freertos.bin
  ILINK.IlinkOutputFile: openvg_tiger_freertos_cm33_core0.out
  ILINK.IlinkIcfFile: MIMXRT798Sxxxx_cm33_core0_psram_flash.icf
  ILINK.IlinkExtraOptions: --redirect  __iar_sh_stdout=__iar_sh_stdout_swo
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STATIC_LINK=1; gcdSTATIC_LINK=1; GCID_REV_CID=gc555/0x423_ECO; BOOT_ENABLE_XSPI1_PSRAM; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; SDK_I2C_BASED_COMPONENT_USED=1; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; CPU_MIMXRT798SGFOB_cm33_core0; MIMXRT798S_cm33_core0_SERIES; BOOT_HEADER_ENABLE=1; MCUX_DBI_LEGACY=0; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  group source
    ../: tiger_freertos.c tiger_path.h FreeRTOSConfigBoard.h pin_mux.c pin_mux.h vglite_support.c vglite_support.h display_support.h display_support.c display_support.h display_support.c FreeRTOSConfig_Gen.h mcux_config.h mcux_config.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c hardware_init.c app.h
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group device
    ../../../../../../devices/MIMXRT798S/: fsl_device_registers.h MIMXRT798S_cm33_core0.h MIMXRT798S_cm33_core0_COMMON.h MIMXRT798S_cm33_core0_features.h system_MIMXRT798S_cm33_core0.c system_MIMXRT798S_cm33_core0.h
  group device/periph
    ../../../../../../devices/MIMXRT798S/periph/: PERI_ADC.h PERI_AHBSC0.h PERI_AHBSC3.h PERI_AHBSC4.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CDOG.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CLKCTL2.h PERI_CLKCTL3.h PERI_CLKCTL4.h PERI_CMP.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUG_MAILBOX.h PERI_DMA.h PERI_ELS.h PERI_FLEXIO.h PERI_FREQME.h PERI_FRO.h PERI_GDET.h PERI_GLIKEY.h PERI_GPIO.h PERI_I2S.h PERI_I3C.h PERI_INPUTMUX0.h PERI_INPUTMUX1.h PERI_IOPCTL0.h PERI_IOPCTL1.h PERI_IOPCTL2.h PERI_ITRC.h PERI_JPEGDEC.h PERI_JPGDECWRP.h PERI_LCDIF.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_LP_FLEXCOMM.h PERI_MIPI_DSI_HOST.h PERI_MMU.h PERI_MRT.h PERI_MU.h PERI_NIC.h PERI_OCOTP.h PERI_OSC32KNP.h PERI_OSCCA.h PERI_OSTIMER.h PERI_PDM.h PERI_PINT.h PERI_PKC.h PERI_PMC.h PERI_PNGDEC.h PERI_PUF.h PERI_PVTS.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RSTCTL2.h PERI_RSTCTL3.h PERI_RSTCTL4.h PERI_RTC.h PERI_SCT.h PERI_SDADC.h PERI_SEMA42.h PERI_SLEEPCON0.h PERI_SLEEPCON1.h PERI_SYSCON0.h PERI_SYSCON1.h PERI_SYSCON2.h PERI_SYSCON3.h PERI_SYSCON4.h PERI_SYSPM.h PERI_TRNG.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_UTICK.h PERI_WWDT.h PERI_XCACHE.h PERI_XSPI.h
  group startup
    ../../../../../../devices/MIMXRT798S/: startup_MIMXRT798S_cm33_core0.c
  group drivers
    ../../../../../../devices/MIMXRT798S/drivers/: fsl_clock.c fsl_clock.h fsl_edma_soc.c fsl_edma_soc.h fsl_iopctl.h fsl_soc_mipi_dsi.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_edma.h fsl_edma_core.h fsl_edma.c fsl_flexio.c fsl_flexio.h fsl_flexio_mculcd_edma.c fsl_flexio_mculcd_edma.h fsl_flexio_mculcd.c fsl_flexio_mculcd.h fsl_glikey.h fsl_glikey.c fsl_gpio.h fsl_gpio.c fsl_lcdif.h fsl_lcdif.c fsl_lpflexcomm.h fsl_lpflexcomm.c fsl_lpuart.h fsl_lpuart.c fsl_lpi2c.h fsl_lpi2c.c fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_xspi.c fsl_xspi.h
  group utilities
    ../../../../../../devices/MIMXRT798S/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../../devices/MIMXRT798S/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MIMXRT798S/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group video
    ../../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../../components/video/display/dc/: fsl_dc_fb.h
    ../../../../../../components/video/display/: fsl_display.h
    ../../../../../../components/video/display/fbdev/: fsl_fbdev.h fsl_fbdev.c
    ../../../../../../components/video/display/dbi/: fsl_dbi.h fsl_dbi.c
    ../../../../../../components/video/display/dbi/flexio/: fsl_dbi_flexio_edma.h fsl_dbi_flexio_edma.c
    ../../../../../../components/video/display/dbi/lcdif/: fsl_dbi_lcdif.h fsl_dbi_lcdif.c
    ../../../../../../components/video/display/dc/dsi_cmd/: fsl_dc_fb_dsi_cmd.h fsl_dc_fb_dsi_cmd.c
    ../../../../../../components/video/display/dc/lcdif/: fsl_dc_fb_lcdif.h fsl_dc_fb_lcdif.c
    ../../../../../../components/video/display/dc/dbi/: fsl_dc_fb_dbi.h fsl_dc_fb_dbi.c
    ../../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.h fsl_mipi_dsi_cmd.c
    ../../../../../../components/video/display/hx8394/: fsl_hx8394.h fsl_hx8394.c
    ../../../../../../components/video/display/rm68191/: fsl_rm68191.h fsl_rm68191.c
    ../../../../../../components/video/display/rm68200/: fsl_rm68200.h fsl_rm68200.c
    ../../../../../../components/video/display/rm67162/: fsl_rm67162.h fsl_rm67162.c
    ../../../../../../components/video/display/co5300/: fsl_co5300.h fsl_co5300.c
    ../../../../../../components/video/display/rpi/: fsl_rpi.h fsl_rpi.c
  group lcdc
    ../../../../../../components/display/ssd1963/: fsl_ssd1963.h fsl_ssd1963.c
  group vglite
    ../../../../../../middleware/vglite/driver/: RELEASE_NOTES.txt LICENSE.txt
  group vglite/inc
    ../../../../../../middleware/vglite/driver/inc/: vg_lite.h
  group vglite/VGLite
    ../../../../../../middleware/vglite/driver/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_stroke.c vg_lite_options.h vg_lite_context.h
  group vglite/VGLite/rtos
    ../../../../../../middleware/vglite/driver/VGLite/rtos/: vg_lite_os.c
  group vglite/VGLite/Series/gc555/0x423_ECO
    ../../../../../../middleware/vglite/driver/VGLite/Series/gc555/0x423_ECO/: vg_lite_options.h
  group vglite/VGLite/Series/gc355/0x0_1216
    ../../../../../../middleware/vglite/driver/VGLite/Series/gc355/0x0_1216/: vg_lite_options.h
  group vglite/VGLite/Series/gc255/0x40A
    ../../../../../../middleware/vglite/driver/VGLite/Series/gc255/0x40A/: vg_lite_options.h
  group vglite/VGLiteKernel
    ../../../../../../middleware/vglite/driver/VGLiteKernel/: vg_lite_hal.h vg_lite_hw.h vg_lite_kernel.c vg_lite_kernel.h vg_lite_option.h vg_lite_type.h vg_lite_debug.h
  group vglite/VGLiteKernel/rtos
    ../../../../../../middleware/vglite/driver/VGLiteKernel/rtos/: vg_lite_hal.c vg_lite_platform.h
  group openvg/src
    ../../../../../../middleware/openvg/src/: vg_api.c vg_context.c vg_egl.c vg_image.c vg_vgu.c vg_egl_freertos.c
  group openvg/include/EGL
    ../../../../../../middleware/openvg/include/EGL/: egl.h eglplatform.h eglvivante.h
  group openvg/include/KHR
    ../../../../../../middleware/openvg/include/KHR/: khrplatform.h
  group openvg/include/VG
    ../../../../../../middleware/openvg/include/VG/: openvg.h vgplatform.h vgu.h
  group openvg/include/Vivante
    ../../../../../../middleware/openvg/include/Vivante/: vg_context.h vg_defs.h vg_image.h vg_math.h
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/template
    ../../../../../../rtos/freertos/freertos-kernel/template/: FreeRTOSConfig.h
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
