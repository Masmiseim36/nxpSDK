# IAR project dev_composite_hid_audio_unified_freertos_cm33_core0.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT798S_M33_0 NXP MIMXRT798S_M33_0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; HAL_AUDIO_ISR_PRIORITY=0; USB_STACK_FREERTOS; USB_DEVICE_CONFIG_BUFFER_PROPERTY_CACHEABLE=1; EUSB_CONFIG_NATIVE_MODE=0; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT798SGFOB_cm33_core0; MIMXRT798S_cm33_core0_SERIES; OSA_USED; BOOT_HEADER_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; CODEC_MULTI_ADAPTERS=1; CODEC_WM8962_ENABLE; USE_RTOS=1; SDK_OS_FREE_RTOS
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../../flash_config; ../../../../../../../CMSIS/Core/Include; ../../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../../devices/MIMXRT798S; ../../../../../../../devices/MIMXRT798S/periph; ../../../../../../../devices/MIMXRT798S/drivers; ../../../../../../../devices/MIMXRT798S/utilities/debug_console_lite; ../../../../../../../components/lists; ../../../../../../../devices/MIMXRT798S/utilities/str; ../../../../../../../components/codec/i2c; ../../../../../../../components/codec; ../../../../../../../components/codec/port; ../../../../../../../components/codec/port/wm8962; ../../../../../../../components/codec/wm8962; ../../../../../../../components/i2c; ../../../../../../../components/uart; ../../../../../../../components/audio; ../../../../../../../components/osa; ../../../../../../../middleware/usb/include; ../../../../../../../middleware/usb/device; ../../../../../../../middleware/usb/config/device/ehci; ../../../../../../../middleware/usb/device/class; ../../../../../../../middleware/usb/phy; ../../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../../../rtos/freertos/freertos-kernel/template
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT798SGFOB_cm33_core0; MIMXRT798S_cm33_core0_SERIES; OSA_USED
  AARM.AUserIncludes: ..; ../../../../../flash_config; ../../../../../../../CMSIS/Core/Include; ../../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../../devices/MIMXRT798S; ../../../../../../../devices/MIMXRT798S/periph; ../../../../../../../devices/periph; ../../../../../../../devices/MIMXRT798S/drivers; ../../../../../../../devices/MIMXRT798S/utilities/debug_console_lite; ../../../../../../../components/lists; ../../../../../../../devices/MIMXRT798S/utilities/str; ../../../../../../../components/codec/i2c; ../../../../../../../components/codec; ../../../../../../../components/codec/port; ../../../../../../../components/codec/port/wm8962; ../../../../../../../components/codec/wm8962; ../../../../../../../components/i2c; ../../../../../../../components/uart; ../../../../../../../components/audio; ../../../../../../../components/osa; ../../../../../../../middleware/usb/include; ../../../../../../../middleware/usb/device; ../../../../../../../middleware/usb/config/device/ehci; ../../../../../../../middleware/usb/device/class; ../../../../../../../middleware/usb/phy; ../../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../../../rtos/freertos/freertos-kernel/template
  AARM.PreInclude: ../mcux_config.h
  OBJCOPY.OOCOutputFile: dev_composite_hid_audio_unified_freertos.bin
  ILINK.IlinkOutputFile: dev_composite_hid_audio_unified_freertos_cm33_core0.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000
  ILINK.IlinkIcfFile: MIMXRT798Sxxxx_cm33_core0_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: MIMXRT798Sxxxx_cm33_core0_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; HAL_AUDIO_ISR_PRIORITY=0; USB_STACK_FREERTOS; USB_DEVICE_CONFIG_BUFFER_PROPERTY_CACHEABLE=1; EUSB_CONFIG_NATIVE_MODE=0; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT798SGFOB_cm33_core0; MIMXRT798S_cm33_core0_SERIES; OSA_USED; BOOT_HEADER_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; CODEC_MULTI_ADAPTERS=1; CODEC_WM8962_ENABLE; USE_RTOS=1; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 3
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT798Sxxxx_cm33_core0_flash.icf
  group source
    ../: audio_unified.c audio_unified.h composite.c composite.h hid_keyboard.c hid_keyboard.h usb_device_descriptor.c usb_device_descriptor.h app.h hardware_init.c pin_mux.c pin_mux.h usb_audio_config.h FreeRTOSConfig_Gen.h fsl_os_abstraction_config.h mcux_config.h mcux_config.h mcux_config.h usb_device_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c
  group flash_config
    ../../../../../flash_config/: flash_config.c flash_config.h
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group device
    ../../../../../../../devices/MIMXRT798S/: fsl_device_registers.h MIMXRT798S_cm33_core0.h MIMXRT798S_cm33_core0_COMMON.h MIMXRT798S_cm33_core0_features.h system_MIMXRT798S_cm33_core0.c system_MIMXRT798S_cm33_core0.h
  group device/periph
    ../../../../../../../devices/MIMXRT798S/periph/: PERI_ADC.h PERI_AHBSC0.h PERI_AHBSC3.h PERI_AHBSC4.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CDOG.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CLKCTL2.h PERI_CLKCTL3.h PERI_CLKCTL4.h PERI_CMP.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUG_MAILBOX.h PERI_DMA.h PERI_ELS.h PERI_FLEXIO.h PERI_FREQME.h PERI_FRO.h PERI_GDET.h PERI_GLIKEY.h PERI_GPIO.h PERI_I2S.h PERI_I3C.h PERI_INPUTMUX0.h PERI_INPUTMUX1.h PERI_IOPCTL0.h PERI_IOPCTL1.h PERI_IOPCTL2.h PERI_ITRC.h PERI_JPEGDEC.h PERI_JPGDECWRP.h PERI_LCDIF.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_LP_FLEXCOMM.h PERI_MIPI_DSI_HOST.h PERI_MMU.h PERI_MRT.h PERI_MU.h PERI_NIC.h PERI_OCOTP.h PERI_OSC32KNP.h PERI_OSCCA.h PERI_OSTIMER.h PERI_PDM.h PERI_PINT.h PERI_PKC.h PERI_PMC.h PERI_PNGDEC.h PERI_PUF.h PERI_PVTS.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RSTCTL2.h PERI_RSTCTL3.h PERI_RSTCTL4.h PERI_RTC.h PERI_SCT.h PERI_SDADC.h PERI_SEMA42.h PERI_SLEEPCON0.h PERI_SLEEPCON1.h PERI_SYSCON0.h PERI_SYSCON1.h PERI_SYSCON2.h PERI_SYSCON3.h PERI_SYSCON4.h PERI_SYSPM.h PERI_TRNG.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_UTICK.h PERI_WWDT.h PERI_XCACHE.h PERI_XSPI.h
  group startup
    ../../../../../../../devices/MIMXRT798S/: startup_MIMXRT798S_cm33_core0.c
  group drivers
    ../../../../../../../devices/MIMXRT798S/drivers/: fsl_clock.c fsl_clock.h fsl_edma_soc.c fsl_edma_soc.h fsl_inputmux_connections.h fsl_iopctl.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_ctimer.h fsl_ctimer.c fsl_edma.h fsl_edma_core.h fsl_edma.c fsl_glikey.h fsl_glikey.c fsl_gpio.h fsl_gpio.c fsl_inputmux.h fsl_inputmux.c fsl_lpflexcomm.h fsl_lpflexcomm.c fsl_lpuart.h fsl_lpuart.c fsl_lpi2c.h fsl_lpi2c.c fsl_pint.h fsl_pint.c fsl_sai_edma.h fsl_sai_edma.c fsl_sai.h fsl_sai.c fsl_xspi.c fsl_xspi.h
  group utilities
    ../../../../../../../devices/MIMXRT798S/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../../../devices/MIMXRT798S/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../../devices/MIMXRT798S/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/i2c
    ../../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/audio
    ../../../../../../../components/audio/: fsl_adapter_audio.h fsl_adapter_sai.c
  group component/osa
    ../../../../../../../components/osa/: fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h
  group codec
    ../../../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
    ../../../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../../../components/codec/wm8962/: fsl_wm8962.h fsl_wm8962.c
  group codec/port
    ../../../../../../../components/codec/port/: fsl_codec_adapter.c fsl_codec_adapter.h
  group codec/port/wm8962
    ../../../../../../../components/codec/port/wm8962/: fsl_codec_wm8962_adapter.h fsl_codec_wm8962_adapter.c
  group usb/include
    ../../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group usb/device
    ../../../../../../../middleware/usb/device/: usb_device.h usb_device_ehci.c usb_device_ehci.h usb_device_dci.c usb_device_dci.h usb_device_ch9.c usb_device_ch9.h
  group usb/device/class
    ../../../../../../../middleware/usb/device/class/: usb_device_class.c usb_device_class.h usb_device_audio.c usb_device_audio.h usb_device_hid.c usb_device_hid.h
  group usb/phy
    ../../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group freertos/freertos-kernel
    ../../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable
    ../../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/template
    ../../../../../../../rtos/freertos/freertos-kernel/template/: FreeRTOSConfig.h
  group doc
    ../: readme.md examples_shared_readme.md usb_device_audio_recorder_signal_enhancement.jpg usb_device_composite_hid_audio_device_manager.jpg usb_device_composite_hid_audio_right_click_icon.jpg usb_device_composite_hid_audio_select_properties.jpg usb_device_composite_hid_audio_set_default.jpg usb_device_composite_hid_audio_unified_recorder_change_level.jpg usb_device_composite_hid_audio_unified_recorder_default.jpg usb_device_composite_hid_audio_unified_recorder_property.jpg usb_device_composite_hid_audio_unified_speaker_change_level.jpg usb_device_composite_hid_audio_unified_speaker_control_log.jpg usb_device_composite_hid_audio_unified_speaker_default.jpg usb_device_composite_hid_audio_unified_speaker_property.jpg usb_device_composite_hid_audio_unified_start_log.jpg
