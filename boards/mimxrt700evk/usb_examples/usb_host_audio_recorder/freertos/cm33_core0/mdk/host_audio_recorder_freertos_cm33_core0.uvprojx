# Keil uVision project host_audio_recorder_freertos_cm33_core0.uvprojx, settings and files
target host_audio_recorder_freertos_cm33_core0 debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT798SGFOB:cm33_core0 NXP
  pack: NXP.MIMXRT798S_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: host_audio_recorder_freertos_cm33_core0.out
  AfterMake: fromelf.exe --output "$Lhost_audio_recorder_freertos.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, USB_AUDIO_RECORDER_SDCARD_BUFFER_LENGTH=3072, USB_AUDIO_RECORDER_SDCARD_WRITE_LENGTH=1024, USB_STACK_FREERTOS, USB_HOST_CONFIG_BUFFER_PROPERTY_CACHEABLE=1, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, EUSB_CONFIG_NATIVE_MODE=0, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT798SGFOB_cm33_core0, MIMXRT798S_cm33_core0_SERIES, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, BOOT_HEADER_ENABLE=1, SERIAL_PORT_TYPE_UART=1, USE_RTOS=1, SD_ENABLED=1, SDK_OS_FREE_RTOS
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../../flash_config;../../../../../../../CMSIS/Core/Include;../../../../../../../CMSIS/Core/Include/m-profile;../../../../../../../devices/MIMXRT798S;../../../../../../../devices/MIMXRT798S/periph;../../../../../../../devices/MIMXRT798S/drivers;../../../../../../../devices/MIMXRT798S/utilities/debug_console;../../../../../../../components/lists;../../../../../../../devices/MIMXRT798S/utilities/str;../../../../../../../components/serial_manager;../../../../../../../components/gpio;../../../../../../../components/uart;../../../../../../../components/osa;../../../../../../../middleware/usb/include;../../../../../../../middleware/usb/host;../../../../../../../middleware/usb/config/host/ehci;../../../../../../../middleware/usb/host/class;../../../../../../../middleware/usb/phy;../../../../../../../middleware/fatfs/source;../../../../../../../middleware/fatfs/template;../../../../../../../middleware/fatfs/source/fsl_sd_disk;../../../../../../../middleware/sdmmc/common;../../../../../../../middleware/sdmmc/osa;../../../../../../../middleware/sdmmc/sd;../../../../../../../middleware/sdmmc/host/usdhc;../../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure;../../../../../../../rtos/freertos/freertos-kernel/template
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT798SGFOB_cm33_core0, MIMXRT798S_cm33_core0_SERIES, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING
  asm misc: -include ../mcux_config.h
  asm include: ..;../../../../../flash_config;../../../../../../../CMSIS/Core/Include;../../../../../../../CMSIS/Core/Include/m-profile;../../../../../../../devices/MIMXRT798S;../../../../../../../devices/MIMXRT798S/periph;../../../../../../../devices/periph;../../../../../../../devices/MIMXRT798S/drivers;../../../../../../../devices/MIMXRT798S/utilities/debug_console;../../../../../../../components/lists;../../../../../../../devices/MIMXRT798S/utilities/str;../../../../../../../components/serial_manager;../../../../../../../components/gpio;../../../../../../../components/uart;../../../../../../../components/osa;../../../../../../../middleware/usb/include;../../../../../../../middleware/usb/host;../../../../../../../middleware/usb/config/host/ehci;../../../../../../../middleware/usb/host/class;../../../../../../../middleware/usb/phy;../../../../../../../middleware/fatfs/source;../../../../../../../middleware/fatfs/template;../../../../../../../middleware/fatfs/source/fsl_sd_disk;../../../../../../../middleware/sdmmc/common;../../../../../../../middleware/sdmmc/osa;../../../../../../../middleware/sdmmc/sd;../../../../../../../middleware/sdmmc/host/usdhc;../../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure;../../../../../../../rtos/freertos/freertos-kernel/template
  library: MicroLIB
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20080000 size 0x280000
  memory RVCT7: RAM 0x30080000 size 0x280000
  memory RVCT8: RAM 0x680000 size 0x100000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x10080000 size 0x280000
  scatter file: MIMXRT798Sxxxx_cm33_core0_ram.scf
  link misc: --remove --predefine=\"-D__heap_size__=0x2000\" --predefine=\"-D__stack_size__=0x2000\" --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: app.c app.h audio_recorder.c audio_recorder.h sdmmc_config.c sdmmc_config.h hardware_init.c pin_mux.c pin_mux.h FreeRTOSConfig_Gen.h ffconf_gen.h fsl_debug_console_conf.h fsl_os_abstraction_config.h mcux_config.h mcux_config.h mcux_config.h usb_host_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c
  group flash_config
    ../../../../../flash_config/: flash_config.c flash_config.h
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv8m_mpu.h
  group device
    ../../../../../../../devices/MIMXRT798S/: fsl_device_registers.h MIMXRT798S_cm33_core0.h MIMXRT798S_cm33_core0_COMMON.h MIMXRT798S_cm33_core0_features.h system_MIMXRT798S_cm33_core0.c system_MIMXRT798S_cm33_core0.h
  group device/periph
    ../../../../../../../devices/MIMXRT798S/periph/: PERI_ADC.h PERI_AHBSC0.h PERI_AHBSC3.h PERI_AHBSC4.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CDOG.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CLKCTL2.h PERI_CLKCTL3.h PERI_CLKCTL4.h PERI_CMP.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUG_MAILBOX.h PERI_DMA.h PERI_ELS.h PERI_FLEXIO.h PERI_FREQME.h PERI_FRO.h PERI_GDET.h PERI_GLIKEY.h PERI_GPIO.h PERI_I2S.h PERI_I3C.h PERI_INPUTMUX0.h PERI_INPUTMUX1.h PERI_IOPCTL0.h PERI_IOPCTL1.h PERI_IOPCTL2.h PERI_ITRC.h PERI_JPEGDEC.h PERI_JPGDECWRP.h PERI_LCDIF.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_LP_FLEXCOMM.h PERI_MIPI_DSI_HOST.h PERI_MMU.h PERI_MRT.h PERI_MU.h PERI_NIC.h PERI_OCOTP.h PERI_OSC32KNP.h PERI_OSCCA.h PERI_OSTIMER.h PERI_PDM.h PERI_PINT.h PERI_PKC.h PERI_PMC.h PERI_PNGDEC.h PERI_PUF.h PERI_PVTS.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RSTCTL2.h PERI_RSTCTL3.h PERI_RSTCTL4.h PERI_RTC.h PERI_SCT.h PERI_SDADC.h PERI_SEMA42.h PERI_SLEEPCON0.h PERI_SLEEPCON1.h PERI_SYSCON0.h PERI_SYSCON1.h PERI_SYSCON2.h PERI_SYSCON3.h PERI_SYSCON4.h PERI_SYSPM.h PERI_TRNG.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_UTICK.h PERI_WWDT.h PERI_XCACHE.h PERI_XSPI.h
  group startup
    ../../../../../../../devices/MIMXRT798S/: startup_MIMXRT798S_cm33_core0.c
  group drivers
    ../../../../../../../devices/MIMXRT798S/drivers/: fsl_clock.c fsl_clock.h fsl_iopctl.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_glikey.h fsl_glikey.c fsl_gpio.h fsl_gpio.c fsl_lpflexcomm.h fsl_lpflexcomm.c fsl_lpuart.h fsl_lpuart.c fsl_usdhc.c fsl_usdhc.h fsl_xspi.c fsl_xspi.h
  group utilities
    ../../../../../../../devices/MIMXRT798S/utilities/debug_console/: fsl_assert.h fsl_assert.c
    ../../../../../../../devices/MIMXRT798S/utilities/: fsl_memcpy.S
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group utilities/str
    ../../../../../../../devices/MIMXRT798S/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console
    ../../../../../../../devices/MIMXRT798S/utilities/debug_console/: fsl_debug_console.h fsl_debug_console.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/gpio
    ../../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_gpio.c
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/osa
    ../../../../../../../components/osa/: fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h
  group usb/include
    ../../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group usb/host
    ../../../../../../../middleware/usb/host/: usb_host.h usb_host_hci.h usb_host_devices.h usb_host_framework.h usb_host_ehci.c usb_host_ehci.h usb_host_hci.c usb_host_devices.c usb_host_framework.c
  group usb/host/class
    ../../../../../../../middleware/usb/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_audio.c usb_host_audio.h
  group usb/phy
    ../../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group fatfs/source
    ../../../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group source/template
    ../../../../../../../middleware/fatfs/template/: ffconf.h
  group fatfs/source/fsl_sd_disk
    ../../../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group sdmmc/common
    ../../../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h fsl_sdmmc_common.c
  group sdmmc/osa
    ../../../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group sdmmc/sd
    ../../../../../../../middleware/sdmmc/sd/: fsl_sd.c fsl_sd.h
  group sdmmc/host/usdhc
    ../../../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h fsl_sdmmc_host.h
  group sdmmc/host/usdhc/blocking
    ../../../../../../../middleware/sdmmc/host/usdhc/blocking/: fsl_sdmmc_host.c
  group freertos/freertos-kernel
    ../../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable
    ../../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure
    ../../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.c port.c portasm.c portasm.h portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/template
    ../../../../../../../rtos/freertos/freertos-kernel/template/: FreeRTOSConfig.h
  group doc
    ../: readme.md examples_shared_readme.md audio_10_microphone.jpg audio_20_microphone.jpg device_manager.jpg open_uart.jpg PCM2WAV.jpg sdcard_insert.jpg
target host_audio_recorder_freertos_cm33_core0 flash_debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT798SGFOB:cm33_core0 NXP
  pack: NXP.MIMXRT798S_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: host_audio_recorder_freertos_cm33_core0.out
  AfterMake: as above
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20080000 size 0x280000
  memory RVCT7: RAM 0x30080000 size 0x280000
  memory RVCT8: RAM 0x680000 size 0x100000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x10080000 size 0x280000
  scatter file: MIMXRT798Sxxxx_cm33_core0_flash.scf
  link misc: as above
target host_audio_recorder_freertos_cm33_core0 release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT798SGFOB:cm33_core0 NXP
  pack: NXP.MIMXRT798S_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: host_audio_recorder_freertos_cm33_core0.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, USB_AUDIO_RECORDER_SDCARD_BUFFER_LENGTH=3072, USB_AUDIO_RECORDER_SDCARD_WRITE_LENGTH=1024, USB_STACK_FREERTOS, USB_HOST_CONFIG_BUFFER_PROPERTY_CACHEABLE=1, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, EUSB_CONFIG_NATIVE_MODE=0, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT798SGFOB_cm33_core0, MIMXRT798S_cm33_core0_SERIES, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, BOOT_HEADER_ENABLE=1, SERIAL_PORT_TYPE_UART=1, USE_RTOS=1, SD_ENABLED=1, SDK_OS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20080000 size 0x280000
  memory RVCT7: RAM 0x30080000 size 0x280000
  memory RVCT8: RAM 0x680000 size 0x100000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x10080000 size 0x280000
  scatter file: MIMXRT798Sxxxx_cm33_core0_ram.scf
  link misc: as above
target host_audio_recorder_freertos_cm33_core0 flash_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT798SGFOB:cm33_core0 NXP
  pack: NXP.MIMXRT798S_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: host_audio_recorder_freertos_cm33_core0.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20080000 size 0x280000
  memory RVCT7: RAM 0x30080000 size 0x280000
  memory RVCT8: RAM 0x680000 size 0x100000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x10080000 size 0x280000
  scatter file: MIMXRT798Sxxxx_cm33_core0_flash.scf
  link misc: as above
