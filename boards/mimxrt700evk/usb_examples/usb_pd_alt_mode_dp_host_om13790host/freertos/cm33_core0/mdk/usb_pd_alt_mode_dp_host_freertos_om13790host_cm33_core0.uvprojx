# Keil uVision project usb_pd_alt_mode_dp_host_freertos_om13790host_cm33_core0.uvprojx, settings and files
target usb_pd_alt_mode_dp_host_freertos_om13790host_cm33_core0 debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT798SGFOB:cm33_core0 NXP
  pack: NXP.MIMXRT798S_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: usb_pd_alt_mode_dp_host_freertos_om13790host_cm33_core0.out
  AfterMake: fromelf.exe --output "$Lusb_pd_alt_mode_dp_host_freertos_om13790host.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, SDK_OS_FREE_RTOS, I2C_RETRY_TIMES=40000, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT798SGFOB_cm33_core0, MIMXRT798S_cm33_core0_SERIES, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, BOOT_HEADER_ENABLE=1, SERIAL_PORT_TYPE_UART=1, TIMER_PORT_TYPE_MRT=1, USE_RTOS=1
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../../flash_config;../../../../../../../CMSIS/Core/Include;../../../../../../../CMSIS/Core/Include/m-profile;../../../../../../../devices/MIMXRT798S;../../../../../../../devices/MIMXRT798S/periph;../../../../../../../devices/MIMXRT798S/drivers;../../../../../../../devices/MIMXRT798S/utilities/debug_console;../../../../../../../components/lists;../../../../../../../devices/MIMXRT798S/utilities/str;../../../../../../../components/serial_manager;../../../../../../../components/gpio;../../../../../../../components/timer;../../../../../../../components/i2c;../../../../../../../components/uart;../../../../../../../components/osa;../../../../../../../middleware/usb/include;../../../../../../../middleware/usb/pd;../../../../../../../middleware/usb/pd/ptn5110;../../../../../../../middleware/usb/pd/phy_interface;../../../../../../../middleware/usb/config/pd;../../../../../../../middleware/usb/pd/alt_mode;../../../../../../../middleware/usb/phy;../../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure;../../../../../../../rtos/freertos/freertos-kernel/template
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT798SGFOB_cm33_core0, MIMXRT798S_cm33_core0_SERIES, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING
  asm misc: -include ../mcux_config.h
  asm include: ..;../../../../../flash_config;../../../../../../../CMSIS/Core/Include;../../../../../../../CMSIS/Core/Include/m-profile;../../../../../../../devices/MIMXRT798S;../../../../../../../devices/MIMXRT798S/periph;../../../../../../../devices/periph;../../../../../../../devices/MIMXRT798S/drivers;../../../../../../../devices/MIMXRT798S/utilities/debug_console;../../../../../../../components/lists;../../../../../../../devices/MIMXRT798S/utilities/str;../../../../../../../components/serial_manager;../../../../../../../components/gpio;../../../../../../../components/timer;../../../../../../../components/i2c;../../../../../../../components/uart;../../../../../../../components/osa;../../../../../../../middleware/usb/include;../../../../../../../middleware/usb/pd;../../../../../../../middleware/usb/pd/ptn5110;../../../../../../../middleware/usb/pd/phy_interface;../../../../../../../middleware/usb/config/pd;../../../../../../../middleware/usb/pd/alt_mode;../../../../../../../middleware/usb/phy;../../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure;../../../../../../../rtos/freertos/freertos-kernel/template
  library: MicroLIB
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20080000 size 0x280000
  memory RVCT7: RAM 0x30080000 size 0x280000
  memory RVCT8: RAM 0x680000 size 0x100000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x10080000 size 0x280000
  scatter file: MIMXRT798Sxxxx_cm33_core0_ram.scf
  link misc: --remove --predefine=\"-D__stack_size__=0x2000\" --predefine=\"-D__heap_size__=0x1000\" --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: pd_app.c hardware_init.c pin_mux.c pin_mux.h pd_board_config.h pd_app.h pd_app_demo.c pd_command_app.c pd_command_interface.c pd_command_interface.h pd_power_app.c pd_power_interface.c pd_power_interface.h pd_app_misc.h pd_dp_board_chip.c pd_dp_board_chip.h pd_crossbar_cbtl.h pd_crossbar_cbtl.c pd_ptn36502.h pd_ptn36502.c pd_dp_hpd_driver.h pd_dp_hpd_driver.c pd_power_nx20p3483.h pd_power_nx20p3483.c FreeRTOSConfig_Gen.h fsl_debug_console_conf.h fsl_os_abstraction_config.h mcux_config.h mcux_config.h mcux_config.h usb_pd_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c
  group flash_config
    ../../../../../flash_config/: flash_config.c flash_config.h
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv8m_mpu.h
  group device
    ../../../../../../../devices/MIMXRT798S/: fsl_device_registers.h MIMXRT798S_cm33_core0.h MIMXRT798S_cm33_core0_COMMON.h MIMXRT798S_cm33_core0_features.h system_MIMXRT798S_cm33_core0.c system_MIMXRT798S_cm33_core0.h
  group device/periph
    ../../../../../../../devices/MIMXRT798S/periph/: PERI_ADC.h PERI_AHBSC0.h PERI_AHBSC3.h PERI_AHBSC4.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CDOG.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CLKCTL2.h PERI_CLKCTL3.h PERI_CLKCTL4.h PERI_CMP.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUG_MAILBOX.h PERI_DMA.h PERI_ELS.h PERI_FLEXIO.h PERI_FREQME.h PERI_FRO.h PERI_GDET.h PERI_GLIKEY.h PERI_GPIO.h PERI_I2S.h PERI_I3C.h PERI_INPUTMUX0.h PERI_INPUTMUX1.h PERI_IOPCTL0.h PERI_IOPCTL1.h PERI_IOPCTL2.h PERI_ITRC.h PERI_JPEGDEC.h PERI_JPGDECWRP.h PERI_LCDIF.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_LP_FLEXCOMM.h PERI_MIPI_DSI_HOST.h PERI_MMU.h PERI_MRT.h PERI_MU.h PERI_NIC.h PERI_OCOTP.h PERI_OSC32KNP.h PERI_OSCCA.h PERI_OSTIMER.h PERI_PDM.h PERI_PINT.h PERI_PKC.h PERI_PMC.h PERI_PNGDEC.h PERI_PUF.h PERI_PVTS.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RSTCTL2.h PERI_RSTCTL3.h PERI_RSTCTL4.h PERI_RTC.h PERI_SCT.h PERI_SDADC.h PERI_SEMA42.h PERI_SLEEPCON0.h PERI_SLEEPCON1.h PERI_SYSCON0.h PERI_SYSCON1.h PERI_SYSCON2.h PERI_SYSCON3.h PERI_SYSCON4.h PERI_SYSPM.h PERI_TRNG.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_UTICK.h PERI_WWDT.h PERI_XCACHE.h PERI_XSPI.h
  group startup
    ../../../../../../../devices/MIMXRT798S/: startup_MIMXRT798S_cm33_core0.c
  group drivers
    ../../../../../../../devices/MIMXRT798S/drivers/: fsl_clock.c fsl_clock.h fsl_inputmux_connections.h fsl_iopctl.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_glikey.h fsl_glikey.c fsl_gpio.h fsl_gpio.c fsl_inputmux.h fsl_inputmux.c fsl_lpflexcomm.h fsl_lpflexcomm.c fsl_lpuart.h fsl_lpuart.c fsl_lpi2c.h fsl_lpi2c.c fsl_mrt.h fsl_mrt.c fsl_pint.h fsl_pint.c fsl_xspi.c fsl_xspi.h
  group utilities
    ../../../../../../../devices/MIMXRT798S/utilities/debug_console/: fsl_assert.h fsl_assert.c
    ../../../../../../../devices/MIMXRT798S/utilities/: fsl_memcpy.S
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group utilities/str
    ../../../../../../../devices/MIMXRT798S/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console
    ../../../../../../../devices/MIMXRT798S/utilities/debug_console/: fsl_debug_console.h fsl_debug_console.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/gpio
    ../../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_gpio.c
  group component/timer
    ../../../../../../../components/timer/: fsl_adapter_timer.h fsl_adapter_mrt.c
  group component/i2c
    ../../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/osa
    ../../../../../../../components/osa/: fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h
  group usb/include
    ../../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group usb/pd/ptn5110
    ../../../../../../../middleware/usb/pd/ptn5110/: usb_pd_ptn5110.h usb_pd_ptn5110_connect.c usb_pd_ptn5110_hal.c usb_pd_ptn5110_interface.c usb_pd_ptn5110_msg.c usb_pd_ptn5110_register.h
  group usb/pd
    ../../../../../../../middleware/usb/pd/: usb_pd_timer.c usb_pd.h usb_pd_connect.c usb_pd_interface.h usb_pd_interface.c usb_pd_msg.c usb_pd_phy.h usb_pd_policy.c usb_pd_spec.h usb_pd_timer.c usb_pd_timer.h usb_pd_auto_policy.h
  group usb/pd/phy_interface
    ../../../../../../../middleware/usb/pd/phy_interface/: usb_pd_i2c.h usb_pd_i2c.c
  group usb/pd/alt_mode
    ../../../../../../../middleware/usb/pd/alt_mode/: usb_pd_alt_mode.c usb_pd_alt_mode.h usb_pd_alt_mode_dp.c usb_pd_alt_mode_dp.h
  group usb/phy
    ../../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group freertos/freertos-kernel
    ../../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable
    ../../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure
    ../../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.c port.c portasm.c portasm.h portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/template
    ../../../../../../../rtos/freertos/freertos-kernel/template/: FreeRTOSConfig.h
  group doc
    ../: readme.md examples_shared_readme.md ugreen_typec_hdmi.jpg
target usb_pd_alt_mode_dp_host_freertos_om13790host_cm33_core0 flash_debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT798SGFOB:cm33_core0 NXP
  pack: NXP.MIMXRT798S_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: usb_pd_alt_mode_dp_host_freertos_om13790host_cm33_core0.out
  AfterMake: as above
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20080000 size 0x280000
  memory RVCT7: RAM 0x30080000 size 0x280000
  memory RVCT8: RAM 0x680000 size 0x100000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x10080000 size 0x280000
  scatter file: MIMXRT798Sxxxx_cm33_core0_flash.scf
  link misc: as above
target usb_pd_alt_mode_dp_host_freertos_om13790host_cm33_core0 release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT798SGFOB:cm33_core0 NXP
  pack: NXP.MIMXRT798S_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: usb_pd_alt_mode_dp_host_freertos_om13790host_cm33_core0.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, SDK_OS_FREE_RTOS, I2C_RETRY_TIMES=40000, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT798SGFOB_cm33_core0, MIMXRT798S_cm33_core0_SERIES, DEBUG_CONSOLE_TRANSFER_NON_BLOCKING, BOOT_HEADER_ENABLE=1, SERIAL_PORT_TYPE_UART=1, TIMER_PORT_TYPE_MRT=1, USE_RTOS=1
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20080000 size 0x280000
  memory RVCT7: RAM 0x30080000 size 0x280000
  memory RVCT8: RAM 0x680000 size 0x100000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x10080000 size 0x280000
  scatter file: MIMXRT798Sxxxx_cm33_core0_ram.scf
  link misc: as above
target usb_pd_alt_mode_dp_host_freertos_om13790host_cm33_core0 flash_release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT798SGFOB:cm33_core0 NXP
  pack: NXP.MIMXRT798S_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: usb_pd_alt_mode_dp_host_freertos_om13790host_cm33_core0.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: -include ../mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20080000 size 0x280000
  memory RVCT7: RAM 0x30080000 size 0x280000
  memory RVCT8: RAM 0x680000 size 0x100000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x10080000 size 0x280000
  scatter file: MIMXRT798Sxxxx_cm33_core0_flash.scf
  link misc: as above
