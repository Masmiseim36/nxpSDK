# IAR project hello_world_virtual_com.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 NXP MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK22FN512VDC12; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; SERIAL_PORT_TYPE_USBCDC=1; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; USB_STACK_BM; BOARD_USE_VIRTUALCOM=1; TWR_K22F120M; TOWER; SERIAL_PORT_TYPE_USBCDC=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ..; ../../..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../components/serial_manager; ../../../../../devices/MK22F51212/drivers; ../../../../../components/lists; ../../../../../components/serial_manager/usb_cdc_adapter; ../../../component_examples/config; ../../../../../middleware/usb/device; ../../../../../middleware/usb/include; ../../../../../devices/MK22F51212/drivers; ../../../../../devices/MK22F51212; ../../../../../devices/MK22F51212/utilities/str; ../../../../../devices/MK22F51212/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../devices/MK22F51212/drivers; ../../../../../devices/MK22F51212/drivers; ../../../../../devices/MK22F51212/drivers; ../../../../../devices/MK22F51212/drivers; ../../../../../devices/MK22F51212/drivers; ../../../../../components/osa; ../../../../../devices/MK22F51212/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: hello_world_virtual_com.out
  ILINK.IlinkIcfFile: MK22FN512xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK22FN512VDC12; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; SERIAL_PORT_TYPE_USBCDC=1; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; USB_STACK_BM; BOARD_USE_VIRTUALCOM=1; TWR_K22F120M; TOWER; SERIAL_PORT_TYPE_USBCDC=1; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: hello_world.c
  group board
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_usb.c serial_port_usb.h serial_port_uart.c serial_port_uart.h
  group component/serial_manager/usb_cdc_adapter
    ../../../../../components/serial_manager/usb_cdc_adapter/: usb_device_descriptor.c usb_device_descriptor.h usb_device_cdc_acm.c usb_device_cdc_acm.h usb_device_class.c usb_device_class.h usb_device_ch9.c usb_device_ch9.h
    ../../../component_examples/config/: usb_device_config.h
  group component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group component/uart
    ../../../../../components/uart/: uart.h uart_adapter.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group drivers
    ../../../../../devices/MK22F51212/drivers/: fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_uart.c fsl_uart.h fsl_lpuart.c fsl_lpuart.h fsl_port.h fsl_smc.c fsl_smc.h fsl_gpio.c fsl_gpio.h
  group usb/device/source
    ../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/khci
    ../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
  group usb/device/include
    ../../../../../middleware/usb/device/: usb_device.h
  group usb/include
    ../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group device
    ../../../../../devices/MK22F51212/: MK22F51212.h MK22F51212_features.h fsl_device_registers.h system_MK22F51212.c system_MK22F51212.h
  group utilities
    ../../../../../devices/MK22F51212/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MK22F51212/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK22F51212/utilities/: fsl_assert.c
  group startup
    ../../../../../devices/MK22F51212/iar/: startup_MK22F51212.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
