# Keil uVision project i2c_read_accel_value_transfer.uvprojx, settings and files
target i2c_read_accel_value_transfer Debug (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: i2c_read_accel_value_transfer.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MK22FN512VDC12, PRINTF_ADVANCED_ENABLE=1, TWR_K22F120M, TOWER
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../CMSIS/Include;../../../../../../devices;..;../../../..;../../../../../../devices/MK22F51212/drivers;../../../../../../devices/MK22F51212/utilities;../../../../../../devices/MK22F51212
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: --remove
  group startup
    ../../../../../../devices/MK22F51212/arm/: startup_MK22F51212.s
    ../../../../../../devices/MK22F51212/: system_MK22F51212.c system_MK22F51212.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MK22F51212/drivers/: fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_i2c.h fsl_i2c.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group source
    ../: i2c_read_accel_value_transfer.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../devices/MK22F51212/utilities/: fsl_debug_console.c fsl_debug_console.h
target i2c_read_accel_value_transfer Release (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: i2c_read_accel_value_transfer.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MK22FN512VDC12, PRINTF_ADVANCED_ENABLE=1, TWR_K22F120M, TOWER
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: --remove
