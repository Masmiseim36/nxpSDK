# IAR project sai_interrupt_record_playback.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 NXP MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK22FN512VDC12; TWR_K22F120M; TOWER; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../platform/components/sgtl5000; ../..; ..; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MK22F51212/drivers; ../../../../../../components/codec/sgtl5000; ../../../../../../components/codec; ../../../../../../devices/MK22F51212/drivers; ../../../../../../devices/MK22F51212/drivers; ../../../../../../devices/MK22F51212/drivers; ../../../../../../devices/MK22F51212/drivers; ../../../../../../devices/MK22F51212/drivers; ../../../../../../devices/MK22F51212; ../../../../../../devices/MK22F51212/utilities/str; ../../../../../../devices/MK22F51212/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/serial_manager; ../../../../../../devices/MK22F51212/drivers; ../../../../../../components/lists; ../../../../../../devices/MK22F51212/drivers; ../../../../../../devices/MK22F51212/drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: sai_interrupt_record_playback.out
  ILINK.IlinkIcfFile: MK22FN512xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK22FN512VDC12; TWR_K22F120M; TOWER; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source_transfer
    ../: sai_interrupt_record_playback.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MK22F51212/drivers/: fsl_i2c.h fsl_i2c.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_sai.h fsl_sai.c fsl_common.h fsl_common.c fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_smc.h fsl_smc.c
  group codec
    ../../../../../../components/codec/sgtl5000/: fsl_sgtl5000.h fsl_sgtl5000.c
    ../../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
  group device
    ../../../../../../devices/MK22F51212/: fsl_device_registers.h MK22F51212.h MK22F51212_features.h system_MK22F51212.c system_MK22F51212.h
  group utilities
    ../../../../../../devices/MK22F51212/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MK22F51212/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MK22F51212/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../components/uart/: uart.h uart_adapter.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: generic_list.h generic_list.c
  group startup
    ../../../../../../devices/MK22F51212/iar/: startup_MK22F51212.s
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
