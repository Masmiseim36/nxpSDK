# IAR project dev_audio_speaker_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 NXP MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; CPU_MK22FN512VDC12; USB_STACK_FREERTOS_HEAP_SIZE=32768; USB_STACK_FREERTOS; USING_SAI; FSL_RTOS_FREE_RTOS; TWR_K22F120M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F; ../../../../../../rtos/freertos_9.0.0/Source/include; ..; ../../../../../../rtos/freertos_9.0.0/Source; ../../../../../../middleware/usb_1.6.3; ../../../../../../middleware/usb_1.6.3/osa; ../../../../../../middleware/usb_1.6.3/include; ../../../../../../middleware/usb_1.6.3/device; ../../../../../../CMSIS/Include; ../../../..; ../../../../../../devices/MK22F51212/drivers; ../../../../../../devices/MK22F51212/utilities; ../../../../../../devices/MK22F51212
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../..; ..
  ILINK.IlinkOutputFile: dev_audio_speaker_freertos.out
  ILINK.IlinkIcfFile: MK22FN512xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK22FN512VDC12; USB_STACK_FREERTOS_HEAP_SIZE=32768; USB_STACK_FREERTOS; USING_SAI; FSL_RTOS_FREE_RTOS; TWR_K22F120M; TOWER
  ICCARM.CCOptLevel: 3
  group freertos
    ../../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
    ../../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
    ../../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group freertos/portable
    ../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F/: port.c fsl_tickless_systick.c fsl_tickless_generic.h portasm.s portmacro.h
  group startup
    ../../../../../../devices/MK22F51212/iar/: startup_MK22F51212.s
    ../../../../../../devices/MK22F51212/: system_MK22F51212.c system_MK22F51212.h
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb_1.6.3/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/khci
    ../../../../../../middleware/usb_1.6.3/device/: usb_device_khci.c usb_device_khci.h
    ../../../../../../middleware/usb_1.6.3/include/: usb_khci.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/audio
    ../: usb_device_audio.c usb_device_audio.h
  group usb/device/include
    ../../../../../../middleware/usb_1.6.3/device/: usb_device.h
  group usb/include
    ../../../../../../middleware/usb_1.6.3/include/: usb.h usb_misc.h usb_spec.h
  group drivers
    ../../../../../../devices/MK22F51212/drivers/: fsl_sai.h fsl_sai.c fsl_i2c.h fsl_i2c.c fsl_sai_edma.h fsl_sai_edma.c fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c fsl_port.h fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group sources
    ../: sgtl5000_interface.c audio_speaker.c audio_speaker.h usb_device_descriptor.c usb_device_descriptor.h usb_device_config.h FreeRTOSConfig.h
  group codec
    ../: fsl_sgtl5000.h fsl_sgtl5000.c
  group osa
    ../../../../../../middleware/usb_1.6.3/osa/: usb_osa.h usb_osa_freertos.h usb_osa_freertos.c
  group utilities
    ../../../../../../devices/MK22F51212/utilities/: fsl_debug_console.c fsl_debug_console.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
