# Keil uVision project dev_composite_hid_audio_unified_freertos.uvprojx, settings and files
target dev_composite_hid_audio_unified_freertos debug (ARM-ADS)
  device: MK22FN512VDC12 NXP
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: dev_composite_hid_audio_unified_freertos.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _DEBUG=1, DEBUG, CPU_MK22FN512VDC12, USB_STACK_FREERTOS, USB_STACK_FREERTOS_HEAP_SIZE=32768, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_SGTL5000_ENABLE, FSL_RTOS_FREE_RTOS, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../../rtos/amazon-freertos/freertos_kernel/portable/GCC/ARM_CM4F;..;../../../..;../../../../../../CMSIS/Include;../../../../../../rtos/amazon-freertos/freertos_kernel/include;../../../../../../middleware/usb;../../../../../../middleware/usb/include;../../../../../../middleware/usb/device;../../../../../../middleware/usb/device;../../../../../../middleware/usb/include;../../../../../../devices/MK22F51212/drivers;../../../../../../components/codec/sgtl5000;../../../../../../devices/MK22F51212/drivers;../../../../../../devices/MK22F51212/drivers;../../../../../../devices/MK22F51212/drivers;../../../../../../devices/MK22F51212/drivers;../../../../../../components/codec;../../../../../../components/codec/port;../../../../../../components/i2c;../../../../../../devices/MK22F51212/drivers;../../../../../../devices/MK22F51212/drivers;../../../../../../devices/MK22F51212/drivers;../../../../../../devices/MK22F51212;../../../../../../devices/MK22F51212/drivers;../../../../../../devices/MK22F51212/drivers;../../../../../../devices/MK22F51212/drivers;../../../../../../devices/MK22F51212/utilities/str;../../../../../../devices/MK22F51212/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../components/serial_manager;../../../../../../devices/MK22F51212/drivers;../../../../../../components/osa;../../../../../../components/codec/i2c;../../../../../../devices/MK22F51212/utilities
  asm define: DEBUG
  asm include: ../../../..;..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x100"
  group doc
    ../: readme.txt
  group source
    ../: audio_unified.c audio_unified.h composite.c composite.h hid_keyboard.c hid_keyboard.h usb_device_descriptor.c usb_device_descriptor.h usb_device_config.h FreeRTOSConfig.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group usb-device-source-khci
    ../../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
  group usb-include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group drivers
    ../../../../../../devices/MK22F51212/drivers/: fsl_sai.c fsl_sai.h fsl_i2c.c fsl_i2c.h fsl_sai_edma.c fsl_sai_edma.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_smc.c fsl_smc.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_uart.c fsl_uart.h fsl_gpio.c fsl_gpio.h fsl_port.h
  group codec
    ../../../../../../components/codec/sgtl5000/: fsl_sgtl5000.c fsl_sgtl5000.h
    ../../../../../../components/codec/: fsl_codec_common.c fsl_codec_common.h
    ../../../../../../components/codec/port/: fsl_codec_adapter.h
    ../../../../../../components/codec/port/sgtl5000/: fsl_codec_adapter.c
    ../../../../../../components/codec/i2c/: fsl_codec_i2c.c fsl_codec_i2c.h
  group component/i2c
    ../../../../../../components/i2c/: i2c.h i2c_adapter.c
  group usb-device-include
    ../../../../../../middleware/usb/device/: usb_device.h
  group usb-device-source
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
    ../: usb_device_ch9.c usb_device_ch9.h
  group amazon-freertos-freertos_kernel-portable-MemMang
    ../../../../../../rtos/amazon-freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group amazon-freertos-freertos_kernel
    ../../../../../../rtos/amazon-freertos/freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos-freertos_kernel-include
    ../../../../../../rtos/amazon-freertos/freertos_kernel/include/: FreeRTOS.h atomic.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group amazon-freertos-freertos_kernel-portable-GCC-ARM_CM4F
    ../../../../../../rtos/amazon-freertos/freertos_kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group amazon-freertos-freertos_kernel-portable
    ../../../../../../rtos/amazon-freertos/freertos_kernel/portable/: readme.txt
  group usb-device-class
    ../: usb_device_class.c usb_device_class.h
  group usb-device-class-audio
    ../: usb_device_audio.c usb_device_audio.h
  group usb-device-class-hid
    ../: usb_device_hid.c usb_device_hid.h
  group device
    ../../../../../../devices/MK22F51212/: MK22F51212.h MK22F51212_features.h fsl_device_registers.h system_MK22F51212.c system_MK22F51212.h
  group startup
    ../../../../../../devices/MK22F51212/arm/: startup_MK22F51212.s
  group utilities
    ../../../../../../devices/MK22F51212/utilities/: fsl_assert.c
    ../../../../../../devices/MK22F51212/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MK22F51212/utilities/str/: fsl_str.c fsl_str.h
  group component-uart
    ../../../../../../components/uart/: uart.h uart_adapter.c
  group component-serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction_free_rtos.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
target dev_composite_hid_audio_unified_freertos release (ARM-ADS)
  device: MK22FN512VDC12 NXP
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: dev_composite_hid_audio_unified_freertos.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _DEBUG=0, NDEBUG, CPU_MK22FN512VDC12, USB_STACK_FREERTOS, USB_STACK_FREERTOS_HEAP_SIZE=32768, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_SGTL5000_ENABLE, FSL_RTOS_FREE_RTOS, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG
  asm include: ../../../..;..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: as above
