# IAR project host_msd_fatfs_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 NXP MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; CPU_MK22FN512VDC12; USB_STACK_BM; PRINTF_ADVANCED_ENABLE=1; TWR_K22F120M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..; ../../../../../../middleware/fatfs_0.12b/src; ../../../../../../middleware/usb_1.6.3; ../../../../../../middleware/usb_1.6.3/osa; ../../../../../../middleware/usb_1.6.3/include; ../../../../../../CMSIS/Include; ../../../..; ../../../../../../middleware/usb_1.6.3/host; ../../../../../../devices/MK22F51212/drivers; ../../../../../../middleware/usb_1.6.3/host/class; ../../../../../../middleware/fatfs_0.12b/src/option; ../../../../../../devices/MK22F51212/utilities; ../../../../../../devices/MK22F51212
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: host_msd_fatfs_bm.out
  ILINK.IlinkIcfFile: MK22FN512xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK22FN512VDC12; USB_STACK_BM; PRINTF_ADVANCED_ENABLE=1; TWR_K22F120M; TOWER
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/MK22F51212/iar/: startup_MK22F51212.s
    ../../../../../../devices/MK22F51212/: system_MK22F51212.c system_MK22F51212.h
  group usb/host
    ../../../../../../middleware/usb_1.6.3/host/: usb_host_khci.c usb_host_khci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c
  group usb/host/class
    ../../../../../../middleware/usb_1.6.3/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_msd.c usb_host_msd.h usb_host_msd_ufi.c
  group usb/include
    ../../../../../../middleware/usb_1.6.3/include/: usb.h usb_misc.h usb_spec.h
  group drivers
    ../../../../../../devices/MK22F51212/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c fsl_port.h fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group osa
    ../../../../../../middleware/usb_1.6.3/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group fatfs/fatfs_source
    ../../../../../../middleware/fatfs_0.12b/src/: ff.c diskio.c
  group fatfs/fatfs_include
    ../../../../../../middleware/fatfs_0.12b/src/: integer.h ff.h diskio.h
  group sources
    ../: app.c host_msd_fatfs.c ffconf.h host_msd_fatfs.h usb_host_config.h fsl_usb_disk.h fsl_usb_disk_bm.c
  group utilities
    ../../../../../../devices/MK22F51212/utilities/: fsl_debug_console.c fsl_debug_console.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
