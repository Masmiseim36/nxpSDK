# IAR project otg_hid_mouse_freertos.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 NXP MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; DEBUG; CPU_MK22FN512VDC12; USB_STACK_FREERTOS; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; USB_STACK_FREERTOS_HEAP_SIZE=32768; FSL_RTOS_FREE_RTOS; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/amazon-freertos/freertos_kernel/portable/IAR/ARM_CM4F; ..; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../rtos/amazon-freertos/freertos_kernel/include; ../../../../../../middleware/usb; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/device; ../../../../../../middleware/usb/host; ../../../../../../middleware/usb/device; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/host; ../../../../../../middleware/usb/include; ../../../../../../devices/MK22F51212/drivers; ../../../../../../middleware/usb/host; ../../../../../../middleware/usb/otg; ../../../../../../middleware/usb/host/class; ../../../../../../devices/MK22F51212/drivers; ../../../../../../devices/MK22F51212/drivers; ../../../../../../devices/MK22F51212/drivers; ../../../../../../devices/MK22F51212; ../../../../../../devices/MK22F51212/drivers; ../../../../../../devices/MK22F51212/drivers; ../../../../../../devices/MK22F51212/drivers; ../../../../../../devices/MK22F51212/utilities/str; ../../../../../../devices/MK22F51212/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../components/serial_manager; ../../../../../../devices/MK22F51212/drivers; ../../../../../../components/osa; ../../../../../../devices/MK22F51212/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..; ../../../..
  ILINK.IlinkOutputFile: otg_hid_mouse_freertos.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x100
  ILINK.IlinkIcfFile: MK22FN512xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; NDEBUG; CPU_MK22FN512VDC12; USB_STACK_FREERTOS; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; USB_STACK_FREERTOS_HEAP_SIZE=32768; FSL_RTOS_FREE_RTOS; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group doc
    ../: readme.txt
  group source
    ../: usb_otg_config.h usb_otg_mouse.h usb_otg_mouse.c device_mouse.c device_mouse.h host_mouse.c host_mouse.h usb_device_descriptor.c usb_device_descriptor.h usb_host_config.h usb_device_config.h FreeRTOSConfig.h usb_i2c_drv.c usb_i2c_drv.h usb_otg_max3353.c usb_otg_max3353.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group usb/otg
    ../../../../../../middleware/usb/otg/: usb_otg_khci.c usb_otg_khci.h usb_otg.h usb_otg_oci.c usb_otg_oci.h usb_otg_peripheral.h
  group usb/device/source
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
    ../: usb_device_ch9.c usb_device_ch9.h
  group usb/device/source/khci
    ../../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
  group usb/device/include
    ../../../../../../middleware/usb/device/: usb_device.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/hid
    ../: usb_device_hid.c usb_device_hid.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h usb.h usb_misc.h usb_spec.h
  group usb/host
    ../../../../../../middleware/usb/host/: usb_host_khci.c usb_host_khci.h usb_host.h usb_host_devices.c usb_host_devices.h usb_host_framework.c usb_host_framework.h usb_host_hci.c usb_host_hci.h
  group usb/host/class
    ../../../../../../middleware/usb/host/class/: usb_host_hid.c usb_host_hid.h
  group drivers
    ../../../../../../devices/MK22F51212/drivers/: fsl_i2c.c fsl_i2c.h fsl_smc.c fsl_smc.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_uart.c fsl_uart.h fsl_gpio.c fsl_gpio.h fsl_port.h
  group amazon-freertos/freertos_kernel
    ../../../../../../rtos/amazon-freertos/freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos/freertos_kernel/portable
    ../../../../../../rtos/amazon-freertos/freertos_kernel/portable/: readme.txt
  group amazon-freertos/freertos_kernel/portable/MemMang
    ../../../../../../rtos/amazon-freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group amazon-freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../../rtos/amazon-freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group amazon-freertos/freertos_kernel/include
    ../../../../../../rtos/amazon-freertos/freertos_kernel/include/: FreeRTOS.h atomic.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group device
    ../../../../../../devices/MK22F51212/: MK22F51212.h MK22F51212_features.h fsl_device_registers.h system_MK22F51212.c system_MK22F51212.h
  group startup
    ../../../../../../devices/MK22F51212/iar/: startup_MK22F51212.s
  group utilities
    ../../../../../../devices/MK22F51212/utilities/: fsl_assert.c
    ../../../../../../devices/MK22F51212/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MK22F51212/utilities/str/: fsl_str.c fsl_str.h
  group component/uart
    ../../../../../../components/uart/: uart.h uart_adapter.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction_free_rtos.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
