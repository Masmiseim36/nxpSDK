# Keil uVision project cmsis_i2c_read_accel_value_transfer.uvprojx, settings and files
target cmsis_i2c_read_accel_value_transfer Debug (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  cpu: CPUTYPE("Cortex-M4")
  output: cmsis_i2c_read_accel_value_transfer.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MK60DN512VMD10, TWR_K60D100M, TOWER
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../CMSIS/Include;../../../../../../devices;..;../../../../../../CMSIS/Driver/Include;../../../..;../../../../../../devices/MK60D10/drivers;../../../../../../devices/MK60D10/cmsis_drivers;../../../../../../devices/MK60D10/utilities;../../../../../../devices/MK60D10
  asm define: CPU_MK64FN1M0VMD12, DEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK60DN512xxx10_flash.scf
  link misc: --remove
  group startup
    ../../../../../../devices/MK60D10/arm/: startup_MK60D10.s
    ../../../../../../devices/MK60D10/: system_MK60D10.c system_MK60D10.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MK60D10/drivers/: fsl_uart.h fsl_uart.c fsl_port.h fsl_clock.h fsl_clock.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_i2c.h fsl_i2c.c fsl_i2c_edma.c fsl_i2c_edma.h fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
    ../../../../../../devices/MK60D10/cmsis_drivers/: fsl_i2c_cmsis.h fsl_i2c_cmsis.c
  group source
    ../: cmsis_i2c_read_accel_value_transfer.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../devices/MK60D10/utilities/: fsl_debug_console.c fsl_debug_console.h
target cmsis_i2c_read_accel_value_transfer Release (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.0.2
  cpu: CPUTYPE("Cortex-M4")
  output: cmsis_i2c_read_accel_value_transfer.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MK60DN512VMD10, TWR_K60D100M, TOWER
  c misc: as above
  c include: as above
  asm define: CPU_MK64FN1M0VMD12, NDEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK60DN512xxx10_flash.scf
  link misc: --remove
