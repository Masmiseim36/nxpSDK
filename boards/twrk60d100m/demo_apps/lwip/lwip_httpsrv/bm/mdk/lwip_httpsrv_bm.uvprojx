# Keil uVision project lwip_httpsrv_bm.uvprojx, settings and files
target lwip_httpsrv_bm Debug (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  cpu: CPUTYPE("Cortex-M4")
  output: lwip_httpsrv_bm.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MK60DN512VMD10, PRINTF_ADVANCED_ENABLE=1, TWR_K60D100M, TOWER
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../../platform/components/phyksz8041;../../../../../../../CMSIS/Include;../../../../../../../devices;..;../../../../../../../middleware/lwip_2.0.0/port;../../../../../../../middleware/lwip_2.0.0/src;../../../../../../../middleware/lwip_2.0.0/src/include;../../../../../../../middleware/lwip_2.0.0/contrib/apps;../../../../..;../../../../../../../devices/MK60D10/drivers;../../../../../../../devices/MK60D10/utilities;../../../../../../../devices/MK60D10
  asm define: CPU_MK64FN1M0VMD12, DEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK60DN512xxx10_flash.scf
  link misc: --remove 
--predefine="-D__ram_vector_table__=1"
  group startup
    ../../../../../../../devices/MK60D10/arm/: startup_MK60D10.s
    ../../../../../../../devices/MK60D10/: system_MK60D10.c system_MK60D10.h
  group doc
    ../: readme.txt
  group board
    ../: fsl_phy.h fsl_phy.c pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group drivers
    ../../../../../../../devices/MK60D10/drivers/: fsl_uart.h fsl_uart.c fsl_port.h fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_enet.h fsl_enet.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group lwip-src-apps-httpd
    ../../../../../../../middleware/lwip_2.0.0/src/apps/httpd/: fs.c fsdata.h httpd_structs.h httpd.c
  group lwip-src-include-lwip-apps
    ../../../../../../../middleware/lwip_2.0.0/src/include/lwip/apps/: fs.h httpd.h httpd_opts.h
  group source
    ../: lwip_httpsrv_bm.c
  group utilities
    ../../../../../../../devices/MK60D10/utilities/: fsl_debug_console.c fsl_debug_console.h
  group lwip-port
    ../../../../../../../middleware/lwip_2.0.0/port/: ethernetif.c ethernetif.h lwipopts.h sys_arch.c
  group lwip-port-arch
    ../../../../../../../middleware/lwip_2.0.0/port/arch/: cc.h perf.h sys_arch.h
  group lwip-src-api
    ../../../../../../../middleware/lwip_2.0.0/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-src-core
    ../../../../../../../middleware/lwip_2.0.0/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip-src-core-ipv4
    ../../../../../../../middleware/lwip_2.0.0/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip-src-core-ipv6
    ../../../../../../../middleware/lwip_2.0.0/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip-src-include-lwip
    ../../../../../../../middleware/lwip_2.0.0/src/include/lwip/: api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h igmp.h inet.h inet_chksum.h init.h ip.h ip_addr.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpip.h timeouts.h udp.h
  group lwip-src-include-lwip-priv
    ../../../../../../../middleware/lwip_2.0.0/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h tcp_priv.h tcpip_priv.h
  group lwip-src-include-lwip-prot
    ../../../../../../../middleware/lwip_2.0.0/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h ethernet.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip-src-include-netif
    ../../../../../../../middleware/lwip_2.0.0/src/include/netif/: etharp.h ethernet.h lowpan6.h lowpan6_opts.h slipif.h
    ../../../../../../../middleware/lwip_2.0.0/src/include/netif/ppp/: pppoe.h
  group lwip-src-include-posix
    ../../../../../../../middleware/lwip_2.0.0/src/include/posix/: errno.h netdb.h
  group lwip-src-include-posix-sys
    ../../../../../../../middleware/lwip_2.0.0/src/include/posix/sys/: socket.h
  group lwip-src-netif
    ../../../../../../../middleware/lwip_2.0.0/src/netif/: ethernet.c lowpan6.c slipif.c
  group lwip-src-netif-ppp
    ../../../../../../../middleware/lwip_2.0.0/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lwip-src-include-netif-ppp
    ../../../../../../../middleware/lwip_2.0.0/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip-src-include-netif-ppp-polarssl
    ../../../../../../../middleware/lwip_2.0.0/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
target lwip_httpsrv_bm Release (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.0.2
  cpu: CPUTYPE("Cortex-M4")
  output: lwip_httpsrv_bm.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MK60DN512VMD10, PRINTF_ADVANCED_ENABLE=1, TWR_K60D100M, TOWER
  c misc: as above
  c include: as above
  asm define: CPU_MK64FN1M0VMD12, NDEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK60DN512xxx10_flash.scf
  link misc: --remove 
--predefine="-D__ram_vector_table__=1"
