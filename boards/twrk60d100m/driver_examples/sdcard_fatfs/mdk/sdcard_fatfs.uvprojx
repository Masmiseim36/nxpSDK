# Keil uVision project sdcard_fatfs.uvprojx, settings and files
target sdcard_fatfs Debug (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  cpu: CPUTYPE("Cortex-M4")
  output: sdcard_fatfs.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MK60DN512VMD10, TWR_K60D100M, TOWER
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;..;../../../../../middleware/sdmmc_2.1.2/inc;../../../../../middleware/sdmmc_2.1.2/src;../../../../../middleware/sdmmc_2.1.2/port;../../..;../../../../../devices/MK60D10/drivers;../../../../../middleware/fatfs_0.12b/src/fsl_sd_disk;../../../../../devices/MK60D10/utilities;../../../../../middleware/fatfs_0.12b/src;../../../../../middleware/fatfs_0.12b/src/option;../../../../../devices/MK60D10
  asm define: CPU_MK64FN1M0VMD12, DEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK60DN512xxx10_flash.scf
  link misc: --remove
  group startup
    ../../../../../devices/MK60D10/arm/: startup_MK60D10.s
    ../../../../../devices/MK60D10/: system_MK60D10.c system_MK60D10.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK60D10/drivers/: fsl_uart.h fsl_uart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_sysmpu.h fsl_sysmpu.c fsl_sdhc.h fsl_sdhc.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group sdmmc-src
    ../../../../../middleware/sdmmc_2.1.2/src/: fsl_sd.c fsl_sdmmc.c
  group fatfs-fatfs_include
    ../../../../../middleware/fatfs_0.12b/src/fsl_sd_disk/: fsl_sd_disk.h
    ../../../../../middleware/fatfs_0.12b/src/: integer.h ff.h diskio.h
  group fatfs-fatfs_source
    ../../../../../middleware/fatfs_0.12b/src/fsl_sd_disk/: fsl_sd_disk.c
    ../../../../../middleware/fatfs_0.12b/src/: ff.c diskio.c
  group source
    ../: sdcard_fatfs.c ffconf.h
  group sdmmc-port
    ../: fsl_host.c event.c event.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MK60D10/utilities/: fsl_debug_console.c fsl_debug_console.h
  group sdmmc-inc
    ../../../../../middleware/sdmmc_2.1.2/inc/: fsl_card.h fsl_host.h fsl_sdmmc.h fsl_specification.h
target sdcard_fatfs Release (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.0.2
  cpu: CPUTYPE("Cortex-M4")
  output: sdcard_fatfs.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MK60DN512VMD10, TWR_K60D100M, TOWER
  c misc: as above
  c include: as above
  asm define: CPU_MK64FN1M0VMD12, NDEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK60DN512xxx10_flash.scf
  link misc: --remove
