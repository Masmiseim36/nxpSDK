# IAR project tsi_v2_low_power_mode.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 NXP MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MK60DN512VMD10; TWR_K60D100M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../devices; ..; ../../../..; ../../../../../../devices/MK60D10/drivers; ../../../../../../devices/MK60D10/utilities; ../../../../../../devices/MK60D10
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: tsi_v2_low_power_mode.out
  ILINK.IlinkIcfFile: MK60DN512xxx10_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK60DN512VMD10; TWR_K60D100M; TOWER
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/MK60D10/iar/: startup_MK60D10.s
    ../../../../../../devices/MK60D10/: system_MK60D10.c system_MK60D10.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MK60D10/drivers/: fsl_uart.h fsl_uart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_clock.h fsl_clock.c fsl_rcm.c fsl_rcm.h fsl_smc.h fsl_smc.c fsl_llwu.h fsl_llwu.c fsl_pmc.h fsl_pmc.c fsl_tsi_v2.h fsl_tsi_v2.c fsl_common.h fsl_common.c fsl_flash.c fsl_flash.h
  group source
    ../: tsi_v2_low_power.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../devices/MK60D10/utilities/: fsl_debug_console.c fsl_debug_console.h
