# Keil uVision project mmcau.uvprojx, settings and files
target mmcau Debug (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  cpu: CPUTYPE("Cortex-M4")
  output: mmcau.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MK60DN512VMD10, PRINTF_FLOAT_ENABLE=1, TWR_K60D100M, TOWER
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;..;../../../../../middleware/mmcau_2.0.0;../../..;../../../../../devices/MK60D10/drivers;../../../../../devices/MK60D10/utilities;../../../../../devices/MK60D10
  asm define: CPU_MK64FN1M0VMD12, DEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK60DN512xxx10_flash.scf
  link misc: ../../../../../middleware/mmcau_2.0.0/asm-cm4-cm7/lib_mmcau.lib 
--remove
  group startup
    ../../../../../devices/MK60D10/arm/: startup_MK60D10.s
    ../../../../../devices/MK60D10/: system_MK60D10.c system_MK60D10.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK60D10/drivers/: fsl_uart.h fsl_uart.c fsl_port.h fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group source
    ../: mmcau_api.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group mmcau-mmcau_include
    ../../../../../middleware/mmcau_2.0.0/: cau_api.h fsl_mmcau.h
  group mmcau-mmcau_source
    ../../../../../middleware/mmcau_2.0.0/: fsl_mmcau.c
  group utilities
    ../../../../../devices/MK60D10/utilities/: fsl_debug_console.c fsl_debug_console.h
target mmcau Release (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.0.2
  cpu: CPUTYPE("Cortex-M4")
  output: mmcau.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MK60DN512VMD10, PRINTF_FLOAT_ENABLE=1, TWR_K60D100M, TOWER
  c misc: as above
  c include: as above
  asm define: CPU_MK64FN1M0VMD12, NDEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK60DN512xxx10_flash.scf
  link misc: as above
