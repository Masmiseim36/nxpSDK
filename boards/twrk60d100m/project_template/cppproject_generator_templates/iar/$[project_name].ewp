# IAR project $[project_name].ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 NXP MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../platform/drivers; ../../../../../devices/MK60D10/drivers; ../../../../../devices/MK60D10/utilities; ../../../../../devices/MK60D10
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: cppproject_templates.out
  ILINK.IlinkIcfFile: MK60DN512xxx10_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../devices/MK60D10/iar/: startup_MK60D10.s
    ../../../../../devices/MK60D10/: system_MK60D10.c system_MK60D10.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK60D10/drivers/: fsl_uart.h fsl_uart.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group utilities
    ../../../../../devices/MK60D10/utilities/: fsl_debug_console.c fsl_debug_console.h
