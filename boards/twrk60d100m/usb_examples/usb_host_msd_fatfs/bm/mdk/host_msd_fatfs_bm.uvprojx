# Keil uVision project host_msd_fatfs_bm.uvprojx, settings and files
target host_msd_fatfs_bm Debug (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  cpu: CPUTYPE("Cortex-M4")
  output: host_msd_fatfs_bm.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: _DEBUG=1, CPU_MK60DN512VMD10, USB_STACK_BM, PRINTF_ADVANCED_ENABLE=1, TWR_K60D100M, TOWER
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..;../../../../../../middleware/fatfs_0.12b/src;../../../../../../middleware/usb_1.6.3;../../../../../../middleware/usb_1.6.3/osa;../../../../../../middleware/usb_1.6.3/include;../../../../../../CMSIS/Include;../../../..;../../../../../../middleware/usb_1.6.3/host;../../../../../../devices/MK60D10/drivers;../../../../../../middleware/usb_1.6.3/host/class;../../../../../../middleware/fatfs_0.12b/src/option;../../../../../../devices/MK60D10/utilities;../../../../../../devices/MK60D10
  asm define: CPU_MK64FN1M0VMD12, DEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK60DN512xxx10_flash.scf
  link misc: --remove
  group startup
    ../../../../../../devices/MK60D10/arm/: startup_MK60D10.s
    ../../../../../../devices/MK60D10/: system_MK60D10.c system_MK60D10.h
  group usb-host
    ../../../../../../middleware/usb_1.6.3/host/: usb_host_khci.c usb_host_khci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c
  group drivers
    ../../../../../../devices/MK60D10/drivers/: fsl_uart.h fsl_uart.c fsl_port.h fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_sysmpu.h fsl_sysmpu.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group osa
    ../../../../../../middleware/usb_1.6.3/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group usb-host-class
    ../../../../../../middleware/usb_1.6.3/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_msd.c usb_host_msd.h usb_host_msd_ufi.c
  group fatfs-fatfs_source
    ../../../../../../middleware/fatfs_0.12b/src/: ff.c diskio.c
  group fatfs-fatfs_include
    ../../../../../../middleware/fatfs_0.12b/src/: integer.h ff.h diskio.h
  group sources
    ../: app.c host_msd_fatfs.c ffconf.h host_msd_fatfs.h usb_host_config.h fsl_usb_disk.h fsl_usb_disk_bm.c
  group utilities
    ../../../../../../devices/MK60D10/utilities/: fsl_debug_console.c fsl_debug_console.h
  group usb-include
    ../../../../../../middleware/usb_1.6.3/include/: usb.h usb_misc.h usb_spec.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
target host_msd_fatfs_bm Release (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.0.2
  cpu: CPUTYPE("Cortex-M4")
  output: host_msd_fatfs_bm.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: _DEBUG=0, CPU_MK60DN512VMD10, USB_STACK_BM, PRINTF_ADVANCED_ENABLE=1, TWR_K60D100M, TOWER
  c misc: as above
  c include: as above
  asm define: CPU_MK64FN1M0VMD12, NDEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK60DN512xxx10_flash.scf
  link misc: --remove
