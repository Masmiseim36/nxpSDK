# IAR project host_msd_fatfs_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 NXP MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: _DEBUG=1; CPU_MK60DN512VMD10; USB_STACK_FREERTOS_HEAP_SIZE=32768; USB_STACK_FREERTOS; PRINTF_ADVANCED_ENABLE=1; FSL_RTOS_FREE_RTOS; TWR_K60D100M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM3; ../../../../../../rtos/freertos_9.0.0/Source/include; ..; ../../../../../../middleware/fatfs_0.12b/src; ../../../../../../rtos/freertos_9.0.0/Source; ../../../../../../middleware/usb_1.6.3; ../../../../../../middleware/usb_1.6.3/osa; ../../../../../../middleware/usb_1.6.3/include; ../../../../../../CMSIS/Include; ../../../..; ../../../../../../middleware/usb_1.6.3/host; ../../../../../../devices/MK60D10/drivers; ../../../../../../middleware/usb_1.6.3/host/class; ../../../../../../middleware/fatfs_0.12b/src/option; ../../../../../../devices/MK60D10/utilities; ../../../../../../devices/MK60D10
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../..; ..
  ILINK.IlinkOutputFile: host_msd_fatfs_freertos.out
  ILINK.IlinkIcfFile: MK60DN512xxx10_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK60DN512VMD10; USB_STACK_FREERTOS_HEAP_SIZE=32768; USB_STACK_FREERTOS; PRINTF_ADVANCED_ENABLE=1; FSL_RTOS_FREE_RTOS; TWR_K60D100M; TOWER
  ICCARM.CCOptLevel: 3
  group freertos
    ../../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
    ../../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
    ../../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group freertos/portable
    ../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM3/: port.c fsl_tickless_systick.c fsl_tickless_generic.h portasm.s portmacro.h
  group startup
    ../../../../../../devices/MK60D10/iar/: startup_MK60D10.s
    ../../../../../../devices/MK60D10/: system_MK60D10.c system_MK60D10.h
  group usb/host
    ../../../../../../middleware/usb_1.6.3/host/: usb_host_khci.c usb_host_khci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c
  group usb/host/class
    ../../../../../../middleware/usb_1.6.3/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_msd.c usb_host_msd.h usb_host_msd_ufi.c
  group usb/include
    ../../../../../../middleware/usb_1.6.3/include/: usb.h usb_misc.h usb_spec.h
  group drivers
    ../../../../../../devices/MK60D10/drivers/: fsl_uart.h fsl_uart.c fsl_port.h fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_sysmpu.h fsl_sysmpu.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group osa
    ../../../../../../middleware/usb_1.6.3/osa/: usb_osa.h usb_osa_freertos.h usb_osa_freertos.c
  group fatfs/fatfs_source
    ../../../../../../middleware/fatfs_0.12b/src/: ff.c diskio.c
  group fatfs/fatfs_include
    ../../../../../../middleware/fatfs_0.12b/src/: integer.h ff.h diskio.h
  group sources
    ../: app.c host_msd_fatfs.c ffconf.h host_msd_fatfs.h usb_host_config.h FreeRTOSConfig.h fsl_usb_disk.h fsl_usb_disk_freertos.c
  group utilities
    ../../../../../../devices/MK60D10/utilities/: fsl_debug_console.c fsl_debug_console.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
