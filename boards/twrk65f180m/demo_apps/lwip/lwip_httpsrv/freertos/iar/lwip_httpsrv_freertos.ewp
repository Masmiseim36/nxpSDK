# IAR project lwip_httpsrv_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK65FN2M0xxx18 NXP MK65FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK65FN2M0VMI18; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; HTTPSRV_CFG_WEBSOCKET_ENABLED=1; FSL_RTOS_FREE_RTOS; TWR_K65F180M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F; ../../../../../../../rtos/freertos_9.0.0/Source/include; ; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../devices/MK65F18/drivers; ..; ../../../../../../../middleware/lwip_2.0.0/src/apps/httpsrv; ../../../../../../../devices/MK65F18/utilities; ../../../../../../../middleware/lwip_2.0.0; ../../../../../../../middleware/lwip_2.0.0/port; ../../../../../../../middleware/lwip_2.0.0/port/arch; ../../../../../../../middleware/lwip_2.0.0/src; ../../../../../../../middleware/lwip_2.0.0/src/include; ../../../../../../../middleware/lwip_2.0.0/src/include/lwip; ../../../../../../../middleware/lwip_2.0.0/src/include/lwip/priv; ../../../../../../../middleware/lwip_2.0.0/src/include/netif; ../../../../../../../middleware/lwip_2.0.0/src/include/posix; ../../../../../../../middleware/lwip_2.0.0/src/include; ../../../../../../../middleware/lwip_2.0.0/contrib/apps; ../../../../../../../rtos/freertos_9.0.0/Source; ../../../../..; ../../../../../../../devices/MK65F18
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: lwip_httpsrv_freertos.out
  ILINK.IlinkIcfFile: MK65FN2M0xxx18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK65FN2M0VMI18; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; HTTPSRV_CFG_WEBSOCKET_ENABLED=1; FSL_RTOS_FREE_RTOS; TWR_K65F180M; TOWER
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../../devices/MK65F18/iar/: startup_MK65F18.s
    ../../../../../../../devices/MK65F18/: system_MK65F18.c system_MK65F18.h
  group freertos
    ../../../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h
    ../../../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
    ../../../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_3.c
  group freertos/portable
    ../../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F/: port.c fsl_tickless_systick.c fsl_tickless_generic.h portasm.s portmacro.h
  group doc
    ../: readme.txt
  group board
    ../: fsl_phy.h fsl_phy.c pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group drivers
    ../../../../../../../devices/MK65F18/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c fsl_port.h fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_enet.h fsl_enet.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group httpsrv
    ../../../../../../../middleware/lwip_2.0.0/src/apps/httpsrv/: httpsrv.c httpsrv.h httpsrv_tls.h httpsrv_config.h httpsrv_base64.h httpsrv_base64.c httpsrv_fs.c httpsrv_fs.h httpsrv_fs_data.c httpsrv_port.h httpsrv_prv.h httpsrv_script.h httpsrv_script.c httpsrv_sha1.h httpsrv_sha1.c httpsrv_supp.c httpsrv_supp.h httpsrv_task.c httpsrv_utf8.h httpsrv_utf8.c httpsrv_ws.h httpsrv_ws.c httpsrv_ws_api.c httpsrv_ws_prv.h
  group source
    ../: lwip_httpsrv_freertos.c FreeRTOSConfig.h
  group utilities
    ../../../../../../../devices/MK65F18/utilities/: fsl_debug_console.c fsl_debug_console.h
  group lwip/port
    ../../../../../../../middleware/lwip_2.0.0/port/arch/: cc.h perf.h sys_arch.h
    ../../../../../../../middleware/lwip_2.0.0/port/: ethernetif.c ethernetif.h lwipopts.h sys_arch.c
  group lwip/src/api
    ../../../../../../../middleware/lwip_2.0.0/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/core
    ../../../../../../../middleware/lwip_2.0.0/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/src/core/ipv4
    ../../../../../../../middleware/lwip_2.0.0/src/core/ipv4/: dhcp.c autoip.c etharp.c icmp.c igmp.c ip4_addr.c ip4.c ip4_frag.c
  group lwip/src/core/ipv6
    ../../../../../../../middleware/lwip_2.0.0/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip/src/include/lwip
    ../../../../../../../middleware/lwip_2.0.0/src/include/lwip/: api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h ethip6.h etharp.h icmp.h icmp6.h igmp.h inet.h inet_chksum.h init.h ip.h ip_addr.h ip4_frag.h ip4.h ip4_addr.h ip6.h ip6_addr.h ip6_frag.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/priv
    ../../../../../../../middleware/lwip_2.0.0/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h tcp_priv.h tcpip_priv.h
  group lwip/src/include/netif
    ../../../../../../../middleware/lwip_2.0.0/src/include/netif/: etharp.h ethernet.h slipif.h lowpan6.h lowpan6_opts.h
    ../../../../../../../middleware/lwip_2.0.0/src/include/netif/ppp/: pppoe.h
  group lwip/src/include/netif/ppp
    ../../../../../../../middleware/lwip_2.0.0/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../../../middleware/lwip_2.0.0/src/include/netif/ppp/polarssl/: md5.h md4.h sha1.h des.h arc4.h
  group lwip/src/include/posix
    ../../../../../../../middleware/lwip_2.0.0/src/include/posix/: netdb.h
    ../../../../../../../middleware/lwip_2.0.0/src/include/posix/sys/: socket.h
  group lwip/src/netif
    ../../../../../../../middleware/lwip_2.0.0/src/netif/: ethernet.c lowpan6.c slipif.c
  group lwip/src/netif/ppp
    ../../../../../../../middleware/lwip_2.0.0/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c lwip_ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
