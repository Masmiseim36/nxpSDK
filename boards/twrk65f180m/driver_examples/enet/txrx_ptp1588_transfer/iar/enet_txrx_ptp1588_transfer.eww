<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>enet_txrx_ptp1588_transfer</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>enet_txrx_ptp1588_transfer</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>enet_txrx_ptp1588_transfer</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>enet_txrx_ptp1588_transfer</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/enet_txrx_ptp1588_transfer.ewp</path>
  </project>
</workspace>
