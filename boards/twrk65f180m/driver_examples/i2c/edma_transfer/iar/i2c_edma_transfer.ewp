# IAR project i2c_edma_transfer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK65FN2M0xxx18 NXP MK65FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK65FN2M0VMI18; TWR_K65F180M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MK65F18/drivers; ..; ../../../../../../devices/MK65F18/utilities; ../../../../../../middleware/dma_manager_2.0.0; ../../../..; ../../../../../../devices/MK65F18
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: i2c_edma_transfer.out
  ILINK.IlinkIcfFile: MK65FN2M0xxx18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK65FN2M0VMI18; TWR_K65F180M; TOWER
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/MK65F18/iar/: startup_MK65F18.s
    ../../../../../../devices/MK65F18/: system_MK65F18.c system_MK65F18.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MK65F18/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_port.h fsl_i2c.h fsl_i2c.c fsl_i2c_edma.c fsl_i2c_edma.h fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group source
    ../: i2c_edma_transfer.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../devices/MK65F18/utilities/: fsl_debug_console.c fsl_debug_console.h
  group dma_manager
    ../../../../../../middleware/dma_manager_2.0.0/: fsl_dma_manager.c fsl_dma_manager.h
