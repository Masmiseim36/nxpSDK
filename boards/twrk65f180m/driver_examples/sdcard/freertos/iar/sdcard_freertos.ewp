# IAR project sdcard_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK65FN2M0xxx18 NXP MK65FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK65FN2M0VMI18; FSL_RTOS_FREE_RTOS; TWR_K65F180M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F; ../../../../../../rtos/freertos_9.0.0/Source/include; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MK65F18/drivers; ..; ../../../../../../devices/MK65F18/utilities; ../../../../../../rtos/freertos_9.0.0/Source; ../../../../../../middleware/sdmmc_2.1.1/inc; ../../../../../../middleware/sdmmc_2.1.1/src; ../../../..; ../../../../../../devices/MK65F18
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: sdcard_freertos.out
  ILINK.IlinkIcfFile: MK65FN2M0xxx18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK65FN2M0VMI18; FSL_RTOS_FREE_RTOS; TWR_K65F180M; TOWER
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/MK65F18/iar/: startup_MK65F18.s
    ../../../../../../devices/MK65F18/: system_MK65F18.c system_MK65F18.h
  group freertos
    ../../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h
    ../../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
    ../../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F/: port.c fsl_tickless_systick.c fsl_tickless_generic.h portasm.s portmacro.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MK65F18/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_mpu.h fsl_mpu.c fsl_sdhc.h fsl_sdhc.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group source
    ../: sdcard_freertos.c event.h event.c FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../devices/MK65F18/utilities/: fsl_debug_console.c fsl_debug_console.h
  group sdmmc/src
    ../../../../../../middleware/sdmmc_2.1.1/src/: fsl_sd.c fsl_mmc.c fsl_sdmmc.c
  group sdmmc/inc
    ../../../../../../middleware/sdmmc_2.1.1/inc/: fsl_card.h fsl_specification.h fsl_sdmmc.h
