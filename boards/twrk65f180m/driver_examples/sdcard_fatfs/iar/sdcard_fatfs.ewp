# IAR project sdcard_fatfs.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK65FN2M0xxx18 NXP MK65FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK65FN2M0VMI18; TWR_K65F180M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MK65F18/drivers; ../../../../../middleware/fatfs_0.11a/src; ../../../../../middleware/fatfs_0.11a/src/fsl_sd_disk; ..; ../../../../../devices/MK65F18/utilities; ../../../../../middleware/sdmmc_2.1.1/inc; ../../../../../middleware/sdmmc_2.1.1/src; ../../..; ../../../../../devices/MK65F18
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: sdcard_fatfs.out
  ILINK.IlinkIcfFile: MK65FN2M0xxx18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK65FN2M0VMI18; TWR_K65F180M; TOWER
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../devices/MK65F18/iar/: startup_MK65F18.s
    ../../../../../devices/MK65F18/: system_MK65F18.c system_MK65F18.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK65F18/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_mpu.h fsl_mpu.c fsl_sdhc.h fsl_sdhc.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group source
    ../: sdcard_fatfs.c sdhc_config.h event.c ffconf.h
  group FATFS_Source
    ../../../../../middleware/fatfs_0.11a/src/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
    ../../../../../middleware/fatfs_0.11a/src/: integer.h ff.c ff.h diskio.c diskio.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MK65F18/utilities/: fsl_debug_console.c fsl_debug_console.h
  group sdmmc/src
    ../../../../../middleware/sdmmc_2.1.1/src/: fsl_sd.c fsl_mmc.c fsl_sdmmc.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc_2.1.1/inc/: fsl_card.h fsl_specification.h fsl_sdmmc.h
