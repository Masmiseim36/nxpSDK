# IAR project tsi_v4_low_power_mode.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK65FN2M0xxx18 NXP MK65FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK65FN2M0VMI18; TWR_K65F180M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MK65F18/drivers; ..; ../../../../../../devices/MK65F18/utilities; ../../../..; ../../../../../../devices/MK65F18
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: tsi_v4_low_power_mode.out
  ILINK.IlinkIcfFile: MK65FN2M0xxx18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK65FN2M0VMI18; TWR_K65F180M; TOWER
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/MK65F18/iar/: startup_MK65F18.s
    ../../../../../../devices/MK65F18/: system_MK65F18.c system_MK65F18.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MK65F18/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_clock.h fsl_clock.c fsl_rcm.c fsl_rcm.h fsl_smc.h fsl_smc.c fsl_llwu.h fsl_llwu.c fsl_lptmr.c fsl_lptmr.h fsl_pmc.h fsl_pmc.c fsl_tsi_v4.h fsl_tsi_v4.c fsl_common.h fsl_common.c fsl_flash.c fsl_flash.h
  group source
    ../: tsi_v4_low_power.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../devices/MK65F18/utilities/: fsl_debug_console.c fsl_debug_console.h
