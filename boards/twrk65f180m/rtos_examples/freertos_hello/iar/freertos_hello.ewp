# IAR project freertos_hello.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK65FN2M0xxx18 NXP MK65FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK65FN2M0VMI18; FSL_RTOS_FREE_RTOS; TWR_K65F180M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F; ../../../../../rtos/freertos_9.0.0/Source/include; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MK65F18/drivers; ..; ../../../../../devices/MK65F18/utilities; ../../../../../rtos/freertos_9.0.0/Source; ../../..; ../../../../../devices/MK65F18
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: freertos_hello.out
  ILINK.IlinkIcfFile: MK65FN2M0xxx18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK65FN2M0VMI18; FSL_RTOS_FREE_RTOS; TWR_K65F180M; TOWER
  ICCARM.CCOptLevel: 3
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK65F18/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flash.c fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_lpuart.c fsl_lpuart.h fsl_port.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h
  group freertos
    ../../../../../rtos/freertos_9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F/: fsl_tickless_generic.h fsl_tickless_systick.c port.c portasm.s portmacro.h
  group source
    ../: freertos_hello.c FreeRTOSConfig.h
  group startup
    ../../../../../devices/MK65F18/iar/: startup_MK65F18.s
    ../../../../../devices/MK65F18/: system_MK65F18.c system_MK65F18.h
  group utilities
    ../../../../../devices/MK65F18/utilities/: fsl_debug_console.c fsl_debug_console.h
