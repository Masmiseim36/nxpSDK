# IAR project dev_composite_cdc_msc_sdcard_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK65FN2M0xxx18 NXP MK65FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; CPU_MK65FN2M0VMI18; USB_STACK_FREERTOS_HEAP_SIZE=32768; USB_STACK_FREERTOS; FSL_RTOS_FREE_RTOS; TWR_K65F180M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F; ../../../../../../rtos/freertos_9.0.0/Source/include; ..; ../../../../../../devices/MK65F18/drivers; ../../../../../../rtos/freertos_9.0.0/Source; ../../../../../../devices/MK65F18/utilities; ../../../../../../middleware/usb_1.4.0; ../../../../../../middleware/usb_1.4.0/osa; ../../../../../../middleware/usb_1.4.0/include; ../../../../../../middleware/usb_1.4.0/device; ../../../../../../CMSIS/Include; ../../../../../../middleware/sdmmc_2.1.1/inc; ../../../../../../middleware/sdmmc_2.1.1/src; ../../../..; ../../../../../../middleware/usb_1.4.0/phy; ../../../../../../devices/MK65F18
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: dev_composite_cdc_msc_sdcard_freertos.out
  ILINK.IlinkIcfFile: MK65FN2M0xxx18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK65FN2M0VMI18; USB_STACK_FREERTOS_HEAP_SIZE=32768; USB_STACK_FREERTOS; FSL_RTOS_FREE_RTOS; TWR_K65F180M; TOWER
  ICCARM.CCOptLevel: 3
  group freertos
    ../../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h
    ../../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
    ../../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F/: port.c fsl_tickless_systick.c fsl_tickless_generic.h portasm.s portmacro.h
  group startup
    ../../../../../../devices/MK65F18/iar/: startup_MK65F18.s
    ../../../../../../devices/MK65F18/: system_MK65F18.c system_MK65F18.h
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb_1.4.0/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/khci
    ../../../../../../middleware/usb_1.4.0/device/: usb_device_khci.c usb_device_khci.h
    ../../../../../../middleware/usb_1.4.0/include/: usb_khci.h
  group usb/device/source/ehci
    ../../../../../../middleware/usb_1.4.0/device/: usb_device_ehci.c usb_device_ehci.h
    ../../../../../../middleware/usb_1.4.0/include/: usb_ehci.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/cdc
    ../: usb_device_cdc_acm.c usb_device_cdc_acm.h
  group usb/device/class/msc
    ../: usb_device_msc.c usb_device_msc.h usb_device_msc_ufi.c usb_device_msc_ufi.h
  group usb/device/include
    ../../../../../../middleware/usb_1.4.0/device/: usb_device.h
  group usb/phy
    ../../../../../../middleware/usb_1.4.0/phy/: usb_phy.c usb_phy.h
  group usb/include
    ../../../../../../middleware/usb_1.4.0/include/: usb.h usb_misc.h usb_spec.h
  group drivers
    ../../../../../../devices/MK65F18/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c fsl_sdhc.h fsl_sdhc.c fsl_port.h fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_mpu.h fsl_mpu.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group osa
    ../../../../../../middleware/usb_1.4.0/osa/: usb_osa.h usb_osa_freertos.h usb_osa_freertos.c
  group sources
    ../: composite.c composite.h disk_sdcard.c disk_sdcard.h event.c event.h usb_device_descriptor.c usb_device_descriptor.h virtual_com.c virtual_com.h usb_device_config.h FreeRTOSConfig.h
  group utilities
    ../../../../../../devices/MK65F18/utilities/: fsl_debug_console.c fsl_debug_console.h
  group sdmmc/src
    ../../../../../../middleware/sdmmc_2.1.1/src/: fsl_sd.c fsl_mmc.c fsl_sdmmc.c
  group sdmmc/inc
    ../../../../../../middleware/sdmmc_2.1.1/inc/: fsl_card.h fsl_specification.h fsl_sdmmc.h
  group board
    ../: clock_config.h clock_config.c board.c board.h pin_mux.c pin_mux.h
