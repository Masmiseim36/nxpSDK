# IAR project dev_hid_mouse_ucosiii.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK65FN2M0xxx18 NXP MK65FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; CPU_MK65FN2M0VMI18; USB_STACK_FREERTOS_HEAP_SIZE=32768; USB_STACK_UCOSIII; FSL_RTOS_UCOSIII; TWR_K65F180M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/ucosiii_3.05.01/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR; ../../../../../../rtos/ucosiii_3.05.01/uC-CPU/ARM-Cortex-M4/IAR; ..; ../../../../../../rtos/ucosiii_3.05.01/uCOS-III/Source; ../../../../../../rtos/ucosiii_3.05.01/uC-CPU; ../../../../../../rtos/ucosiii_3.05.01/uC-LIB; ../../../../../../devices/MK65F18/utilities; ../../../../../../middleware/usb_1.4.0; ../../../../../../middleware/usb_1.4.0/osa; ../../../../../../middleware/usb_1.4.0/include; ../../../../../../middleware/usb_1.4.0/device; ../../../../../../CMSIS/Include; ../../../..; ../../../../../../middleware/usb_1.4.0/phy; ../../../../../../devices/MK65F18/drivers; ../../../../../../devices/MK65F18
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: dev_hid_mouse_ucosiii.out
  ILINK.IlinkIcfFile: MK65FN2M0xxx18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK65FN2M0VMI18; USB_STACK_FREERTOS_HEAP_SIZE=32768; USB_STACK_UCOSIII; FSL_RTOS_UCOSIII; TWR_K65F180M; TOWER
  ICCARM.CCOptLevel: 3
  group ucosiii
    ../../../../../../rtos/ucosiii_3.05.01/uC-CPU/ARM-Cortex-M4/IAR/: cpu.h cpu_c.c cpu_a.asm
    ../../../../../../rtos/ucosiii_3.05.01/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
    ../../../../../../rtos/ucosiii_3.05.01/uC-CPU/: cpu_def.h cpu_core.h cpu_core.c
    ../../../../../../rtos/ucosiii_3.05.01/uC-LIB/: lib_def.h
    ../../../../../../rtos/ucosiii_3.05.01/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_mon.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group startup
    ../../../../../../devices/MK65F18/iar/: startup_MK65F18.s
    ../../../../../../devices/MK65F18/: system_MK65F18.c system_MK65F18.h
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb_1.4.0/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/khci
    ../../../../../../middleware/usb_1.4.0/device/: usb_device_khci.c usb_device_khci.h
    ../../../../../../middleware/usb_1.4.0/include/: usb_khci.h
  group usb/device/source/ehci
    ../../../../../../middleware/usb_1.4.0/device/: usb_device_ehci.c usb_device_ehci.h
    ../../../../../../middleware/usb_1.4.0/include/: usb_ehci.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/hid
    ../: usb_device_hid.c usb_device_hid.h
  group usb/device/include
    ../../../../../../middleware/usb_1.4.0/device/: usb_device.h
  group usb/phy
    ../../../../../../middleware/usb_1.4.0/phy/: usb_phy.c usb_phy.h
  group usb/include
    ../../../../../../middleware/usb_1.4.0/include/: usb.h usb_misc.h usb_spec.h
  group drivers
    ../../../../../../devices/MK65F18/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c fsl_port.h fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_mpu.h fsl_mpu.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group osa
    ../../../../../../middleware/usb_1.4.0/osa/: usb_osa.h usb_osa_ucosiii.h usb_osa_ucosiii.c
  group sources
    ../: mouse.c mouse.h usb_device_descriptor.c usb_device_descriptor.h usb_device_config.h os_cfg.h cpu_cfg.h os_cfg_app.h
  group utilities
    ../../../../../../devices/MK65F18/utilities/: fsl_debug_console.c fsl_debug_console.h
  group board
    ../: clock_config.h clock_config.c board.c board.h pin_mux.c pin_mux.h
