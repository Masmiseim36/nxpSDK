# IAR project host_hid_mouse_ucosii.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK65FN2M0xxx18 NXP MK65FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; CPU_MK65FN2M0VMI18; USB_STACK_FREERTOS_HEAP_SIZE=32768; USB_STACK_UCOSII; FSL_RTOS_UCOSII; TWR_K65F180M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/ucosii_2.92.11/uCOS-II/Ports/ARM-Cortex-M4/Generic/IAR; ../../../../../../rtos/ucosii_2.92.11/uC-CPU/ARM-Cortex-M4/IAR; ..; ../../../../../../rtos/ucosii_2.92.11/uCOS-II/Source; ../../../../../../rtos/ucosii_2.92.11/uC-CPU; ../../../../../../rtos/ucosii_2.92.11/uC-LIB; ../../../../../../devices/MK65F18/utilities; ../../../../../../middleware/usb_1.4.0; ../../../../../../middleware/usb_1.4.0/osa; ../../../../../../middleware/usb_1.4.0/include; ../../../../../../CMSIS/Include; ../../../..; ../../../../../../middleware/usb_1.4.0/host; ../../../../../../middleware/usb_1.4.0/phy; ../../../../../../devices/MK65F18/drivers; ../../../../../../middleware/usb_1.4.0/host/class; ../../../../../../devices/MK65F18
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: host_hid_mouse_ucosii.out
  ILINK.IlinkIcfFile: MK65FN2M0xxx18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK65FN2M0VMI18; USB_STACK_FREERTOS_HEAP_SIZE=32768; USB_STACK_UCOSII; FSL_RTOS_UCOSII; TWR_K65F180M; TOWER
  ICCARM.CCOptLevel: 3
  group ucosii
    ../../../../../../rtos/ucosii_2.92.11/uC-CPU/ARM-Cortex-M4/IAR/: cpu.h
    ../../../../../../rtos/ucosii_2.92.11/uCOS-II/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c fsl_isr_wrapper.S
    ../../../../../../rtos/ucosii_2.92.11/uC-CPU/: cpu_def.h
    ../../../../../../rtos/ucosii_2.92.11/uC-LIB/: lib_def.h
    ../../../../../../rtos/ucosii_2.92.11/uCOS-II/Source/: ucos_ii.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group startup
    ../../../../../../devices/MK65F18/iar/: startup_MK65F18.s
    ../../../../../../devices/MK65F18/: system_MK65F18.c system_MK65F18.h
  group usb/host
    ../../../../../../middleware/usb_1.4.0/host/: usb_host_khci.c usb_host_khci.h usb_host_ehci.c usb_host_ehci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c
  group usb/host/class
    ../../../../../../middleware/usb_1.4.0/host/class/: usb_host_hid.c usb_host_hid.h usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h
  group usb/phy
    ../../../../../../middleware/usb_1.4.0/phy/: usb_phy.c usb_phy.h
  group usb/include
    ../../../../../../middleware/usb_1.4.0/include/: usb.h usb_misc.h usb_spec.h
  group drivers
    ../../../../../../devices/MK65F18/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c fsl_port.h fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_mpu.h fsl_mpu.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group osa
    ../../../../../../middleware/usb_1.4.0/osa/: usb_osa.h usb_osa_ucosii.h usb_osa_ucosii.c
  group sources
    ../: app.c host_mouse.c host_mouse.h usb_host_config.h os_cfg.h cpu_cfg.h app_cfg.h
  group utilities
    ../../../../../../devices/MK65F18/utilities/: fsl_debug_console.c fsl_debug_console.h
  group board
    ../: clock_config.h clock_config.c board.c board.h pin_mux.c pin_mux.h
