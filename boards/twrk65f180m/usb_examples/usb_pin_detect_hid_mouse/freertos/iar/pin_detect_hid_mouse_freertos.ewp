# IAR project pin_detect_hid_mouse_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK65FN2M0xxx18 NXP MK65FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; CPU_MK65FN2M0VMI18; USB_STACK_FREERTOS_HEAP_SIZE=32768; USB_STACK_FREERTOS; PRINTF_FLOAT_ENABLE; FSL_RTOS_FREE_RTOS; TWR_K65F180M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F; ../../../../../../rtos/freertos_9.0.0/Source/include; ..; ../../../../../../rtos/freertos_9.0.0/Source; ../../../../../../devices/MK65F18/utilities; ../../../../../../middleware/usb_1.4.0; ../../../../../../middleware/usb_1.4.0/osa; ../../../../../../middleware/usb_1.4.0/include; ../../../../../../CMSIS/Include; ../../../../../../middleware/usb_1.4.0/device; ../../../..; ../../../../../../middleware/usb_1.4.0/host; ../../../../../../middleware/usb_1.4.0/phy; ../../../../../../devices/MK65F18/drivers; ../../../../../../middleware/usb_1.4.0/host/class; ../../../../../../devices/MK65F18
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: pin_detect_hid_mouse_freertos.out
  ILINK.IlinkIcfFile: MK65FN2M0xxx18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK65FN2M0VMI18; USB_STACK_FREERTOS_HEAP_SIZE=32768; USB_STACK_FREERTOS; PRINTF_FLOAT_ENABLE; FSL_RTOS_FREE_RTOS; TWR_K65F180M; TOWER
  ICCARM.CCOptLevel: 3
  group freertos
    ../../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h
    ../../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
    ../../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F/: port.c fsl_tickless_systick.c fsl_tickless_generic.h portasm.s portmacro.h
  group startup
    ../../../../../../devices/MK65F18/iar/: startup_MK65F18.s
    ../../../../../../devices/MK65F18/: system_MK65F18.c system_MK65F18.h
  group usb/host
    ../../../../../../middleware/usb_1.4.0/host/: usb_host_khci.c usb_host_khci.h usb_host_ehci.c usb_host_ehci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c
  group usb/host/class
    ../../../../../../middleware/usb_1.4.0/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_hid.c usb_host_hid.h
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb_1.4.0/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/khci
    ../../../../../../middleware/usb_1.4.0/device/: usb_device_khci.c usb_device_khci.h
    ../../../../../../middleware/usb_1.4.0/include/: usb_khci.h
  group usb/device/source/ehci
    ../../../../../../middleware/usb_1.4.0/device/: usb_device_ehci.c usb_device_ehci.h
    ../../../../../../middleware/usb_1.4.0/include/: usb_ehci.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/hid
    ../: usb_device_hid.c usb_device_hid.h
  group usb/device/include
    ../../../../../../middleware/usb_1.4.0/device/: usb_device.h
  group usb/phy
    ../../../../../../middleware/usb_1.4.0/phy/: usb_phy.c usb_phy.h
  group usb/include
    ../../../../../../middleware/usb_1.4.0/include/: usb.h usb_misc.h usb_spec.h
  group drivers
    ../../../../../../devices/MK65F18/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c fsl_port.h fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_mpu.h fsl_mpu.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group osa
    ../../../../../../middleware/usb_1.4.0/osa/: usb_osa.h usb_osa_freertos.h usb_osa_freertos.c
  group sources
    ../: app.c device_mouse.c device_mouse.h host_mouse.c host_mouse.h usb_device_descriptor.c usb_device_descriptor.h usb_host_config.h usb_device_config.h FreeRTOSConfig.h
  group utilities
    ../../../../../../devices/MK65F18/utilities/: fsl_debug_console.c fsl_debug_console.h
  group board
    ../: clock_config.h clock_config.c board.c board.h pin_mux.c pin_mux.h
