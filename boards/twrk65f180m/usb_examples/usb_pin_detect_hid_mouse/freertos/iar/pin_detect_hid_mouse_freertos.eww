<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>pin_detect_hid_mouse_freertos</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>pin_detect_hid_mouse_freertos</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>pin_detect_hid_mouse_freertos</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>pin_detect_hid_mouse_freertos</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/pin_detect_hid_mouse_freertos.ewp</path>
  </project>
</workspace>
