<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>adc16_low_power_async_edma</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>adc16_low_power_async_edma</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>adc16_low_power_async_edma</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>adc16_low_power_async_edma</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/adc16_low_power_async_edma.ewp</path>
  </project>
</workspace>
