# Keil uVision project emvl1.uvprojx, settings and files
target emvl1 Debug (ARM-ADS)
  device: MK80FN256VDC15 NXP
  pack: Keil.Kinetis_K80_DFP.1.0.0.pack
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: emvl1.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MK80FN256VDC15, TWR_K80F150M, TOWER, ISO7816_CARD_SUPPORT, USING_PHY_TDA8035
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;..;../../..;../../../../../devices/MK80F25615/drivers;../../../../../devices/MK80F25615;../../../../../devices/MK80F25615/utilities/io;../../../../../devices/MK80F25615/utilities/str;../../../../../devices/MK80F25615/utilities/log;../../../../../devices/MK80F25615/utilities;../../../../../middleware/emv/inc
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK80FN256xxx15_flash.scf
  link misc: --remove
  group source
    ../: emvl1.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK80F25615/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_smartcard.h fsl_smartcard_emvsim.h fsl_smartcard_emvsim.c fsl_smartcard_phy.h fsl_smartcard_phy_tda8035.c fsl_flash.c fsl_flash.h fsl_port.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c
  group startup
    ../../../../../devices/MK80F25615/: system_MK80F25615.c system_MK80F25615.h
    ../../../../../devices/MK80F25615/arm/: startup_MK80F25615.s
  group utilities
    ../../../../../devices/MK80F25615/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MK80F25615/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MK80F25615/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK80F25615/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group emv-inc
    ../../../../../middleware/emv/inc/: emvl1_adapter_sdk.h emvl1_core.h
  group emv-src
    ../../../../../middleware/emv/src/: emvl1_core.c
target emvl1 Release (ARM-ADS)
  device: MK80FN256VDC15 NXP
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: emvl1.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MK80FN256VDC15, TWR_K80F150M, TOWER, ISO7816_CARD_SUPPORT, USING_PHY_TDA8035
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK80FN256xxx15_flash.scf
  link misc: --remove
