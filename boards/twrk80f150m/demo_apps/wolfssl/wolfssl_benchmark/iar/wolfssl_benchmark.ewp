# IAR project wolfssl_benchmark.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK80FN256xxx15 NXP MK80FN256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK80FN256VDC15; TWR_K80F150M; TOWER; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; FREESCALE_KSDK_BM; WOLFSSL_USER_SETTINGS
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167,Pe177,Pa089,Pa134
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../devices; ..; ../../../..; ../../../../../../middleware/mmcau; ../../../../../../middleware/wolfssl; ../../../../../../middleware/wolfssl/wolfssl/wolfcrypt/port; ../../../../../../devices/MK80F25615/drivers; ../../../../../../devices/MK80F25615; ../../../../../../devices/MK80F25615/utilities/io; ../../../../../../devices/MK80F25615/utilities/str; ../../../../../../devices/MK80F25615/utilities/log; ../../../../../../devices/MK80F25615/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: wolfssl_benchmark.out
  ILINK.IlinkIcfFile: MK80FN256xxx15_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../middleware/mmcau/asm-cm4-cm7/lib_mmcau.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK80FN256VDC15; TWR_K80F150M; TOWER; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; FREESCALE_KSDK_BM; WOLFSSL_USER_SETTINGS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: wolfssl_benchmark.c user_settings.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MK80F25615/drivers/: fsl_trng.c fsl_trng.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_flash.c fsl_flash.h fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c
  group mmcau/mmcau_include
    ../../../../../../middleware/mmcau/: cau_api.h fsl_mmcau.h
  group mmcau/mmcau_source
    ../../../../../../middleware/mmcau/: fsl_mmcau.c
  group startup
    ../../../../../../devices/MK80F25615/: system_MK80F25615.c system_MK80F25615.h
    ../../../../../../devices/MK80F25615/iar/: startup_MK80F25615.s
  group utilities
    ../../../../../../devices/MK80F25615/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../devices/MK80F25615/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../devices/MK80F25615/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MK80F25615/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group wolfssl/wolfssl_include
    ../../../../../../middleware/wolfssl/wolfssl/: callbacks.h certs_test.h crl.h error-ssl.h internal.h ocsp.h options.h sniffer.h sniffer_error.h ssl.h test.h version.h
    ../../../../../../middleware/wolfssl/wolfssl/openssl/: ec.h ssl.h bn.h
    ../../../../../../middleware/wolfssl/wolfssl/wolfcrypt/: aes.h arc4.h asn.h asn_public.h blake2.h blake2-impl.h blake2-int.h camellia.h cmac.h chacha.h chacha20_poly1305.h coding.h compress.h curve25519.h des3.h dh.h dsa.h ecc.h ed25519.h error-crypt.h fe_operations.h fips_test.h ge_operations.h hash.h hc128.h hmac.h integer.h idea.h logging.h md2.h md4.h md5.h mem_track.h memory.h misc.h mpi_class.h mpi_superclass.h pkcs7.h poly1305.h pwdbased.h rabbit.h random.h ripemd.h rsa.h settings.h sha.h sha256.h sha512.h signature.h srp.h tfm.h types.h visibility.h wc_encrypt.h wc_port.h
  group wolfssl/wolfssl_source
    ../../../../../../middleware/wolfssl/wolfcrypt/src/: aes.c arc4.c asm.c asn.c blake2b.c camellia.c chacha.c chacha20_poly1305.c coding.c compress.c curve25519.c des3.c dh.c dsa.c ecc.c ecc_fp.c ed25519.c error.c fe_low_mem.c fe_operations.c ge_low_mem.c ge_operations.c hash.c hc128.c hmac.c integer.c idea.c logging.c md2.c md4.c md5.c memory.c misc.c pkcs7.c poly1305.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha512.c signature.c srp.c tfm.c wc_encrypt.c wc_port.c
    ../../../../../../middleware/wolfssl/src/: crl.c internal.c io.c keys.c ocsp.c sniffer.c ssl.c tls.c
  group wolfssl/wolfssl_port
    ../../../../../../middleware/wolfssl/wolfcrypt/src/port/nxp/: ksdk_port.c
    ../../../../../../middleware/wolfssl/wolfssl/wolfcrypt/port/nxp/: ksdk_port.h
