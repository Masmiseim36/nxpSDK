<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>flexio_spi_int_dspi_transfer_master</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>flexio_spi_int_dspi_transfer_master</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>flexio_spi_int_dspi_transfer_master</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>flexio_spi_int_dspi_transfer_master</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/flexio_spi_int_dspi_transfer_master.ewp</path>
  </project>
</workspace>
