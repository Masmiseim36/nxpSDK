<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>tsi_v4_low_power_mode</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>tsi_v4_low_power_mode</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>tsi_v4_low_power_mode</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>tsi_v4_low_power_mode</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/tsi_v4_low_power_mode.ewp</path>
  </project>
</workspace>
