# IAR project mmcau.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK80FN256xxx15 NXP MK80FN256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK80FN256VDC15; TWR_K80F150M; TOWER; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ..; ../../..; ../../../../../middleware/mmcau; ../../../../../devices/MK80F25615/drivers; ../../../../../devices/MK80F25615; ../../../../../devices/MK80F25615/utilities/io; ../../../../../devices/MK80F25615/utilities/str; ../../../../../devices/MK80F25615/utilities/log; ../../../../../devices/MK80F25615/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: mmcau.out
  ILINK.IlinkIcfFile: MK80FN256xxx15_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/mmcau/asm-cm4-cm7/lib_mmcau.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK80FN256VDC15; TWR_K80F150M; TOWER; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: mmcau_api.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group mmcau/mmcau_include
    ../../../../../middleware/mmcau/: cau_api.h fsl_mmcau.h
  group mmcau/mmcau_source
    ../../../../../middleware/mmcau/: fsl_mmcau.c
  group drivers
    ../../../../../devices/MK80F25615/drivers/: fsl_clock.h fsl_clock.c fsl_flash.c fsl_flash.h fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c
  group startup
    ../../../../../devices/MK80F25615/: system_MK80F25615.c system_MK80F25615.h
    ../../../../../devices/MK80F25615/iar/: startup_MK80F25615.s
  group utilities
    ../../../../../devices/MK80F25615/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MK80F25615/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MK80F25615/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK80F25615/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
