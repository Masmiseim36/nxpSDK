# IAR project ucosii_hello.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK80FN256xxx15 NXP MK80FN256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK80FN256VDC15; FSL_RTOS_UCOSII; TWR_K80F150M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/ucosii_2.92.11/uCOS-II/Ports/ARM-Cortex-M4/Generic/IAR; ../../../../../rtos/ucosii_2.92.11/uC-CPU/ARM-Cortex-M4/IAR; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MK80F25615/drivers; ..; ../../../../../devices/MK80F25615/utilities; ../../../../../rtos/ucosii_2.92.11/uCOS-II/Source; ../../../../../rtos/ucosii_2.92.11/uC-CPU; ../../../../../rtos/ucosii_2.92.11/uC-LIB; ../../..; ../../../../../devices/MK80F25615
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: ucosii_hello.out
  ILINK.IlinkIcfFile: MK80FN256xxx15_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK80FN256VDC15; FSL_RTOS_UCOSII; TWR_K80F150M; TOWER
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../devices/MK80F25615/iar/: startup_MK80F25615.s
    ../../../../../devices/MK80F25615/: system_MK80F25615.c system_MK80F25615.h
  group ucosii
    ../../../../../rtos/ucosii_2.92.11/uC-CPU/ARM-Cortex-M4/IAR/: cpu.h
    ../../../../../rtos/ucosii_2.92.11/uCOS-II/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c fsl_isr_wrapper.S
    ../../../../../rtos/ucosii_2.92.11/uC-CPU/: cpu_def.h
    ../../../../../rtos/ucosii_2.92.11/uC-LIB/: lib_def.h
    ../../../../../rtos/ucosii_2.92.11/uCOS-II/Source/: ucos_ii.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK80F25615/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group source
    ../: os_cfg.h app_hooks.c app_cfg.h cpu_cfg.h ucosii_hello.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MK80F25615/utilities/: fsl_debug_console.c fsl_debug_console.h
