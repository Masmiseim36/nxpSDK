# IAR project ucosiii_hello.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK80FN256xxx15 NXP MK80FN256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK80FN256VDC15; FSL_RTOS_UCOSIII; TWR_K80F150M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/ucosiii_3.05.01/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR; ../../../../../rtos/ucosiii_3.05.01/uC-CPU/ARM-Cortex-M4/IAR; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MK80F25615/drivers; ..; ../../../../../devices/MK80F25615/utilities; ../../../../../rtos/ucosiii_3.05.01/uCOS-III/Source; ../../../../../rtos/ucosiii_3.05.01/uC-CPU; ../../../../../rtos/ucosiii_3.05.01/uC-LIB; ../../..; ../../../../../devices/MK80F25615
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: ucosiii_hello.out
  ILINK.IlinkIcfFile: MK80FN256xxx15_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK80FN256VDC15; FSL_RTOS_UCOSIII; TWR_K80F150M; TOWER
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../devices/MK80F25615/iar/: startup_MK80F25615.s
    ../../../../../devices/MK80F25615/: system_MK80F25615.c system_MK80F25615.h
  group ucosiii
    ../../../../../rtos/ucosiii_3.05.01/uC-CPU/ARM-Cortex-M4/IAR/: cpu.h cpu_c.c cpu_a.asm
    ../../../../../rtos/ucosiii_3.05.01/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
    ../../../../../rtos/ucosiii_3.05.01/uC-CPU/: cpu_def.h cpu_core.h cpu_core.c
    ../../../../../rtos/ucosiii_3.05.01/uC-LIB/: lib_def.h
    ../../../../../rtos/ucosiii_3.05.01/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_mon.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK80F25615/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group source
    ../: app_cfg.h os_cfg_app.h os_cfg.h cpu_cfg.h os_app_hooks.h os_app_hooks.c ucosiii_hello.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MK80F25615/utilities/: fsl_debug_console.c fsl_debug_console.h
