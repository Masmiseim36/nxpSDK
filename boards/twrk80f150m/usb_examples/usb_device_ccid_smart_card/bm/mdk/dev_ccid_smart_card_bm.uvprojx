# Keil uVision project dev_ccid_smart_card_bm.uvprojx, settings and files
target dev_ccid_smart_card_bm Debug (ARM-ADS)
  device: MK80FN256VDC15 NXP
  pack: Keil.Kinetis_K80_DFP.1.0.0.pack
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: dev_ccid_smart_card_bm.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: _DEBUG=1, CPU_MK80FN256VDC15, USING_PHY_TDA8035, USB_STACK_BM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..;../../../..;../../../../../../CMSIS/Include;../../../../../../middleware/usb;../../../../../../middleware/usb/osa;../../../../../../middleware/usb/include;../../../../../../middleware/usb/device;../../../../../../devices/MK80F25615/drivers;../../../../../../middleware/emv/inc;../../../../../../devices/MK80F25615/utilities/io;../../../../../../devices/MK80F25615/utilities/str;../../../../../../devices/MK80F25615/utilities/log;../../../../../../devices/MK80F25615/utilities;../../../../../../devices/MK80F25615
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK80FN256xxx15_flash.scf
  link misc: --remove
  group doc
    ../: readme.txt
  group sources
    ../: emvl1_interface.c emvl1_interface.h smart_card.c smart_card.h usb_device_descriptor.c usb_device_descriptor.h usb_device_config.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group drivers
    ../../../../../../devices/MK80F25615/drivers/: fsl_smartcard.h fsl_smartcard_emvsim.h fsl_smartcard_emvsim.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_smartcard_phy.h fsl_smartcard_phy_tda8035.c fsl_port.h fsl_sim.h fsl_sim.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_sysmpu.h fsl_sysmpu.c
  group usb-device-source-khci
    ../../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
    ../../../../../../middleware/usb/include/: usb_khci.h
  group usb-include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group osa
    ../../../../../../middleware/usb/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group usb-device-include
    ../../../../../../middleware/usb/device/: usb_device.h
  group usb-device-source
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
    ../: usb_device_ch9.c usb_device_ch9.h
  group usb-device-class
    ../: usb_device_class.c usb_device_class.h
  group usb-device-class-ccid
    ../: usb_device_ccid.c usb_device_ccid.h
  group emv-inc
    ../../../../../../middleware/emv/inc/: emvl1_adapter_sdk.h emvl1_core.h
  group emv-src
    ../../../../../../middleware/emv/src/: emvl1_core.c
  group utilities
    ../../../../../../devices/MK80F25615/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../devices/MK80F25615/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../devices/MK80F25615/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MK80F25615/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group startup
    ../../../../../../devices/MK80F25615/: system_MK80F25615.c system_MK80F25615.h
    ../../../../../../devices/MK80F25615/arm/: startup_MK80F25615.s
target dev_ccid_smart_card_bm Release (ARM-ADS)
  device: MK80FN256VDC15 NXP
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: dev_ccid_smart_card_bm.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: _DEBUG=0, CPU_MK80FN256VDC15, USING_PHY_TDA8035, USB_STACK_BM
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK80FN256xxx15_flash.scf
  link misc: --remove
