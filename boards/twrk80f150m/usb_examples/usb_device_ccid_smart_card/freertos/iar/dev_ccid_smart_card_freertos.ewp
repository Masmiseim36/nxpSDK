# IAR project dev_ccid_smart_card_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK80FN256xxx15 NXP MK80FN256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; CPU_MK80FN256VDC15; USING_PHY_TDA8035; USB_STACK_FREERTOS; USB_STACK_FREERTOS_HEAP_SIZE=32768; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../rtos/freertos/Source/portable/IAR/ARM_CM4F; ..; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../middleware/usb; ../../../../../../middleware/usb/osa; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/device; ../../../../../../rtos/freertos/Source/include; ../../../../../../devices/MK80F25615/drivers; ../../../../../../middleware/emv/inc; ../../../../../../devices/MK80F25615/utilities/io; ../../../../../../devices/MK80F25615/utilities/str; ../../../../../../devices/MK80F25615/utilities/log; ../../../../../../devices/MK80F25615/utilities; ../../../../../../devices/MK80F25615
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ../../../..; ..
  ILINK.IlinkOutputFile: dev_ccid_smart_card_freertos.out
  ILINK.IlinkIcfFile: MK80FN256xxx15_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK80FN256VDC15; USING_PHY_TDA8035; USB_STACK_FREERTOS; USB_STACK_FREERTOS_HEAP_SIZE=32768; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  group doc
    ../: readme.txt
  group sources
    ../: emvl1_interface.c emvl1_interface.h smart_card.c smart_card.h usb_device_descriptor.c usb_device_descriptor.h usb_device_config.h FreeRTOSConfig.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group drivers
    ../../../../../../devices/MK80F25615/drivers/: fsl_smartcard.h fsl_smartcard_emvsim.h fsl_smartcard_emvsim.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_smartcard_phy.h fsl_smartcard_phy_tda8035.c fsl_port.h fsl_sim.h fsl_sim.c fsl_smartcard_freertos.h fsl_smartcard_freertos.c fsl_pit.c fsl_pit.h fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_sysmpu.h fsl_sysmpu.c
  group usb/device/source
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
    ../: usb_device_ch9.c usb_device_ch9.h
  group usb/device/source/khci
    ../../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
    ../../../../../../middleware/usb/include/: usb_khci.h
  group usb/device/include
    ../../../../../../middleware/usb/device/: usb_device.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/ccid
    ../: usb_device_ccid.c usb_device_ccid.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group osa
    ../../../../../../middleware/usb/osa/: usb_osa.h usb_osa_freertos.h usb_osa_freertos.c
  group freertos
    ../../../../../../rtos/freertos/: FreeRTOS_for_Kinetis_SDK_v2.0.txt
  group freertos/portable
    ../../../../../../rtos/freertos/Source/portable/MemMang/: heap_4.c
    ../../../../../../rtos/freertos/Source/portable/: readme.txt
    ../../../../../../rtos/freertos/Source/portable/IAR/ARM_CM4F/: fsl_tickless_systick.c fsl_tickless_generic.h port.c portasm.s portmacro.h
  group freertos/license
    ../../../../../../rtos/freertos/License/: license.txt
  group freertos/include
    ../../../../../../rtos/freertos/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h stdint.readme task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
  group freertos/source
    ../../../../../../rtos/freertos/Source/: croutine.c list.c queue.c readme.txt tasks.c timers.c event_groups.c
  group emv/inc
    ../../../../../../middleware/emv/inc/: emvl1_adapter_sdk.h emvl1_core.h
  group emv/src
    ../../../../../../middleware/emv/src/: emvl1_core.c
  group utilities
    ../../../../../../devices/MK80F25615/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../devices/MK80F25615/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../devices/MK80F25615/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MK80F25615/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group startup
    ../../../../../../devices/MK80F25615/: system_MK80F25615.c system_MK80F25615.h
    ../../../../../../devices/MK80F25615/iar/: startup_MK80F25615.s
