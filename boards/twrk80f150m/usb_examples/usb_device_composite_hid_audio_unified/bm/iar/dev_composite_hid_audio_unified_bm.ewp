# IAR project dev_composite_hid_audio_unified_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK80FN256xxx15 NXP MK80FN256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; CPU_MK80FN256VDC15; USB_STACK_BM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../middleware/usb; ../../../../../../middleware/usb/osa; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/device; ../../../../../../devices/MK80F25615/drivers; ../../../../../../devices/MK80F25615/utilities/io; ../../../../../../devices/MK80F25615/utilities/str; ../../../../../../devices/MK80F25615/utilities/log; ../../../../../../devices/MK80F25615/utilities; ../../../../../../devices/MK80F25615
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: dev_composite_hid_audio_unified_bm.out
  ILINK.IlinkIcfFile: MK80FN256xxx15_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK80FN256VDC15; USB_STACK_BM
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  group sources
    ../: sgtl5000_interface.c audio_unified.c audio_unified.h composite.c composite.h hid_keyboard.c hid_keyboard.h usb_device_descriptor.c usb_device_descriptor.h usb_device_config.h
  group doc
    ../: readme.txt
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group usb/device/source
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
    ../: usb_device_ch9.c usb_device_ch9.h
  group usb/device/source/khci
    ../../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
    ../../../../../../middleware/usb/include/: usb_khci.h
  group usb/device/include
    ../../../../../../middleware/usb/device/: usb_device.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/audio
    ../: usb_device_audio.c usb_device_audio.h
  group usb/device/class/hid
    ../: usb_device_hid.c usb_device_hid.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group osa
    ../../../../../../middleware/usb/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group drivers
    ../../../../../../devices/MK80F25615/drivers/: fsl_sai.h fsl_sai.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_i2c.h fsl_i2c.c fsl_sai_edma.h fsl_sai_edma.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_port.h fsl_sim.h fsl_sim.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_sysmpu.h fsl_sysmpu.c
  group codec
    ../: fsl_sgtl5000.h fsl_sgtl5000.c
  group utilities
    ../../../../../../devices/MK80F25615/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../devices/MK80F25615/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../devices/MK80F25615/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MK80F25615/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group startup
    ../../../../../../devices/MK80F25615/: system_MK80F25615.c system_MK80F25615.h
    ../../../../../../devices/MK80F25615/iar/: startup_MK80F25615.s
