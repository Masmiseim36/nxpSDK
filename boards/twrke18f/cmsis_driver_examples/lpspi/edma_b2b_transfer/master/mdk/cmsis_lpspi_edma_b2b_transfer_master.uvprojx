# Keil uVision project cmsis_lpspi_edma_b2b_transfer_master.uvprojx, settings and files
target cmsis_lpspi_edma_b2b_transfer_master debug (ARM-ADS)
  device: MKE18F512VLL16 NXP
  pack: Keil.Kinetis_KExx_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: cmsis_lpspi_edma_b2b_transfer_master.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_MKE18F512VLL16, TWR_KE18F, TOWER, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../../CMSIS/Driver/Include;../../../../..;../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../devices/MKE18F16/drivers;../../../../../../../devices/MKE18F16/cmsis_drivers;../../../../../../../devices/MKE18F16;../../../../../../../devices/MKE18F16/utilities/str;../../../../../../../devices/MKE18F16/utilities/debug_console;../../../../../../../components/uart;../../../../../../../components/serial_manager;../../../../../../../components/lists;../../../../../../../devices/MKE18F16/utilities
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x10000
  memory RVCT9: RAM 0x1fff8000 size 0x10000
  scatter file: MKE18F512xxx16_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
  group source
    ../: cmsis_lpspi_edma_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MKE18F16/drivers/: fsl_port.h fsl_clock.c fsl_clock.h fsl_gpio.c fsl_gpio.h fsl_lpuart.c fsl_lpuart.h fsl_edma.c fsl_edma.h fsl_dmamux.c fsl_dmamux.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.c fsl_lpspi_edma.h fsl_common.c fsl_common.h fsl_smc.c fsl_smc.h
    ../../../../../../../devices/MKE18F16/cmsis_drivers/: fsl_lpspi_cmsis.c fsl_lpspi_cmsis.h
  group device
    ../../../../../../../devices/MKE18F16/: MKE18F16.h MKE18F16_features.h fsl_device_registers.h system_MKE18F16.c system_MKE18F16.h
  group utilities
    ../../../../../../../devices/MKE18F16/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/MKE18F16/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MKE18F16/utilities/: fsl_assert.c
  group component-uart
    ../../../../../../../components/uart/: lpuart_adapter.c uart.h
  group component-serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../../../devices/MKE18F16/arm/: startup_MKE18F16.S
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_SPI.h Driver_Common.h
target cmsis_lpspi_edma_b2b_transfer_master release (ARM-ADS)
  device: MKE18F512VLL16 NXP
  pack: Keil.Kinetis_KExx_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: cmsis_lpspi_edma_b2b_transfer_master.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_MKE18F512VLL16, TWR_KE18F, TOWER, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x10000
  memory RVCT9: RAM 0x1fff8000 size 0x10000
  scatter file: MKE18F512xxx16_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
