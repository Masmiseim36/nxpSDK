# IAR project power_manager.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKE18F512xxx16 NXP MKE18F512xxx16
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MKE18F512VLL16; TWR_KE18F; TOWER; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../platform/utilities/notifier; ../../..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MKE18F16/drivers; ../../../../../devices/MKE18F16/utilities; ../../../../../devices/MKE18F16; ../../../../../devices/MKE18F16/utilities/str; ../../../../../devices/MKE18F16/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: power_manager.out
  ILINK.IlinkIcfFile: MKE18F512xxx16_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKE18F512VLL16; TWR_KE18F; TOWER; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: clock_scg.c power_manager.h power_manager.c
  group board
    ../: peripherals.c peripherals.h pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKE18F16/drivers/: fsl_port.h fsl_pmc.c fsl_pmc.h fsl_smc.c fsl_smc.h fsl_rcm.c fsl_rcm.h fsl_lptmr.c fsl_lptmr.h fsl_gpio.c fsl_gpio.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h
  group utilities
    ../../../../../devices/MKE18F16/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MKE18F16/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MKE18F16/utilities/: fsl_assert.c
  group utilities/utilities
    ../../../../../devices/MKE18F16/utilities/: fsl_notifier.c fsl_notifier.h
  group device
    ../../../../../devices/MKE18F16/: MKE18F16.h MKE18F16_features.h fsl_device_registers.h system_MKE18F16.c system_MKE18F16.h
  group component/uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MKE18F16/iar/: startup_MKE18F16.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
