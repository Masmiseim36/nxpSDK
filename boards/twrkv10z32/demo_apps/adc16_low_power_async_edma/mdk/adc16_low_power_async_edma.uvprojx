# Keil uVision project adc16_low_power_async_edma.uvprojx, settings and files
target adc16_low_power_async_edma Debug (ARM-ADS)
  device: MKV10Z32xxx7 Freescale
  cpu: CPUTYPE("Cortex-M0+")
  output: adc16_low_power_async_edma.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKV10Z32VLF7, TWR_KV10Z32, TOWER
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;..;../../..;../../../../../devices/MKV10Z7/drivers;../../../../../devices/MKV10Z7/utilities;../../../../../devices/MKV10Z7
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKV10Z32xxx7_flash.scf
  link misc: --remove
  group startup
    ../../../../../devices/MKV10Z7/arm/: startup_MKV10Z7.s
    ../../../../../devices/MKV10Z7/: system_MKV10Z7.c system_MKV10Z7.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKV10Z7/drivers/: fsl_uart.h fsl_uart.c fsl_port.h fsl_lptmr.c fsl_lptmr.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_adc16.c fsl_adc16.h fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_sim.h fsl_sim.c fsl_pmc.h fsl_pmc.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group source
    ../: adc16_low_power_async_edma.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MKV10Z7/utilities/: fsl_debug_console.c fsl_debug_console.h
target adc16_low_power_async_edma Release (ARM-ADS)
  device: MKV10Z32xxx7 Freescale
  cpu: CPUTYPE("Cortex-M0+")
  output: adc16_low_power_async_edma.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKV10Z32VLF7, TWR_KV10Z32, TOWER
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKV10Z32xxx7_flash.scf
  link misc: --remove
