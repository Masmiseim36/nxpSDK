# IAR project mc_bldc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV10Z32xxx7 NXP MKV10Z32xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKV10Z32VLF7; CLOCK_SETUP=1; CPU_MKV10Z32VLC7=1; TWR_KV10Z32; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_IAR/AMCLIB; ../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_IAR/AMCLIB/Include; ../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_IAR/GDFLIB; ../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_IAR/GDFLIB/Include; ../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_IAR/GFLIB; ../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_IAR/GFLIB/Include; ../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_IAR/GMCLIB; ../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_IAR/GMCLIB/Include; ../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_IAR/MLIB; ../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_IAR/MLIB/Include; ../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_IAR/PCLIB; ../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_IAR/PCLIB/Include; ../../../../../middleware/motor_control_1.1.0/bldc/mc_algorithms; ../../../../../CMSIS/Include; ../../../../../devices; ..; ../../../../../middleware/motor_control_1.1.0/bldc/mc_drivers; ../../../../../middleware/motor_control_1.1.0/bldc/mc_state_machine; ../../../../../middleware/motor_control_1.1.0/bldc/state_machine; ../../..; ../../../../../devices/MKV10Z7/drivers; ../../../../../devices/MKV10Z7/utilities; ../../../../../devices/MKV10Z7
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: mc_bldc.out
  ILINK.IlinkIcfFile: MKV10Z32xxx7_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_IAR/GDFLIB/GDFLIB.a; ../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_IAR/GFLIB/GFLIB.a; ../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_IAR/GMCLIB/GMCLIB.a; ../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_IAR/MLIB/MLIB.a; ../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_IAR/PCLIB/PCLIB.a; ../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_IAR/AMCLIB/AMCLIB.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV10Z32VLF7; CLOCK_SETUP=1; CPU_MKV10Z32VLC7=1; TWR_KV10Z32; TOWER
  ICCARM.CCOptLevel: 3
  group rtcesl/amclib
    ../: amclib.h
  group rtcesl/gdflib
    ../: gdflib.h
  group rtcesl/gflib
    ../: gflib.h
  group rtcesl/gmclib
    ../: gmclib.h
  group rtcesl/mlib
    ../: mlib.h
  group startup
    ../../../../../devices/MKV10Z7/iar/: startup_MKV10Z7.s
    ../../../../../devices/MKV10Z7/: system_MKV10Z7.c system_MKV10Z7.h
  group doc
    ../: readme.txt readme.txt
  group drivers
    ../../../../../devices/MKV10Z7/drivers/: fsl_sim.h fsl_sim.c fsl_port.h fsl_dmamux.h fsl_dmamux.c fsl_clock.h fsl_clock.c fsl_dspi.h fsl_dspi.c fsl_uart.h fsl_uart.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group mc_drivers
    ../../../../../middleware/motor_control_1.1.0/bldc/mc_drivers/: mcdrv_adc_adc16.h mcdrv_adc_adc16.c mcdrv_ftm_cmt.c mcdrv_ftm_cmt.h mcdrv_ftm_pwm3ph.c mcdrv_ftm_pwm3ph.h mcdrv_spi_driver3ph.c mcdrv_spi_driver3ph.h
  group source
    ../: main.c m1_bldc_appconfig.h
  group board
    ../: mcdrv_twrkv10z32.c mcdrv_twrkv10z32.h mcdrv.h pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group mc_algorithms
    ../../../../../middleware/motor_control_1.1.0/bldc/mc_algorithms/: bldc_control.c bldc_control.h
  group mc_state_machine
    ../../../../../middleware/motor_control_1.1.0/bldc/mc_state_machine/: m1_sm_ref_sol.c m1_sm_ref_sol.h
  group state_machine
    ../../../../../middleware/motor_control_1.1.0/bldc/state_machine/: state_machine.c state_machine.h
  group utilities
    ../../../../../devices/MKV10Z7/utilities/: fsl_debug_console.c fsl_debug_console.h
