# Keil uVision project mc_bldc.uvprojx, settings and files
target mc_bldc Debug (ARM-ADS)
  device: MKV10Z32xxx7 Freescale
  cpu: CPUTYPE("Cortex-M0+")
  output: mc_bldc.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, ARM_MATH_CM4, CPU_MKV10Z32VLF7, CLOCK_SETUP=1, CPU_MKV10Z32VLC7=1, TWR_KV10Z32, TOWER
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_KEIL/AMCLIB;../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_KEIL/AMCLIB/Include;../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_KEIL/GDFLIB;../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_KEIL/GDFLIB/Include;../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_KEIL/GFLIB;../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_KEIL/GFLIB/Include;../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_KEIL/GMCLIB;../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_KEIL/GMCLIB/Include;../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_KEIL/MLIB;../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_KEIL/MLIB/Include;../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_KEIL/PCLIB;../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_KEIL/PCLIB/Include;../../../../../middleware/motor_control_1.1.0/bldc/mc_algorithms;../../../../../CMSIS/Include;../../../../../devices;..;../../../../../middleware/motor_control_1.1.0/bldc/mc_drivers;../../../../../middleware/motor_control_1.1.0/bldc/mc_state_machine;../../../../../middleware/motor_control_1.1.0/bldc/state_machine;../../..;../../../../../devices/MKV10Z7/drivers;../../../../../devices/MKV10Z7/utilities;../../../../../devices/MKV10Z7
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKV10Z32xxx7_flash.scf
  link misc: ../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_KEIL/GDFLIB/GDFLIB.lib 
../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_KEIL/GFLIB/GFLIB.lib 
../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_KEIL/GMCLIB/GMCLIB.lib 
../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_KEIL/MLIB/MLIB.lib 
../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_KEIL/PCLIB/PCLIB.lib 
../../../../../middleware/rtcesl_4.3/CM0_RTCESL_4.3_KEIL/AMCLIB/AMCLIB.lib 
--remove
  group rtcesl/amclib
    ../: amclib.h
  group rtcesl/gdflib
    ../: gdflib.h
  group rtcesl/gflib
    ../: gflib.h
  group rtcesl/gmclib
    ../: gmclib.h
  group rtcesl/mlib
    ../: mlib.h
  group startup
    ../../../../../devices/MKV10Z7/arm/: startup_MKV10Z7.s
    ../../../../../devices/MKV10Z7/: system_MKV10Z7.c system_MKV10Z7.h
  group doc
    ../: readme.txt readme.txt
  group drivers
    ../../../../../devices/MKV10Z7/drivers/: fsl_sim.h fsl_sim.c fsl_port.h fsl_dmamux.h fsl_dmamux.c fsl_clock.h fsl_clock.c fsl_dspi.h fsl_dspi.c fsl_uart.h fsl_uart.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group mc_drivers
    ../../../../../middleware/motor_control_1.1.0/bldc/mc_drivers/: mcdrv_adc_adc16.h mcdrv_adc_adc16.c mcdrv_ftm_cmt.c mcdrv_ftm_cmt.h mcdrv_ftm_pwm3ph.c mcdrv_ftm_pwm3ph.h mcdrv_spi_driver3ph.c mcdrv_spi_driver3ph.h
  group source
    ../: main.c m1_bldc_appconfig.h
  group board
    ../: mcdrv_twrkv10z32.c mcdrv_twrkv10z32.h mcdrv.h pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group mc_algorithms
    ../../../../../middleware/motor_control_1.1.0/bldc/mc_algorithms/: bldc_control.c bldc_control.h
  group mc_state_machine
    ../../../../../middleware/motor_control_1.1.0/bldc/mc_state_machine/: m1_sm_ref_sol.c m1_sm_ref_sol.h
  group state_machine
    ../../../../../middleware/motor_control_1.1.0/bldc/state_machine/: state_machine.c state_machine.h
  group utilities
    ../../../../../devices/MKV10Z7/utilities/: fsl_debug_console.c fsl_debug_console.h
target mc_bldc Release (ARM-ADS)
  device: MKV10Z32xxx7 Freescale
  cpu: CPUTYPE("Cortex-M0+")
  output: mc_bldc.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, ARM_MATH_CM4, CPU_MKV10Z32VLF7, CLOCK_SETUP=1, CPU_MKV10Z32VLC7=1, TWR_KV10Z32, TOWER
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKV10Z32xxx7_flash.scf
  link misc: as above
