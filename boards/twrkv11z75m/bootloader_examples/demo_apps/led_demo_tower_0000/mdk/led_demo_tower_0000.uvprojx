# Keil uVision project led_demo_tower_0000.uvprojx, settings and files
target led_demo_tower_0000 release (ARM-ADS)
  device: MKV11Z128VLH7 NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: led_demo_tower_0000.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_MKV11Z128VLH7, CPU_IS_ARM_CORTEX_M0P=1, TOWER, TWR_KV11Z75M
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -Wno-null-dereference  -Wno-unknown-attributes  -Wno-expansion-to-defined  -Wno-invalid-noreturn
  c include: ../../../../../../CMSIS/Include;../../../../../../devices/MKV11Z7;../../../../../../middleware/mcu-boot/targets/MKV11Z7/src;../../../../../../middleware/mcu-boot/src/startup;../../../../../../middleware/mcu-boot/src/include;../../../../../../middleware/mcu-boot/apps/led_demo/src;..;../../../../../../devices/MKV11Z7
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKV11Z128xxx7_application_0x0000.scf
  link misc: --remove --keep=*(.FlashConfig) --datacompressor off --predefine="-D__ram_vector_table__=1"
  group MKV11Z7
    ../: main.c
    ../../../../../../middleware/mcu-boot/apps/led_demo/src/: milliseconds_delay.h milliseconds_delay.c
  group device
    ../../../../../../devices/MKV11Z7/: MKV11Z7.h MKV11Z7_features.h fsl_device_registers.h system_MKV11Z7.c system_MKV11Z7.h
  group startup
    ../../../../../../middleware/mcu-boot/targets/MKV11Z7/src/startup/arm/: startup_MKV11Z7.s
    ../../../../../../middleware/mcu-boot/src/startup/: startup.c
  group source-include
    ../../../../../../middleware/mcu-boot/src/include/: bootloader_core.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm0plus.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
