# Keil uVision project flashloader_loader.uvprojx, settings and files
target flashloader_loader release (ARM-ADS)
  device: MKV11Z128VLH7 NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: flashloader_loader.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_MKV11Z128VLH7, CPU_IS_ARM_CORTEX_M0P=1, BL_TARGET_FLASH, TWR_KV11Z75M
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -Wno-null-dereference  -Wno-unknown-attributes  -Wno-expansion-to-defined  -Wno-invalid-noreturn
  c include: ../../flashloader/mdk;../../../../../CMSIS/Include;../../../../../middleware/mcu-boot/src;../../../../../middleware/mcu-boot/src/bootloader;../../../../../middleware/mcu-boot/src/include;../../../../../middleware/mcu-boot/src/startup;../../../../../middleware/mcu-boot/src/utilities;../../../../../middleware/mcu-boot/src/drivers;../../../../../middleware/mcu-boot/src/drivers/crc;../../../../../middleware/mcu-boot/src/drivers/microseconds;../../../../../middleware/mcu-boot/targets/MKV11Z7/src;../../../../../devices/MKV11Z7;../../../../../devices/MKV11Z7/drivers;../../../../../devices/MKV11Z7/drivers;../../../../../devices/MKV11Z7;../../../../../devices/MKV11Z7/drivers;../../../../../devices/MKV11Z7/drivers
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=0, LITE_FOOTPRINT
  asm include: ../../../../../middleware/mcu-boot/src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKV11Z128xxx7_flashloader_loader.scf
  link misc: --remove --keep=*(.FlashConfig) --datacompressor off
  group MKV11Z7
    ../../../../../middleware/mcu-boot/targets/MKV11Z7/src/: bootloader_config.h target_config.h
  group drivers
    ../../../../../devices/MKV11Z7/drivers/: fsl_clock.c fsl_clock.h fsl_uart.c fsl_uart.h fsl_common.c fsl_common.h
  group device
    ../../../../../devices/MKV11Z7/: MKV11Z7.h MKV11Z7_features.h fsl_device_registers.h system_MKV11Z7.c system_MKV11Z7.h
  group startup
    ../../../../../middleware/mcu-boot/targets/MKV11Z7/src/startup/arm/: startup_MKV11Z7.s
    ../../../../../middleware/mcu-boot/src/startup/: startup.c
  group source-bootloader
    ../../../../../middleware/mcu-boot/src/bootloader/: flashloader_image.h
    ../../../../../middleware/mcu-boot/src/bootloader/src/: bl_exception_handler.c bl_flashloader.c
  group source-include
    ../../../../../middleware/mcu-boot/src/include/: bootloader_common.h bootloader_core.h
  group source-utilities
    ../../../../../middleware/mcu-boot/src/utilities/: fsl_assert.h vector_table_info.h
  group source-utilities-src
    ../../../../../middleware/mcu-boot/src/utilities/src/: fsl_assert.c
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm0plus.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
