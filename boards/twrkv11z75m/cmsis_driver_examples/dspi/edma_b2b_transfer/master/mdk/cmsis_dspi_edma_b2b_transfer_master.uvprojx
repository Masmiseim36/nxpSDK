# Keil uVision project cmsis_dspi_edma_b2b_transfer_master.uvprojx, settings and files
target cmsis_dspi_edma_b2b_transfer_master debug (ARM-ADS)
  device: MKV11Z128VLH7 NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: cmsis_dspi_edma_b2b_transfer_master.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_MKV11Z128VLH7, TWR_KV11Z75M, TOWER, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../../CMSIS/Driver/Include;../../../../..;../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../devices/MKV11Z7/drivers;../../../../../../../devices/MKV11Z7/drivers;../../../../../../../devices/MKV11Z7/drivers;../../../../../../../devices/MKV11Z7/drivers;../../../../../../../devices/MKV11Z7/drivers;../../../../../../../devices/MKV11Z7/drivers;../../../../../../../devices/MKV11Z7/drivers;../../../../../../../devices/MKV11Z7/cmsis_drivers;../../../../../../../devices/MKV11Z7/drivers;../../../../../../../devices/MKV11Z7;../../../../../../../devices/MKV11Z7/utilities/str;../../../../../../../devices/MKV11Z7/utilities/debug_console;../../../../../../../components/uart;../../../../../../../components/serial_manager;../../../../../../../components/lists;../../../../../../../components/serial_manager;../../../../../../../devices/MKV11Z7/drivers;../../../../../../../devices/MKV11Z7/drivers;../../../../../../../CMSIS/Driver/Include;../../../../../../../CMSIS/Driver/Include;../../../../../../../devices/MKV11Z7/utilities
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKV11Z128xxx7_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
  group source
    ../: cmsis_dspi_edma_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MKV11Z7/drivers/: fsl_port.h fsl_clock.c fsl_clock.h fsl_gpio.c fsl_gpio.h fsl_edma.c fsl_edma.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_common.c fsl_common.h fsl_uart.c fsl_uart.h fsl_smc.c fsl_smc.h
    ../../../../../../../devices/MKV11Z7/cmsis_drivers/: fsl_dspi_cmsis.c fsl_dspi_cmsis.h
  group device
    ../../../../../../../devices/MKV11Z7/: MKV11Z7.h MKV11Z7_features.h fsl_device_registers.h system_MKV11Z7.c system_MKV11Z7.h
  group utilities
    ../../../../../../../devices/MKV11Z7/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/MKV11Z7/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MKV11Z7/utilities/: fsl_assert.c
  group component-uart
    ../../../../../../../components/uart/: uart.h uart_adapter.c
  group component-serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../../../devices/MKV11Z7/arm/: startup_MKV11Z7.s
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm0plus.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_SPI.h Driver_Common.h
target cmsis_dspi_edma_b2b_transfer_master release (ARM-ADS)
  device: MKV11Z128VLH7 NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: cmsis_dspi_edma_b2b_transfer_master.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_MKV11Z128VLH7, TWR_KV11Z75M, TOWER, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKV11Z128xxx7_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
