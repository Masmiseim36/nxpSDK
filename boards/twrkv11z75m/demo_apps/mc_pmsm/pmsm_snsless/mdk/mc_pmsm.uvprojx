# Keil uVision project mc_pmsm.uvprojx, settings and files
target mc_pmsm debug (ARM-ADS)
  device: MKV11Z128VLH7 NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: mc_pmsm.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_MKV11Z128VLH7, TWR_KV11Z75M, TOWER, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../../middleware/motor_control/boards/twrkv11z75m/mc_pmsm/pmsm_snsless;..;../../../..;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../middleware/motor_control/fmstr_cfg_uart;../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_drivers;../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_state_machine;../../../../../../devices/MKV11Z7/drivers;../../../../../../devices/MKV11Z7/drivers;../../../../../../devices/MKV11Z7/drivers;../../../../../../devices/MKV11Z7/drivers;../../../../../../devices/MKV11Z7/drivers;../../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/AMCLIB;../../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/AMCLIB/Include;../../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/GDFLIB;../../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/GDFLIB/Include;../../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/GFLIB;../../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/GFLIB/Include;../../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/GMCLIB;../../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/GMCLIB/Include;../../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/MLIB;../../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/MLIB/Include;../../../../../../middleware/motor_control/pmsm/pmsm_frac;../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_algorithms;../../../../../../middleware/motor_control/pmsm/pmsm_frac/state_machine;../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_identification;../../../../../../devices/MKV11Z7/drivers;../../../../../../devices/MKV11Z7;../../../../../../devices/MKV11Z7/utilities/str;../../../../../../devices/MKV11Z7/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../components/serial_manager;../../../../../../devices/MKV11Z7/drivers;../../../../../../devices/MKV11Z7/drivers;../../../../../../devices/MKV11Z7/drivers;../../../../../../middleware/freemaster/src/common;../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial;../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can;../../../../../../middleware/freemaster/src/platforms/gen32le;../../../../../../devices/MKV11Z7/utilities
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKV11Z128xxx7_flash.scf
  link misc: ../../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/AMCLIB/AMCLIB.lib ../../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/GDFLIB/GDFLIB.lib ../../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/GFLIB/GFLIB.lib ../../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/GMCLIB/GMCLIB.lib ../../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/MLIB/MLIB.lib --remove --keep=*(.FlashConfig)
  group source
    ../../../../../../middleware/motor_control/fmstr_cfg_uart/: freemaster_cfg.h
    ../: main.c main.h m1_pmsm_appconfig.h
    ../../../../../../middleware/motor_control/pmsm/pmsm_frac/: fm_tsa_pmsm.c fm_tsa_pmsm.h
  group mc_drivers
    ../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_drivers/: mcdrv_adc_adc16.h mcdrv_adc_adc16.c mcdrv_pwm3ph_ftm.c mcdrv_pwm3ph_ftm.h mcdrv_mosfet_predrv_spi.c mcdrv_mosfet_predrv_spi.h
  group mc_state_machine
    ../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_state_machine/: m1_sm_snsless.c m1_sm_snsless.h sm_common.h
  group board
    ../: mcdrv_twrkv11z75m.c mcdrv_twrkv11z75m.h mcdrv.h pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MKV11Z7/drivers/: fsl_sim.c fsl_sim.h fsl_port.h fsl_dmamux.c fsl_dmamux.h fsl_clock.c fsl_clock.h fsl_dspi.c fsl_dspi.h fsl_common.c fsl_common.h fsl_uart.c fsl_uart.h fsl_smc.c fsl_smc.h fsl_gpio.c fsl_gpio.h
  group rtcesl/amclib
    ../../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/AMCLIB/Include/: AMCLIB_AngleTrackObsrv_F32.h AMCLIB_CtrlFluxWkng_A32.h AMCLIB_PMSMBemfObsrvABHw_A32.h AMCLIB_PMSMBemfObsrvAB_A32.h AMCLIB_PMSMBemfObsrvDQHw_A32.h AMCLIB_PMSMBemfObsrvDQ_A32.h AMCLIB_TrackObsrv_F32.h amclib.h amclib_types.h
  group rtcesl/gdflib
    ../../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/GDFLIB/Include/: GDFLIB_FilterExp_F32.h GDFLIB_FilterIIR1_F32.h GDFLIB_FilterIIR2_F32.h GDFLIB_FilterMA_A32.h GDFLIB_FilterMA_A32_Asmi.h gdflib.h gdflib_types.h
  group rtcesl/gflib
    ../../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/GFLIB/Include/: GFLIB_AtanYXHw_F32.h GFLIB_AtanYX_F32.h GFLIB_Atan_F32.h GFLIB_CtrlBetaIPp_A32.h GFLIB_CtrlPIp_A32.h GFLIB_DFlexRampHw_A32.h GFLIB_DFlexRamp_A32.h GFLIB_DRamp_F16.h GFLIB_DRamp_F32.h GFLIB_FlexRampHw_A32.h GFLIB_FlexRamp_A32.h GFLIB_Hyst_F16_Asmi.h GFLIB_Integrator_A32.h GFLIB_Limit_F16.h GFLIB_Limit_F32.h GFLIB_LowerLimit_F16.h GFLIB_LowerLimit_F32.h GFLIB_LutPer_F16_Asmi.h GFLIB_LutPer_F32.h GFLIB_Lut_F16_Asmi.h GFLIB_Lut_F32.h GFLIB_Ramp_F16.h GFLIB_Ramp_F16_Asmi.h GFLIB_Ramp_F32.h GFLIB_Ramp_F32_Asmi.h GFLIB_SinCos_A32.h GFLIB_SqrtHw_F16.h GFLIB_SqrtHw_F16_Asmi.h GFLIB_SqrtHw_F32.h GFLIB_SqrtHw_F32_Asmi.h GFLIB_Sqrt_F16.h GFLIB_Sqrt_F32.h GFLIB_UpperLimit_F16.h GFLIB_UpperLimit_F32.h GFLIB_VectorLimit1Hw_F16.h GFLIB_VectorLimit1_F16.h gflib.h gflib_types.h
  group rtcesl/gmclib
    ../../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/GMCLIB/Include/: GMCLIB_Clark_F16_Asmi.h GMCLIB_Decoupling_A32.h GMCLIB_ElimDcBusRipHw_A32.h GMCLIB_ElimDcBusRipHw_F16.h GMCLIB_ElimDcBusRip_A32.h GMCLIB_ElimDcBusRip_F16.h GMCLIB_Park_F16_Asmi.h GMCLIB_Svm_F16.h gmclib.h gmclib_types.h
  group rtcesl/mlib
    ../../../../../../middleware/rtcesl/CM0_RTCESL_4.5_KEIL/MLIB/Include/: MLIB_Abs_F16.h MLIB_Abs_F16_Asmi.h MLIB_Abs_F32.h MLIB_Abs_F32_Asmi.h MLIB_Add4_F16.h MLIB_Add4_F16_Asmi.h MLIB_Add4_F32.h MLIB_Add4_F32_Asmi.h MLIB_Add_A32.h MLIB_Add_A32_Asmi.h MLIB_Add_F16.h MLIB_Add_F16_Asmi.h MLIB_Add_F32.h MLIB_Add_F32_Asmi.h MLIB_BiShift_F16.h MLIB_BiShift_F16_Asmi.h MLIB_BiShift_F32.h MLIB_BiShift_F32_Asmi.h MLIB_Clb_F16_Asmi.h MLIB_Clb_F32.h MLIB_Clb_F32_Asmi.h MLIB_Conv_F32.h MLIB_Div1Q_A32_Asm.h MLIB_Div1Q_F16_Asm.h MLIB_Div1Q_F32_Asm.h MLIB_DivHw1Q_A32_Asm.h MLIB_DivHw1Q_F16_Asm.h MLIB_DivHw1Q_F32_Asm.h MLIB_DivHw_A32_Asm.h MLIB_DivHw_F16_Asm.h MLIB_DivHw_F32.h MLIB_DivHw_F32_Asm.h MLIB_Div_A32_Asm.h MLIB_Div_F16_Asm.h MLIB_Div_F32_Asm.h MLIB_Log2_U16_Asmi.h MLIB_MMDVSQ.h MLIB_Mac4Rnd_F16.h MLIB_Mac4Rnd_F16_Asmi.h MLIB_Mac4Rnd_F32_Asm.h MLIB_Mac4_F32.h MLIB_MacRnd_A32.h MLIB_MacRnd_A32_Asmi.h MLIB_MacRnd_F16.h MLIB_MacRnd_F16_Asmi.h MLIB_MacRnd_F32.h MLIB_MacRnd_F32_Asmi.h MLIB_Mac_A32.h MLIB_Mac_F16.h MLIB_Mac_F16_Asmi.h MLIB_Mac_F32.h MLIB_Mac_F32_Asmi.h MLIB_MnacRnd_A32.h MLIB_MnacRnd_A32_Asmi.h MLIB_MnacRnd_F16.h MLIB_MnacRnd_F16_Asmi.h MLIB_MnacRnd_F32.h MLIB_MnacRnd_F32_Asmi.h MLIB_Mnac_A32.h MLIB_Mnac_F16.h MLIB_Mnac_F16_Asmi.h MLIB_Mnac_F32.h MLIB_Mnac_F32_Asmi.h MLIB_Msu4Rnd_F16.h MLIB_Msu4Rnd_F16_Asmi.h MLIB_Msu4Rnd_F32_Asm.h MLIB_Msu4_F32.h MLIB_MsuRnd_A32.h MLIB_MsuRnd_A32_Asmi.h MLIB_MsuRnd_F16.h MLIB_MsuRnd_F16_Asmi.h MLIB_MsuRnd_F32.h MLIB_MsuRnd_F32_Asmi.h MLIB_Msu_A32.h MLIB_Msu_F16.h MLIB_Msu_F16_Asmi.h MLIB_Msu_F32.h MLIB_Msu_F32_Asmi.h MLIB_MulRnd_A32.h MLIB_MulRnd_A32_Asmi.h MLIB_MulRnd_F16.h MLIB_MulRnd_F16_Asmi.h MLIB_MulRnd_F32.h MLIB_MulRnd_F32_Asmi.h MLIB_Mul_A32.h MLIB_Mul_A32_Asmi.h MLIB_Mul_F16.h MLIB_Mul_F16_Asmi.h MLIB_Mul_F32.h MLIB_Mul_F32_Asmi.h MLIB_Neg_F16.h MLIB_Neg_F16_Asmi.h MLIB_Neg_F32.h MLIB_Neg_F32_Asmi.h MLIB_Rcp1Q_A32_Asm.h MLIB_RcpHw1Q_A32_Asmi.h MLIB_RcpHw_A32_Asm.h MLIB_Rcp_A32_Asm.h MLIB_Rnd_F32.h MLIB_Rnd_F32_Asmi.h MLIB_Sat_A32.h MLIB_Sat_A32_Asmi.h MLIB_Shift_F16.h MLIB_Shift_F16_Asmi.h MLIB_Shift_F32.h MLIB_Shift_F32_Asmi.h MLIB_Sign_F16_Asmi.h MLIB_Sign_F32_Asmi.h MLIB_Sub4_F16.h MLIB_Sub4_F16_Asmi.h MLIB_Sub4_F32.h MLIB_Sub4_F32_Asmi.h MLIB_Sub_A32.h MLIB_Sub_A32_Asmi.h MLIB_Sub_F16.h MLIB_Sub_F16_Asmi.h MLIB_Sub_F32.h MLIB_Sub_F32_Asmi.h RTCESL_cfg.h asm_mac.h mlib.h mlib_types.h
  group mc_algorithms
    ../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_algorithms/: pmsm_control.c pmsm_control.h
  group mc_identification
    ../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_identification/: ke_measure.c ke_measure.h ls_measure.c ls_measure.h mid_auxiliary.c mid_auxiliary.h mid_def.h mid_sm_ctrl.c mid_sm_ctrl.h mid_sm_states.c mid_sm_states.h pp_measure.c pp_measure.h pwrstg_characteristic.c pwrstg_characteristic.h rs_measure.c rs_measure.h
  group state_machine
    ../../../../../../middleware/motor_control/pmsm/pmsm_frac/state_machine/: state_machine.c state_machine.h
  group device
    ../../../../../../devices/MKV11Z7/: MKV11Z7.h MKV11Z7_features.h fsl_device_registers.h system_MKV11Z7.c system_MKV11Z7.h
  group utilities
    ../../../../../../devices/MKV11Z7/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MKV11Z7/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MKV11Z7/utilities/: fsl_assert.c
  group component-uart
    ../../../../../../components/uart/: uart.h uart_adapter.c
  group component-serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../../devices/MKV11Z7/arm/: startup_MKV11Z7.s
  group freemaster
    ../../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_can.c freemaster_can.h freemaster_defcfg.h freemaster_pdbdm.c freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_serial.c freemaster_serial.h freemaster_sha.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h
  group freemaster/drivers/mcuxsdk/can
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mcan.c freemaster_mcan.h freemaster_mscan.c freemaster_mscan.h
  group freemaster/drivers/mcuxsdk/serial
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_usb.c freemaster_serial_usb.h
  group freemaster/platforms
    ../../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm0plus.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
target mc_pmsm release (ARM-ADS)
  device: MKV11Z128VLH7 NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: mc_pmsm.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_MKV11Z128VLH7, TWR_KV11Z75M, TOWER, SERIAL_PORT_TYPE_UART=1
  c misc: -O1  -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKV11Z128xxx7_flash.scf
  link misc: as above
