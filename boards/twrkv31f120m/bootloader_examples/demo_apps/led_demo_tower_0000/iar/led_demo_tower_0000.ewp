# IAR project led_demo_tower_0000.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: MKV31F512xxx12 NXP MKV31F512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CPU_MKV31F512VLL12; TOWER; TWR_KV31F120M
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050,Pe1105,Pe1305,Pa182
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../devices/MKV31F51212; ../../../../../../middleware/mcu-boot/targets/MKV31F51212/src; ../../../../../../middleware/mcu-boot/src/startup; ../../../../../../middleware/mcu-boot/src/include; ../../../../../../middleware/mcu-boot/apps/led_demo/src; ..; ../../../../../../devices/MKV31F51212
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG; BL_HAS_BOOTLOADER_CONFIG
  ILINK.IlinkOutputFile: led_demo_tower_0000.out
  ILINK.IlinkIcfFile: MKV31F512xxx12_application_0x0000.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group MKV31F51212
    ../: main.c
    ../../../../../../middleware/mcu-boot/apps/led_demo/src/: milliseconds_delay.h milliseconds_delay.c
  group device
    ../../../../../../devices/MKV31F51212/: MKV31F51212.h MKV31F51212_features.h fsl_device_registers.h system_MKV31F51212.c system_MKV31F51212.h
  group startup
    ../../../../../../middleware/mcu-boot/src/startup/: crt0.s startup.c
    ../../../../../../middleware/mcu-boot/targets/MKV31F51212/src/startup/iar/: startup_MKV31F51212.s
  group source/include
    ../../../../../../middleware/mcu-boot/src/include/: bootloader_core.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
