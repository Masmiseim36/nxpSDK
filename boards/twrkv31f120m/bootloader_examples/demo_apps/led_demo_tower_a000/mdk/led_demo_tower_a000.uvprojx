# Keil uVision project led_demo_tower_a000.uvprojx, settings and files
target led_demo_tower_a000 release (ARM-ADS)
  device: MKV31F512VLL12 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: led_demo_tower_a000.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_MKV31F512VLL12, TOWER, TWR_KV31F120M
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -Wno-null-dereference  -Wno-unknown-attributes  -Wno-expansion-to-defined  -Wno-invalid-noreturn
  c include: ../../../../../../CMSIS/Include;../../../../../../devices/MKV31F51212;../../../../../../middleware/mcu-boot/targets/MKV31F51212/src;../../../../../../middleware/mcu-boot/src/startup;../../../../../../middleware/mcu-boot/src/include;../../../../../../middleware/mcu-boot/apps/led_demo/src;..;../../../../../../devices/MKV31F51212
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: MKV31F512xxx12_application_0xa000.scf
  link misc: --remove --keep=*(.FlashConfig) --datacompressor off --predefine="-D__ram_vector_table__=1"
  group MKV31F51212
    ../: main.c
    ../../../../../../middleware/mcu-boot/apps/led_demo/src/: milliseconds_delay.h milliseconds_delay.c
  group device
    ../../../../../../devices/MKV31F51212/: MKV31F51212.h MKV31F51212_features.h fsl_device_registers.h system_MKV31F51212.c system_MKV31F51212.h
  group startup
    ../../../../../../middleware/mcu-boot/targets/MKV31F51212/src/startup/arm/: startup_MKV31F51212.s
    ../../../../../../middleware/mcu-boot/src/startup/: startup.c
  group source-include
    ../../../../../../middleware/mcu-boot/src/include/: bootloader_core.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
