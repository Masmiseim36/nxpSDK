<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>ftm_dual_edge_capture</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>ftm_dual_edge_capture</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>ftm_dual_edge_capture</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>ftm_dual_edge_capture</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/ftm_dual_edge_capture.ewp</path>
  </project>
</workspace>
