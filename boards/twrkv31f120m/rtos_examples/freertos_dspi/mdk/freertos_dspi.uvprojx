# Keil uVision project freertos_dspi.uvprojx, settings and files
target freertos_dspi debug (ARM-ADS)
  device: MKV31F512VLL12 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: freertos_dspi.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_MKV31F512VLL12, TWR_KV31F120M, TOWER, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../rtos/amazon-freertos/freertos_kernel/portable/GCC/ARM_CM4F;..;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../rtos/amazon-freertos/freertos_kernel/include;../../../../../devices/MKV31F51212/drivers;../../../../../devices/MKV31F51212/drivers;../../../../../devices/MKV31F51212/drivers;../../../../../devices/MKV31F51212/drivers;../../../../../devices/MKV31F51212/drivers;../../../../../devices/MKV31F51212/drivers;../../../../../devices/MKV31F51212;../../../../../devices/MKV31F51212/utilities/str;../../../../../devices/MKV31F51212/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../components/serial_manager;../../../../../devices/MKV31F51212/drivers;../../../../../devices/MKV31F51212/drivers;../../../../../devices/MKV31F51212/drivers;../../../../../devices/MKV31F51212/utilities
  asm define: DEBUG
  asm include: ..;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: MKV31F512xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
  group source
    ../: freertos_dspi.c FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKV31F51212/drivers/: fsl_port.h fsl_gpio.c fsl_gpio.h fsl_clock.c fsl_clock.h fsl_dspi.c fsl_dspi.h fsl_common.c fsl_common.h fsl_uart.c fsl_uart.h fsl_lpuart.c fsl_lpuart.h fsl_smc.c fsl_smc.h
  group drivers-freertos
    ../../../../../devices/MKV31F51212/drivers/: fsl_dspi_freertos.c fsl_dspi_freertos.h
  group amazon-freertos-freertos_kernel-portable-MemMang
    ../../../../../rtos/amazon-freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group device
    ../../../../../devices/MKV31F51212/: MKV31F51212.h MKV31F51212_features.h fsl_device_registers.h system_MKV31F51212.c system_MKV31F51212.h
  group utilities
    ../../../../../devices/MKV31F51212/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MKV31F51212/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MKV31F51212/utilities/: fsl_assert.c
  group component-uart
    ../../../../../components/uart/: uart.h uart_adapter.c
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MKV31F51212/arm/: startup_MKV31F51212.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
  group amazon-freertos-freertos_kernel
    ../../../../../rtos/amazon-freertos/freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos-freertos_kernel-include
    ../../../../../rtos/amazon-freertos/freertos_kernel/include/: FreeRTOS.h atomic.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group amazon-freertos-freertos_kernel-portable-GCC-ARM_CM4F
    ../../../../../rtos/amazon-freertos/freertos_kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group amazon-freertos-freertos_kernel-portable
    ../../../../../rtos/amazon-freertos/freertos_kernel/portable/: readme.txt
target freertos_dspi release (ARM-ADS)
  device: MKV31F512VLL12 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: freertos_dspi.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_MKV31F512VLL12, TWR_KV31F120M, TOWER, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: NDEBUG
  asm include: ..;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: MKV31F512xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
