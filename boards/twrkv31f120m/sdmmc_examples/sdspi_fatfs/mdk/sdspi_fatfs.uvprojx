# Keil uVision project sdspi_fatfs.uvprojx, settings and files
target sdspi_fatfs debug (ARM-ADS)
  device: MKV31F512VLL12 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: sdspi_fatfs.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_MKV31F512VLL12, TWR_KV31F120M, TOWER, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../devices/MKV31F51212/drivers;../../../../../devices/MKV31F51212/drivers;../../../../../devices/MKV31F51212/drivers;../../../../../middleware/fatfs/source;../../../../../middleware/fatfs/source/fsl_sdspi_disk;../../../../../devices/MKV31F51212/drivers;../../../../../devices/MKV31F51212/drivers;../../../../../devices/MKV31F51212;../../../../../devices/MKV31F51212/utilities/str;../../../../../devices/MKV31F51212/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../components/serial_manager;../../../../../devices/MKV31F51212/drivers;../../../../../devices/MKV31F51212/drivers;../../../../../devices/MKV31F51212/drivers;../../../../../middleware/sdmmc/inc;../../../../../middleware/sdmmc/src;../../../../../devices/MKV31F51212/utilities
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: MKV31F512xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
  group source
    ../: sdspi_fatfs.c ffconf.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKV31F51212/drivers/: fsl_port.h fsl_gpio.c fsl_gpio.h fsl_dspi.c fsl_dspi.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_uart.c fsl_uart.h fsl_lpuart.c fsl_lpuart.h fsl_smc.c fsl_smc.h
  group fatfs-source
    ../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs-source-fsl_sdspi_disk
    ../../../../../middleware/fatfs/source/fsl_sdspi_disk/: fsl_sdspi_disk.c fsl_sdspi_disk.h
  group device
    ../../../../../devices/MKV31F51212/: MKV31F51212.h MKV31F51212_features.h fsl_device_registers.h system_MKV31F51212.c system_MKV31F51212.h
  group utilities
    ../../../../../devices/MKV31F51212/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MKV31F51212/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MKV31F51212/utilities/: fsl_assert.c
  group component-uart
    ../../../../../components/uart/: uart.h uart_adapter.c
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MKV31F51212/arm/: startup_MKV31F51212.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
  group sdmmc
    ../../../../../middleware/sdmmc/: ChangeLogKSDK.txt ChangeLogKSDK.txt
  group sdmmc-inc
    ../../../../../middleware/sdmmc/inc/: fsl_sdspi.h fsl_sdmmc_spec.h
  group sdmmc-src
    ../../../../../middleware/sdmmc/src/: fsl_sdspi.c
target sdspi_fatfs release (ARM-ADS)
  device: MKV31F512VLL12 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: sdspi_fatfs.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_MKV31F512VLL12, TWR_KV31F120M, TOWER, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: MKV31F512xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
