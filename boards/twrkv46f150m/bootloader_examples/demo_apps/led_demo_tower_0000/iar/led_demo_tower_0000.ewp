# IAR project led_demo_tower_0000.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: MKV46F256xxx16 NXP MKV46F256xxx16
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CPU_MKV46F256VLL16; TOWER; TWR_KV46F150M
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050,Pe1105,Pe1305,Pa182
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../devices/MKV46F16; ../../../../../../middleware/mcu-boot/targets/MKV46F16/src; ../../../../../../middleware/mcu-boot/src/startup; ../../../../../../middleware/mcu-boot/src/include; ../../../../../../middleware/mcu-boot/apps/led_demo/src; ..; ../../../../../../devices/MKV46F16/drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG; BL_HAS_BOOTLOADER_CONFIG
  ILINK.IlinkOutputFile: led_demo_tower_0000.out
  ILINK.IlinkIcfFile: MKV46F256xxx16_application_0x0000.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group board
    ../: pin_mux.c pin_mux.h
  group MKV46F16
    ../: main.c
    ../../../../../../middleware/mcu-boot/apps/led_demo/src/: milliseconds_delay.h milliseconds_delay.c
  group drivers
    ../../../../../../devices/MKV46F16/drivers/: fsl_port.h fsl_gpio.c fsl_gpio.h fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h
  group device
    ../../../../../../devices/MKV46F16/: MKV46F16.h MKV46F16_features.h fsl_device_registers.h system_MKV46F16.c system_MKV46F16.h
  group startup
    ../../../../../../middleware/mcu-boot/src/startup/: crt0.s startup.c
    ../../../../../../middleware/mcu-boot/targets/MKV46F16/src/startup/iar/: startup_MKV46F16.s
  group source/include
    ../../../../../../middleware/mcu-boot/src/include/: bootloader_core.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
