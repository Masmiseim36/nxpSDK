# Keil uVision project led_demo_tower_0000.uvprojx, settings and files
target led_demo_tower_0000 release (ARM-ADS)
  device: MKV46F256VLL16 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.3.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: led_demo_tower_0000.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_MKV46F256VLL16, TOWER, TWR_KV46F150M
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -Wno-null-dereference  -Wno-unknown-attributes  -Wno-expansion-to-defined  -Wno-invalid-noreturn
  c include: ../../../../../../CMSIS/Include;../../../../../../devices/MKV46F16;../../../../../../middleware/mcu-boot/targets/MKV46F16/src;../../../../../../middleware/mcu-boot/src/startup;../../../../../../middleware/mcu-boot/src/include;../../../../../../middleware/mcu-boot/apps/led_demo/src;..;../../../../../../devices/MKV46F16
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: MKV46F256xxx16_application_0x0000.scf
  link misc: --remove --keep=*(.FlashConfig) --datacompressor off --predefine="-D__ram_vector_table__=1"
  group MKV46F16
    ../: main.c
    ../../../../../../middleware/mcu-boot/apps/led_demo/src/: milliseconds_delay.h milliseconds_delay.c
  group device
    ../../../../../../devices/MKV46F16/: MKV46F16.h MKV46F16_features.h fsl_device_registers.h system_MKV46F16.c system_MKV46F16.h
  group startup
    ../../../../../../middleware/mcu-boot/targets/MKV46F16/src/startup/arm/: startup_MKV46F16.s
    ../../../../../../middleware/mcu-boot/src/startup/: startup.c
  group source-include
    ../../../../../../middleware/mcu-boot/src/include/: bootloader_core.h
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
