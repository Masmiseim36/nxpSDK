# IAR project tower_bootloader.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV46F256xxx16 NXP MKV46F256xxx16
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKV46F256VLL16; TOWER; BL_TARGET_FLASH; TWR_KV46F150m; FSL_OSA_BM_TIMER_CONFIG=FSL_OSA_BM_TIMER_NONE
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050,Pe1105,Pe1305,Pa182
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../middleware/mcu-boot/src; ../../../../../middleware/mcu-boot/src/bootloader; ../../../../../middleware/mcu-boot/src/autobaud; ../../../../../middleware/mcu-boot/src/crc; ../../../../../middleware/mcu-boot/src/include; ../../../../../middleware/mcu-boot/src/startup; ../../../../../middleware/mcu-boot/src/utilities; ../../../../../middleware/mcu-boot/src/memory; ../../../../../middleware/mcu-boot/src/memory/src; ../../../../../middleware/mcu-boot/src/packet; ../../../../../middleware/mcu-boot/src/property; ../../../../../middleware/mcu-boot/src/sbloader; ../../../../../middleware/mcu-boot/src/drivers; ../../../../../middleware/mcu-boot/src/drivers/crc; ../../../../../middleware/mcu-boot/src/drivers/microseconds; ../../../../../middleware/mcu-boot/src/drivers/smc; ../../../../../middleware/mcu-boot/src/security; ../../../../../middleware/mcu-boot/src/bm_usb; ../../../../../middleware/mcu-boot/targets/MKV46F16/src; ../../../../../devices/MKV46F16; ../../../../../devices/MKV46F16/drivers; ..; ../../../../../components/osa; ../../../../../components/lists
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../../middleware/mcu-boot/src/startup
  OBJCOPY.OOCOutputFile: generic.srec
  ILINK.IlinkOutputFile: tower_bootloader.out
  ILINK.IlinkIcfFile: MKV46F256xxx16_application_0x0000.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV46F256VLL16; TOWER; BL_TARGET_FLASH; TWR_KV46F150m; FSL_OSA_BM_TIMER_CONFIG=FSL_OSA_BM_TIMER_NONE
  AARM.ADefines: NDEBUG
  group board
    ../: pin_mux.c pin_mux.h
  group drivers
    ../../../../../devices/MKV46F16/drivers/: fsl_clock.c fsl_clock.h fsl_flash.h fsl_ftfx_adapter.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_features.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_ftfx_utilities.h fsl_uart.c fsl_uart.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_port.h fsl_dspi.c fsl_dspi.h fsl_crc.c fsl_crc.h fsl_flexcan.c fsl_flexcan.h fsl_common.c fsl_common.h
  group device
    ../../../../../devices/MKV46F16/: MKV46F16.h MKV46F16_features.h fsl_device_registers.h system_MKV46F16.c system_MKV46F16.h
  group startup
    ../../../../../middleware/mcu-boot/src/startup/: crt0.s ar_asm_macros.h startup.c
    ../../../../../middleware/mcu-boot/targets/MKV46F16/src/startup/iar/: startup_MKV46F16.s
  group source/autobaud
    ../../../../../middleware/mcu-boot/src/autobaud/: autobaud.h
    ../../../../../middleware/mcu-boot/src/autobaud/src/: autobaud_irq.c
  group source/bootloader
    ../../../../../middleware/mcu-boot/src/bootloader/: bl_app_crc_check.h bl_command.h bl_context.h bl_irq_common.h bl_peripheral.h bl_peripheral_interface.h bl_shutdown_cleanup.h bl_user_entry.h bl_version.h bootloader.h bl_reliable_update.h
  group source/bootloader/src
    ../../../../../middleware/mcu-boot/src/bootloader/src/: bl_app_crc_check.c bl_command.c bl_context.c bl_exception_handler.c bl_main.c bl_misc.c bl_shutdown_cleanup.c bl_tree_root.c bl_user_entry.c bl_reliable_update.c dspi_peripheral_interface.c flexcan_peripheral_interface.c i2c_peripheral_interface.c scuart_peripheral_interface.c
  group source/crc
    ../../../../../middleware/mcu-boot/src/crc/: crc16.h crc32.h
    ../../../../../middleware/mcu-boot/src/crc/src/: crc16.c crc32.c
  group source/include
    ../../../../../middleware/mcu-boot/src/include/: bootloader_common.h bootloader_core.h
  group source/memory
    ../../../../../middleware/mcu-boot/src/memory/: memory.h
  group source/memory/src
    ../../../../../middleware/mcu-boot/src/memory/src/: memory.c normal_memory.c normal_memory.h pattern_fill.h pattern_fill.s sram_init.h flash_memory.c flash_memory.h sram_init_cm4.c
  group source/packet
    ../../../../../middleware/mcu-boot/src/packet/: command_packet.h serial_packet.h
  group source/packet/src
    ../../../../../middleware/mcu-boot/src/packet/src/: serial_packet.c
  group source/property
    ../../../../../middleware/mcu-boot/src/property/: property.h
  group source/property/src
    ../../../../../middleware/mcu-boot/src/property/src/: property_kinetis.c
  group source/sbloader
    ../../../../../middleware/mcu-boot/src/sbloader/: sb_file_format.h sbloader.h
  group source/sbloader/src
    ../../../../../middleware/mcu-boot/src/sbloader/src/: sbloader.c
  group source/utilities
    ../../../../../middleware/mcu-boot/src/utilities/: fsl_assert.h fsl_rtos_abstraction.h vector_table_info.h kinetis_family.h
  group source/utilities/src
    ../../../../../middleware/mcu-boot/src/utilities/src/: debug_util.c fsl_assert.c fsl_rtos_abstraction.c
  group source/drivers/smc
    ../../../../../middleware/mcu-boot/src/drivers/smc/: smc.c smc.h
  group source/drivers/microseconds
    ../../../../../middleware/mcu-boot/src/drivers/microseconds/: microseconds.h
    ../../../../../middleware/mcu-boot/src/drivers/microseconds/src/: microseconds_sysclk.c
  group MKV46F16
    ../../../../../middleware/mcu-boot/targets/MKV46F16/src/: bl_clock_config_MKV46F16.c bl_peripherals_MKV46F16.c bootloader_config.h hardware_init_MKV46F16.c memory_map_MKV46F16.c peripherals_pinmux.h target_config.h
    ../../../../../middleware/mcu-boot/targets/common/src/: bl_dspi_irq_config_common.c bl_i2c_irq_config_common.c bl_uart_irq_config_common.c pinmux_utility_common.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
