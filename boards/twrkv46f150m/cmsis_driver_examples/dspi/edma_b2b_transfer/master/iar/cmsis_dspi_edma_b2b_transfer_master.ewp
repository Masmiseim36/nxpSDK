# IAR project cmsis_dspi_edma_b2b_transfer_master.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV46F256xxx16 NXP MKV46F256xxx16
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MKV46F256VLL16; TWR_KV46F150M; TOWER; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../../CMSIS/Driver/Include; ../../../../..; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../devices/MKV46F16/drivers; ../../../../../../../devices/MKV46F16/cmsis_drivers; ../../../../../../../devices/MKV46F16; ../../../../../../../devices/MKV46F16/utilities/str; ../../../../../../../devices/MKV46F16/utilities/debug_console; ../../../../../../../components/uart; ../../../../../../../components/serial_manager; ../../../../../../../components/lists; ../../../../../../../devices/MKV46F16/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: cmsis_dspi_edma_b2b_transfer_master.out
  ILINK.IlinkIcfFile: MKV46F256xxx16_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV46F256VLL16; TWR_KV46F150M; TOWER; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: cmsis_dspi_edma_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MKV46F16/drivers/: fsl_port.h fsl_clock.c fsl_clock.h fsl_gpio.c fsl_gpio.h fsl_edma.c fsl_edma.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_common.c fsl_common.h fsl_uart.c fsl_uart.h fsl_smc.c fsl_smc.h
    ../../../../../../../devices/MKV46F16/cmsis_drivers/: fsl_dspi_cmsis.c fsl_dspi_cmsis.h
  group device
    ../../../../../../../devices/MKV46F16/: MKV46F16.h MKV46F16_features.h fsl_device_registers.h system_MKV46F16.c system_MKV46F16.h
  group utilities
    ../../../../../../../devices/MKV46F16/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/MKV46F16/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MKV46F16/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../../components/uart/: uart.h uart_adapter.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../../../devices/MKV46F16/iar/: startup_MKV46F16.s
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_SPI.h Driver_Common.h
