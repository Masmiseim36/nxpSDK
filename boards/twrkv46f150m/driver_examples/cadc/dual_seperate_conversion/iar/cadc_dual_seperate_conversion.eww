<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>cadc_dual_seperate_conversion</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>cadc_dual_seperate_conversion</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>cadc_dual_seperate_conversion</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>cadc_dual_seperate_conversion</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/cadc_dual_seperate_conversion.ewp</path>
  </project>
</workspace>
