# Keil uVision project freertos_i2c.uvprojx, settings and files
target freertos_i2c debug (ARM-ADS)
  device: MKV46F256VLL16 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.3.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: freertos_i2c.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKV46F256VLL16, TWR_KV46F150M, TOWER, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc --diag_suppress=1296,186
  c include: ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F;..;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../rtos/amazon-freertos/lib/include;../../../../../rtos/amazon-freertos/lib/include/private;../../../../../devices/MKV46F16/drivers;../../../../../devices/MKV46F16/drivers;../../../../../devices/MKV46F16/drivers;../../../../../devices/MKV46F16/drivers;../../../../../devices/MKV46F16/drivers;../../../../../devices/MKV46F16/drivers;../../../../../devices/MKV46F16;../../../../../devices/MKV46F16/utilities/str;../../../../../devices/MKV46F16/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/serial_manager;../../../../../devices/MKV46F16/drivers;../../../../../components/lists;../../../../../devices/MKV46F16/drivers
  asm define: DEBUG
  asm include: ..;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: MKV46F256xxx16_flash.scf
  link misc: --remove
  group source
    ../: freertos_i2c.c FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKV46F16/drivers/: fsl_port.h fsl_gpio.c fsl_gpio.h fsl_clock.c fsl_clock.h fsl_i2c.c fsl_i2c.h fsl_common.c fsl_common.h fsl_uart.c fsl_uart.h fsl_smc.c fsl_smc.h
  group drivers-freertos
    ../../../../../devices/MKV46F16/drivers/: fsl_i2c_freertos.c fsl_i2c_freertos.h
  group amazon-freertos-freertos
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos-freertos-portable
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
  group amazon-freertos-include
    ../../../../../rtos/amazon-freertos/lib/include/: FreeRTOS.h event_groups.h freertos_tasks_c_additions.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
    ../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h stack_macros.h threading_alt.h
  group device
    ../../../../../devices/MKV46F16/: MKV46F16.h MKV46F16_features.h fsl_device_registers.h system_MKV46F16.c system_MKV46F16.h
  group utilities
    ../../../../../devices/MKV46F16/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MKV46F16/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MKV46F16/utilities/: fsl_assert.c
  group component-uart
    ../../../../../components/uart/: uart.h uart_adapter.c
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MKV46F16/arm/: startup_MKV46F16.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h
target freertos_i2c release (ARM-ADS)
  device: MKV46F256VLL16 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.3.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: freertos_i2c.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKV46F256VLL16, TWR_KV46F150M, TOWER, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc --diag_suppress=1296,186
  c include: as above
  asm define: NDEBUG
  asm include: ..;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: MKV46F256xxx16_flash.scf
  link misc: --remove
