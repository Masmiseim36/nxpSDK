# IAR project flashloader_loader.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV58F1M0xxx24 NXP MKV58F1M0xxx24
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MKV58F1M0VLQ24; CPU_IS_ARM_CORTEX_M7=1; BL_TARGET_FLASH; TWR_KV58F220M
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050,Pe1105,Pe1305,Pa182
  ICCARM.CCIncludePath2: ../../flashloader/iar; ../../../../../CMSIS/Include; ../../../../../middleware/mcu-boot/src; ../../../../../middleware/mcu-boot/src/bootloader; ../../../../../middleware/mcu-boot/src/include; ../../../../../middleware/mcu-boot/src/startup; ../../../../../middleware/mcu-boot/src/utilities; ../../../../../middleware/mcu-boot/src/drivers; ../../../../../middleware/mcu-boot/src/drivers/crc; ../../../../../middleware/mcu-boot/src/drivers/microseconds; ../../../../../middleware/mcu-boot/targets/MKV58F24/src; ../../../../../devices/MKV58F24; ../../../../../devices/MKV58F24/drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; LITE_FOOTPRINT
  AARM.AUserIncludes: ../../../../../middleware/mcu-boot/src/include
  OBJCOPY.OOCOutputFile: generic.srec
  ILINK.IlinkOutputFile: flashloader_loader.out
  ILINK.IlinkIcfFile: MKV58F1M0xxx24_flashloader_loader.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV58F1M0VLQ24; CPU_IS_ARM_CORTEX_M7=1; BL_TARGET_FLASH; TWR_KV58F220M
  AARM.ADefines: NDEBUG; LITE_FOOTPRINT
  group doc
    ../: readme.txt
  group MKV58F24
    ../../../../../middleware/mcu-boot/targets/MKV58F24/src/: bootloader_config.h target_config.h
  group drivers
    ../../../../../devices/MKV58F24/drivers/: fsl_clock.c fsl_clock.h fsl_uart.c fsl_uart.h fsl_common.c fsl_common.h
  group device
    ../../../../../devices/MKV58F24/: MKV58F24.h MKV58F24_features.h fsl_device_registers.h system_MKV58F24.c system_MKV58F24.h
  group startup
    ../../../../../middleware/mcu-boot/src/startup/: crt0.s startup.c
    ../../../../../middleware/mcu-boot/targets/MKV58F24/src/startup/iar/: startup_MKV58F24.s
  group source/bootloader
    ../../../../../middleware/mcu-boot/src/bootloader/: flashloader_image.h
    ../../../../../middleware/mcu-boot/src/bootloader/src/: bl_exception_handler.c bl_flashloader.c
  group source/include
    ../../../../../middleware/mcu-boot/src/include/: bootloader_common.h bootloader_core.h
  group source/utilities
    ../../../../../middleware/mcu-boot/src/utilities/: fsl_assert.h vector_table_info.h
  group source/utilities/src
    ../../../../../middleware/mcu-boot/src/utilities/src/: fsl_assert.c
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
