# Keil uVision project flashloader_loader.uvprojx, settings and files
target flashloader_loader debug (ARM-ADS)
  device: MKV58F1M0VLQ24 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: flashloader_loader.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_MKV58F1M0VLQ24, CPU_IS_ARM_CORTEX_M7=1, BL_TARGET_FLASH, TWR_KV58F220M
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -Wno-null-dereference  -Wno-unknown-attributes  -Wno-expansion-to-defined  -Wno-invalid-noreturn
  c include: ../../flashloader/mdk;../../../../../CMSIS/Include;../../../../../middleware/mcu-boot/src;../../../../../middleware/mcu-boot/src/bootloader;../../../../../middleware/mcu-boot/src/include;../../../../../middleware/mcu-boot/src/startup;../../../../../middleware/mcu-boot/src/utilities;../../../../../middleware/mcu-boot/src/drivers;../../../../../middleware/mcu-boot/src/drivers/crc;../../../../../middleware/mcu-boot/src/drivers/microseconds;../../../../../middleware/mcu-boot/targets/MKV58F24/src;../../../../../devices/MKV58F24;../../../../../devices/MKV58F24/drivers
  asm define: DEBUG, BL_HAS_BOOTLOADER_CONFIG=0, LITE_FOOTPRINT
  asm include: ../../../../../middleware/mcu-boot/src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: MKV58F1M0xxx24_flashloader_loader.scf
  link misc: --remove --keep=*(.FlashConfig) --datacompressor off
  group doc
    ../: readme.txt
  group MKV58F24
    ../../../../../middleware/mcu-boot/targets/MKV58F24/src/: bootloader_config.h target_config.h
  group drivers
    ../../../../../devices/MKV58F24/drivers/: fsl_clock.c fsl_clock.h fsl_uart.c fsl_uart.h fsl_common.c fsl_common.h
  group device
    ../../../../../devices/MKV58F24/: MKV58F24.h MKV58F24_features.h fsl_device_registers.h system_MKV58F24.c system_MKV58F24.h
  group startup
    ../../../../../middleware/mcu-boot/targets/MKV58F24/src/startup/arm/: startup_MKV58F24.S
    ../../../../../middleware/mcu-boot/src/startup/: startup.c
  group source-bootloader
    ../../../../../middleware/mcu-boot/src/bootloader/: flashloader_image.h
    ../../../../../middleware/mcu-boot/src/bootloader/src/: bl_exception_handler.c bl_flashloader.c
  group source-include
    ../../../../../middleware/mcu-boot/src/include/: bootloader_common.h bootloader_core.h
  group source-utilities
    ../../../../../middleware/mcu-boot/src/utilities/: fsl_assert.h vector_table_info.h
  group source-utilities-src
    ../../../../../middleware/mcu-boot/src/utilities/src/: fsl_assert.c
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
target flashloader_loader release (ARM-ADS)
  device: MKV58F1M0VLQ24 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: flashloader_loader.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_MKV58F1M0VLQ24, CPU_IS_ARM_CORTEX_M7=1, BL_TARGET_FLASH, TWR_KV58F220M
  c misc: as above
  c include: as above
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=0, LITE_FOOTPRINT
  asm include: ../../../../../middleware/mcu-boot/src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: MKV58F1M0xxx24_flashloader_loader.scf
  link misc: --remove --keep=*(.FlashConfig) --datacompressor off
