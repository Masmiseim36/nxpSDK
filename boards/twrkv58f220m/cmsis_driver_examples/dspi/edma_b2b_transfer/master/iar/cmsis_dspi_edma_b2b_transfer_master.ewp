# IAR project cmsis_dspi_edma_b2b_transfer_master.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV58F1M0xxx24 NXP MKV58F1M0xxx24
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MKV58F1M0VLQ24; TWR_KV58F220M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..; ../../../../../../../CMSIS/Driver/Include; ../../../../..; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../devices/MKV58F24/drivers; ../../../../../../../devices/MKV58F24/cmsis_drivers; ../../../../../../../devices/MKV58F24; ../../../../../../../devices/MKV58F24/utilities/io; ../../../../../../../devices/MKV58F24/utilities/str; ../../../../../../../devices/MKV58F24/utilities/log; ../../../../../../../devices/MKV58F24/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: cmsis_dspi_edma_b2b_transfer_master.out
  ILINK.IlinkIcfFile: MKV58F1M0xxx24_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV58F1M0VLQ24; TWR_KV58F220M; TOWER
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: cmsis_dspi_edma_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MKV58F24/drivers/: fsl_port.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_dspi.h fsl_dspi.c fsl_dspi_edma.h fsl_dspi_edma.c fsl_flash.c fsl_flash.h fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c
    ../../../../../../../devices/MKV58F24/cmsis_drivers/: fsl_dspi_cmsis.h fsl_dspi_cmsis.c
  group startup
    ../../../../../../../devices/MKV58F24/: system_MKV58F24.c system_MKV58F24.h
    ../../../../../../../devices/MKV58F24/iar/: startup_MKV58F24.s
  group utilities
    ../../../../../../../devices/MKV58F24/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../../devices/MKV58F24/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../../devices/MKV58F24/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MKV58F24/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
