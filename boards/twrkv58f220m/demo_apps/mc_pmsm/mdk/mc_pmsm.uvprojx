# Keil uVision project mc_pmsm.uvprojx, settings and files
target mc_pmsm debug (ARM-ADS)
  device: MKV58F1M0VLQ24 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.3.0
  cpu: CPUTYPE("Cortex-M7") FPU2
  output: mc_pmsm.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKV58F1M0VLQ24, ARM_MATH_CM4, TWR_KV58F220M, TOWER
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;..;../../../../../middleware/motor_control/boards/twrkv58f220m;../../../../../devices/MKV58F24/drivers;../../../../../middleware/rtcesl/CM7F_RTCESL_4.5_KEIL/AMCLIB;../../../../../middleware/rtcesl/CM7F_RTCESL_4.5_KEIL/AMCLIB/Include;../../../../../middleware/rtcesl/CM7F_RTCESL_4.5_KEIL/GDFLIB;../../../../../middleware/rtcesl/CM7F_RTCESL_4.5_KEIL/GDFLIB/Include;../../../../../middleware/rtcesl/CM7F_RTCESL_4.5_KEIL/GFLIB;../../../../../middleware/rtcesl/CM7F_RTCESL_4.5_KEIL/GFLIB/Include;../../../../../middleware/rtcesl/CM7F_RTCESL_4.5_KEIL/GMCLIB;../../../../../middleware/rtcesl/CM7F_RTCESL_4.5_KEIL/GMCLIB/Include;../../../../../middleware/rtcesl/CM7F_RTCESL_4.5_KEIL/MLIB;../../../../../middleware/rtcesl/CM7F_RTCESL_4.5_KEIL/MLIB/Include;../../../../../devices/MKV58F24;../../../../../devices/MKV58F24/utilities/io;../../../../../devices/MKV58F24/utilities/str;../../../../../devices/MKV58F24/utilities/log;../../../../../devices/MKV58F24/utilities;../../../../../middleware/motor_control/pmsm;../../../../../middleware/motor_control/pmsm/mc_algorithms;../../../../../middleware/motor_control/pmsm/mc_state_machine;../../../../../middleware/motor_control/pmsm/state_machine;../../../../../middleware/motor_control/freemaster/freemaster_drv
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: MKV58F1M0xxx24_flash.scf
  link misc: ../../../../../middleware/rtcesl/CM7F_RTCESL_4.5_KEIL/AMCLIB/AMCLIB.lib 
../../../../../middleware/rtcesl/CM7F_RTCESL_4.5_KEIL/GFLIB/GFLIB.lib 
../../../../../middleware/rtcesl/CM7F_RTCESL_4.5_KEIL/GDFLIB/GDFLIB.lib 
../../../../../middleware/rtcesl/CM7F_RTCESL_4.5_KEIL/GMCLIB/GMCLIB.lib 
../../../../../middleware/rtcesl/CM7F_RTCESL_4.5_KEIL/MLIB/MLIB.lib 
--remove
  group mc_drivers
    ../: mcdrv_adc_hsadc.c mcdrv_adc_hsadc.h mcdrv_pwm3ph_pwma.c mcdrv_pwm3ph_pwma.h mcdrv_mosfet_predrv_spi.c mcdrv_mosfet_predrv_spi.h
  group source
    ../: main.c m1_pmsm_appconfig.h
    ../../../../../middleware/motor_control/pmsm/: freemaster_cfg.h fm_tsa_pmsm.h fm_tsa_pmsm.c
  group board
    ../: mcdrv_twrkv58f220m.c mcdrv_twrkv58f220m.h mcdrv.h pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKV58F24/drivers/: fsl_sim.h fsl_sim.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_port.h fsl_dmamux.h fsl_dmamux.c fsl_xbara.h fsl_xbara.c fsl_dspi.h fsl_dspi.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c
  group rtcesl/amclib
    ../../../../../middleware/rtcesl/CM7F_RTCESL_4.5_KEIL/AMCLIB/Include/: amclib.h AMCLIB_ACIMCtrlMTPA_FLT.h AMCLIB_ACIMRotFluxObsrv_FLT.h AMCLIB_ACIMSpeedMRAS_FLT.h AMCLIB_AngleTrackObsrv_F32.h AMCLIB_AngleTrackObsrv_FLT.h AMCLIB_CtrlFluxWkng_A32.h AMCLIB_CtrlFluxWkng_FLT.h amclib_FP.h AMCLIB_PMSMBemfObsrvAB_A32.h AMCLIB_PMSMBemfObsrvAB_FLT.h AMCLIB_PMSMBemfObsrvDQ_A32.h AMCLIB_PMSMBemfObsrvDQ_FLT.h AMCLIB_TrackObsrv_F32.h AMCLIB_TrackObsrv_FLT.h amclib_types.h
  group rtcesl/gdflib
    ../../../../../middleware/rtcesl/CM7F_RTCESL_4.5_KEIL/GDFLIB/Include/: gdflib.h GDFLIB_FilterExp_F32.h GDFLIB_FilterExp_FLT.h GDFLIB_FilterIIR1_F32.h GDFLIB_FilterIIR1_F32_Asmi.h GDFLIB_FilterIIR1_FLT.h GDFLIB_FilterIIR2_F32.h GDFLIB_FilterIIR2_FLT.h GDFLIB_FilterIIR3_F32.h GDFLIB_FilterIIR3_FLT.h GDFLIB_FilterIIR4_F32.h GDFLIB_FilterIIR4_FLT.h GDFLIB_FilterMA_A32.h GDFLIB_FilterMA_FLT.h gdflib_FP.h gdflib_types.h
  group rtcesl/gflib
    ../../../../../middleware/rtcesl/CM7F_RTCESL_4.5_KEIL/GFLIB/Include/: gflib.h GFLIB_Acos_F16.h GFLIB_Acos_FLT.h GFLIB_Asin_F16.h GFLIB_Asin_FLT.h GFLIB_Atan_F32.h GFLIB_Atan_FLT.h GFLIB_AtanYX_F16.h GFLIB_AtanYX_FLT.h GFLIB_CtrlBetaIPDp_A32.h GFLIB_CtrlBetaIPDp_FLT.h GFLIB_CtrlBetaIPp_A32.h GFLIB_CtrlBetaIPp_FLT.h GFLIB_CtrlPIDp_A32.h GFLIB_CtrlPIDp_FLT.h GFLIB_CtrlPIp_A32.h GFLIB_CtrlPIp_FLT.h GFLIB_DFlexRamp_A32.h GFLIB_DFlexRamp_FLT.h GFLIB_DRamp_F16.h GFLIB_DRamp_F32.h GFLIB_DRamp_FLT.h GFLIB_FlexRamp_A32.h GFLIB_FlexRamp_FLT.h GFLIB_FlexSRamp_A32.h GFLIB_FlexSRamp_FLT.h gflib_FP.h GFLIB_Hyst_F16_Asmi.h GFLIB_Hyst_FLT.h GFLIB_Integrator_A32.h GFLIB_Integrator_FLT.h GFLIB_Limit_F16.h GFLIB_Limit_F32.h GFLIB_Limit_FLT.h GFLIB_LowerLimit_F16.h GFLIB_LowerLimit_F32.h GFLIB_LowerLimit_FLT.h GFLIB_Lut_F16_Asmi.h GFLIB_Lut_F32.h GFLIB_Lut_FLT.h GFLIB_LutPer_F16_Asmi.h GFLIB_LutPer_F32.h GFLIB_LutPer_FLT.h GFLIB_Ramp_F16.h GFLIB_Ramp_F32.h GFLIB_Ramp_FLT.h GFLIB_SinCos_F32.h GFLIB_SinCos_FLT.h GFLIB_Sqrt_F16.h GFLIB_Sqrt_F32.h GFLIB_Sqrt_FLT_Asmi.h GFLIB_Tan_F32.h GFLIB_Tan_FLT.h gflib_types.h GFLIB_UpperLimit_F16.h GFLIB_UpperLimit_F32.h GFLIB_UpperLimit_FLT.h GFLIB_VectorLimit_F16.h GFLIB_VectorLimit_FLT.h
  group rtcesl/gmclib
    ../../../../../middleware/rtcesl/CM7F_RTCESL_4.5_KEIL/GMCLIB/Include/: gmclib.h GMCLIB_Clark_F16_Asmi.h GMCLIB_Clark_FLT.h GMCLIB_Decoupling_A32.h GMCLIB_Decoupling_FLT.h GMCLIB_ElimDcBusRip_A32_Asmi.h GMCLIB_ElimDcBusRip_F16_Asmi.h GMCLIB_ElimDcBusRip_FLT.h gmclib_FP.h GMCLIB_Park_F16_Asmi.h GMCLIB_Park_FLT.h GMCLIB_Svm_F16.h gmclib_types.h
  group rtcesl/mlib
    ../../../../../middleware/rtcesl/CM7F_RTCESL_4.5_KEIL/MLIB/Include/: asm_mac.h mlib.h MLIB_Abs_F16.h MLIB_Abs_F16_Asmi.h MLIB_Abs_F32.h MLIB_Abs_F32_Asmi.h MLIB_Abs_FLT.h MLIB_Abs_FLT_Asmi.h MLIB_Add_A32.h MLIB_Add_F16.h MLIB_Add_F16_Asmi.h MLIB_Add_F32.h MLIB_Add_F32_Asmi.h MLIB_Add_FLT.h MLIB_Add4_F16_Asmi.h MLIB_Add4_F32_Asmi.h MLIB_Add4_FLT.h MLIB_BiShift_F16.h MLIB_BiShift_F32.h MLIB_Clb_F16.h MLIB_Clb_F32.h MLIB_Conv_F32.h MLIB_Conv_FLT_Asmi.h MLIB_ConvSc_FLT_Asmi.h MLIB_Div_A32.h MLIB_Div_F16.h MLIB_Div_F32.h MLIB_Div_FLT.h MLIB_Div1Q_A32.h MLIB_Div1Q_F16.h MLIB_Div1Q_F32.h mlib_FP.h MLIB_Log2_U16.h MLIB_Mac_A32.h MLIB_Mac_F16_Asmi.h MLIB_Mac_F32.h MLIB_Mac_F32_Asmi.h MLIB_Mac_FLT.h MLIB_Mac4_F32.h MLIB_Mac4_F32_Asmi.h MLIB_Mac4_FLT.h MLIB_Mac4Rnd_F16_Asmi.h MLIB_Mac4Rnd_F32.h MLIB_Mac4Rnd_F32_Asmi.h MLIB_MacRnd_A32.h MLIB_MacRnd_F16_Asmi.h MLIB_MacRnd_F32.h MLIB_MacRnd_F32_Asmi.h MLIB_Mnac_A32.h MLIB_Mnac_F16_Asmi.h MLIB_Mnac_F32.h MLIB_Mnac_F32_Asmi.h MLIB_Mnac_FLT.h MLIB_MnacRnd_A32.h MLIB_MnacRnd_F16_Asmi.h MLIB_MnacRnd_F32.h MLIB_MnacRnd_F32_Asmi.h MLIB_Msu_A32.h MLIB_Msu_F16_Asmi.h MLIB_Msu_F32_Asmi.h MLIB_Msu_FLT.h MLIB_Msu4_F32.h MLIB_Msu4_F32_Asmi.h MLIB_Msu4_FLT.h MLIB_Msu4Rnd_F16.h MLIB_Msu4Rnd_F16_Asmi.h MLIB_Msu4Rnd_F32.h MLIB_Msu4Rnd_F32_Asmi.h MLIB_MsuRnd_A32.h MLIB_MsuRnd_F16_Asmi.h MLIB_MsuRnd_F32.h MLIB_MsuRnd_F32_Asmi.h MLIB_Mul_A32.h MLIB_Mul_A32_Asmi.h MLIB_Mul_F16.h MLIB_Mul_F16_Asmi.h MLIB_Mul_F32.h MLIB_Mul_F32_Asmi.h MLIB_Mul_FLT.h MLIB_MulRnd_A32.h MLIB_MulRnd_A32_Asmi.h MLIB_MulRnd_F16.h MLIB_MulRnd_F16_Asmi.h MLIB_MulRnd_F32.h MLIB_MulRnd_F32_Asmi.h MLIB_Neg_F16.h MLIB_Neg_F16_Asmi.h MLIB_Neg_F32.h MLIB_Neg_F32_Asmi.h MLIB_Neg_FLT.h MLIB_Rcp_A32.h MLIB_Rcp1Q_A32.h MLIB_Rnd_F32.h MLIB_Rnd_F32_Asmi.h MLIB_Sat_A32_Asmi.h MLIB_Shift_F16.h MLIB_Shift_F16_Asmi.h MLIB_Shift_F32.h MLIB_Shift_F32_Asmi.h MLIB_Sign_F16_Asmi.h MLIB_Sign_F32_Asmi.h MLIB_Sign_FLT_Asmi.h MLIB_Sub_A32.h MLIB_Sub_F16.h MLIB_Sub_F16_Asmi.h MLIB_Sub_F32.h MLIB_Sub_F32_Asmi.h MLIB_Sub_F64.h MLIB_Sub_FLT.h MLIB_Sub4_F16_Asmi.h MLIB_Sub4_F32_Asmi.h MLIB_Sub4_FLT.h mlib_types.h RTCESL_cfg.h
  group startup
    ../../../../../devices/MKV58F24/: system_MKV58F24.c system_MKV58F24.h
    ../../../../../devices/MKV58F24/arm/: startup_MKV58F24.s
  group utilities
    ../../../../../devices/MKV58F24/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MKV58F24/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MKV58F24/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MKV58F24/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group mc_algorithms
    ../../../../../middleware/motor_control/pmsm/mc_algorithms/: pmsm_control.c pmsm_control.h
  group mc_state_machine
    ../../../../../middleware/motor_control/pmsm/mc_state_machine/: m1_sm_demo.c m1_sm_demo.h
  group state_machine
    ../../../../../middleware/motor_control/pmsm/state_machine/: state_machine.c state_machine.h
  group freemaster
    ../../../../../middleware/motor_control/freemaster/freemaster_drv/: freemaster_tsa.h freemaster_tsa.c freemaster_sfio.c freemaster_serial.c freemaster_scope.c freemaster_rec.h freemaster_rec.c freemaster_protocol.h freemaster_protocol.c freemaster_private.h freemaster_pipes.c freemaster_lin.c freemaster_defcfg.h freemaster_can.c freemaster_bdm.c freemaster_appcmd.c freemaster_Kxx.h freemaster_Kxx.c freemaster.h
target mc_pmsm release (ARM-ADS)
  device: MKV58F1M0VLQ24 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.3.0
  cpu: CPUTYPE("Cortex-M7") FPU2
  output: mc_pmsm.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKV58F1M0VLQ24, ARM_MATH_CM4, TWR_KV58F220M, TOWER
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: MKV58F1M0xxx24_flash.scf
  link misc: as above
