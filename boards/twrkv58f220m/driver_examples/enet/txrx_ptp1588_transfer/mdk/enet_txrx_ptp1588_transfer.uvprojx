# Keil uVision project enet_txrx_ptp1588_transfer.uvprojx, settings and files
target enet_txrx_ptp1588_transfer debug (ARM-ADS)
  device: MKV58F1M0VLQ24 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: enet_txrx_ptp1588_transfer.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_MKV58F1M0VLQ24, ENET_ENHANCEDBUFFERDESCRIPTOR_MODE=1, PRINTF_ADVANCED_ENABLE=1, TWR_KV58F220M, TOWER, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../..;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../components/phy/mdio/enet;../../../../../../components/phy/device/phyksz8041;../../../../../../devices/MKV58F24/drivers;../../../../../../devices/MKV58F24;../../../../../../devices/MKV58F24/utilities/str;../../../../../../devices/MKV58F24/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../components/phy;../../../../../../devices/MKV58F24/utilities
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: MKV58F1M0xxx24_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --predefine="-D__stack_size__=0x1000" --predefine="-D__heap_size__=0x1000" --predefine="-D__ram_vector_table__=1"
  group source
    ../: enet_txrx_ptp1588_transfer.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group mdio
    ../../../../../../components/phy/mdio/enet/: fsl_enet_mdio.c fsl_enet_mdio.h
    ../../../../../../components/phy/: fsl_mdio.h
  group phy
    ../../../../../../components/phy/device/phyksz8041/: fsl_phyksz8041.c fsl_phyksz8041.h
    ../../../../../../components/phy/: fsl_phy.h
  group drivers
    ../../../../../../devices/MKV58F24/drivers/: fsl_port.h fsl_gpio.c fsl_gpio.h fsl_sysmpu.c fsl_sysmpu.h fsl_sim.c fsl_sim.h fsl_clock.c fsl_clock.h fsl_enet.c fsl_enet.h fsl_common.c fsl_common.h fsl_uart.c fsl_uart.h fsl_smc.c fsl_smc.h
  group device
    ../../../../../../devices/MKV58F24/: MKV58F24.h MKV58F24_features.h fsl_device_registers.h system_MKV58F24.c system_MKV58F24.h
  group utilities
    ../../../../../../devices/MKV58F24/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MKV58F24/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MKV58F24/utilities/: fsl_assert.c
  group component-uart
    ../../../../../../components/uart/: uart.h uart_adapter.c
  group component-serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../../devices/MKV58F24/arm/: startup_MKV58F24.S
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
target enet_txrx_ptp1588_transfer release (ARM-ADS)
  device: MKV58F1M0VLQ24 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: enet_txrx_ptp1588_transfer.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_MKV58F1M0VLQ24, ENET_ENHANCEDBUFFERDESCRIPTOR_MODE=1, PRINTF_ADVANCED_ENABLE=1, TWR_KV58F220M, TOWER, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: MKV58F1M0xxx24_flash.scf
  link misc: as above
