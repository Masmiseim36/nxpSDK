# Keil uVision project fmstr_example_can.uvprojx, settings and files
target fmstr_example_can debug (ARM-ADS)
  device: MKV58F1M0VLQ24 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: fmstr_example_can.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_MKV58F1M0VLQ24, TWR_KV58F220M, TOWER, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../common/fmstr_example;..;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../devices/MKV58F24/drivers;../../../../../middleware/freemaster/src/common;../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial;../../../../../middleware/freemaster/src/drivers/mcuxsdk/can;../../../../../devices/MKV58F24;../../../../../devices/MKV58F24/utilities/str;../../../../../devices/MKV58F24/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../middleware/freemaster/src/platforms/gen32le;../../../../../devices/MKV58F24/utilities
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: MKV58F1M0xxx24_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
  group source
    ../: main.c freemaster_cfg.h
    ../../common/fmstr_example/: freemaster_example.c freemaster_example.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source/example_data
    ../../common/fmstr_example/: data_example_pmp.h data_img_logo.h data_img_file.h data_img_fmstrlogo.h data_html_index.h example_data.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKV58F24/drivers/: fsl_sim.c fsl_sim.h fsl_flexcan.c fsl_flexcan.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_uart.c fsl_uart.h fsl_port.h fsl_smc.c fsl_smc.h fsl_gpio.c fsl_gpio.h
  group freemaster
    ../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_can.c freemaster_can.h freemaster_defcfg.h freemaster_pdbdm.c freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_serial.c freemaster_serial.h freemaster_sha.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h
  group freemaster/drivers/mcuxsdk/can
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mcan.c freemaster_mcan.h freemaster_mscan.c freemaster_mscan.h
  group freemaster/drivers/mcuxsdk/serial
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_usb.c freemaster_serial_usb.h
  group device
    ../../../../../devices/MKV58F24/: MKV58F24.h MKV58F24_features.h fsl_device_registers.h system_MKV58F24.c system_MKV58F24.h
  group utilities
    ../../../../../devices/MKV58F24/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MKV58F24/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MKV58F24/utilities/: fsl_assert.c
  group component-uart
    ../../../../../components/uart/: uart.h uart_adapter.c
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MKV58F24/arm/: startup_MKV58F24.S
  group freemaster/platforms
    ../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
target fmstr_example_can release (ARM-ADS)
  device: MKV58F1M0VLQ24 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: fmstr_example_can.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_MKV58F1M0VLQ24, TWR_KV58F220M, TOWER, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: MKV58F1M0xxx24_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
