# Keil uVision project lwip_httpssrv_mbedTLS_bm.uvprojx, settings and files
target lwip_httpssrv_mbedTLS_bm debug (ARM-ADS)
  device: MKV58F1M0VLQ24 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: lwip_httpssrv_mbedTLS_bm.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_MKV58F1M0VLQ24, PRINTF_ADVANCED_ENABLE=1, MBEDTLS_CONFIG_FILE='\"ksdk_mbedtls_config.h\"', TWR_KV58F220M, TOWER, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../..;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../middleware/mmcau;../../../../../../middleware/mbedtls/include;../../../../../../middleware/mbedtls/port/ksdk;../../../../../../components/phy/mdio/enet;../../../../../../components/phy/device/phyksz8041;../../../../../../devices/MKV58F24/drivers;../../../../../../middleware/lwip/port;../../../../../../middleware/lwip/src;../../../../../../middleware/lwip/src/include;../../../../../../devices/MKV58F24/utilities/str;../../../../../../devices/MKV58F24/utilities/debug_console;../../../../../../devices/MKV58F24;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../components/phy;../../../../../../devices/MKV58F24/utilities
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: MKV58F1M0xxx24_flash.scf
  link misc: ../../../../../../middleware/mmcau/asm-cm4-cm7/lib_mmcau.lib --remove --keep=*(.FlashConfig) --predefine="-D__stack_size__=1000" --predefine="-D__heap_size__=40000"
  group lwip_httpd_mbedtls
    ../: httpd_mbedtls.c httpd_mbedtls.h
  group source
    ../: lwip_httpssrv_mbedTLS_bm.c lwipopts.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group mdio
    ../../../../../../components/phy/mdio/enet/: fsl_enet_mdio.c fsl_enet_mdio.h
    ../../../../../../components/phy/: fsl_mdio.h
  group phy
    ../../../../../../components/phy/device/phyksz8041/: fsl_phyksz8041.c fsl_phyksz8041.h
    ../../../../../../components/phy/: fsl_phy.h
  group drivers
    ../../../../../../devices/MKV58F24/drivers/: fsl_trng.c fsl_trng.h fsl_port.h fsl_sim.c fsl_sim.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_uart.c fsl_uart.h fsl_smc.c fsl_smc.h fsl_gpio.c fsl_gpio.h fsl_enet.c fsl_enet.h
  group mmcau-mmcau_include
    ../../../../../../middleware/mmcau/: cau_api.h fsl_mmcau.h
  group mmcau-mmcau_source
    ../../../../../../middleware/mmcau/: fsl_mmcau.c
  group lwip-src-apps-http
    ../../../../../../middleware/lwip/src/apps/http/: fs.c fsdata.h httpd_structs.h
  group lwip-src-include-lwip-apps
    ../../../../../../middleware/lwip/src/include/lwip/apps/: fs.h httpd.h httpd_opts.h
  group lwip-port-arch
    ../../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip-port
    ../../../../../../middleware/lwip/port/: sys_arch.c enet_ethernetif.c enet_ethernetif.h enet_ethernetif_kinetis.c enet_ethernetif_priv.h
  group lwip-src-api
    ../../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-src-core
    ../../../../../../middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip-src-core-ipv4
    ../../../../../../middleware/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip-src-core-ipv6
    ../../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip-src-include-compat-posix-arpa
    ../../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip-src-include-compat-posix-net
    ../../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip-src-include-compat-posix
    ../../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip-src-include-compat-posix-sys
    ../../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip-src-include-compat-stdc
    ../../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip-src-include-lwip
    ../../../../../../middleware/lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip-src-include-lwip-priv
    ../../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group lwip-src-include-lwip-prot
    ../../../../../../middleware/lwip/src/include/lwip/prot/: acd.h autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip-src-include-netif
    ../../../../../../middleware/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lwip-src-include-netif-ppp
    ../../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip-src-include-netif-ppp-polarssl
    ../../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip-src-netif
    ../../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip-src-netif-ppp
    ../../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group utilities
    ../../../../../../devices/MKV58F24/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MKV58F24/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MKV58F24/utilities/: fsl_assert.c
  group mbedtls-include-mbedtls
    ../../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls-library
    ../../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls-port-ksdk
    ../../../../../../middleware/mbedtls/port/ksdk/: aes_alt.c aes_alt.h des_alt.c des_alt.h ecp_alt.c ecp_alt.h ecp_alt_ksdk.c ecp_curves_alt.c ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h
  group device
    ../../../../../../devices/MKV58F24/: MKV58F24.h MKV58F24_features.h fsl_device_registers.h system_MKV58F24.c system_MKV58F24.h
  group component-uart
    ../../../../../../components/uart/: uart.h uart_adapter.c
  group component-serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../../devices/MKV58F24/arm/: startup_MKV58F24.S
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
target lwip_httpssrv_mbedTLS_bm release (ARM-ADS)
  device: MKV58F1M0VLQ24 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.3.0
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: lwip_httpssrv_mbedTLS_bm.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_MKV58F1M0VLQ24, PRINTF_ADVANCED_ENABLE=1, MBEDTLS_CONFIG_FILE='\"ksdk_mbedtls_config.h\"', TWR_KV58F220M, TOWER, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: MKV58F1M0xxx24_flash.scf
  link misc: as above
