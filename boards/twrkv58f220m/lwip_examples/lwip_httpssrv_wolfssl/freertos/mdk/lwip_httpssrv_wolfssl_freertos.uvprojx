# Keil uVision project lwip_httpssrv_wolfssl_freertos.uvprojx, settings and files
target lwip_httpssrv_wolfssl_freertos debug (ARM-ADS)
  device: MKV58F1M0VLQ24 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.3.0
  cpu: CPUTYPE("Cortex-M7") FPU2
  output: lwip_httpssrv_wolfssl_freertos.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKV58F1M0VLQ24, TWR_KV58F220M, TOWER, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, FSL_RTOS_FREE_RTOS, HTTPSRV_CFG_WOLFSSL_ENABLE=1, HTTPSRV_CFG_WEBSOCKET_ENABLED=1
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186 
--diag_suppress=177,1293
  c include: ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F;../../../../../../platform/components/phyksz8041;../../../../../../CMSIS/Include;../../../../../../devices;..;../../../../../../middleware/lwip/src/apps/httpsrv;../../../..;../../../../../../middleware/mmcau;../../../../../../middleware/wolfssl;../../../../../../middleware/wolfssl/wolfssl/wolfcrypt/port;../../../../../../rtos/amazon-freertos/lib/include;../../../../../../rtos/amazon-freertos/lib/include/private;../../../../../../devices/MKV58F24/drivers;../../../../../../devices/MKV58F24;../../../../../../devices/MKV58F24/utilities/io;../../../../../../devices/MKV58F24/utilities/str;../../../../../../devices/MKV58F24/utilities/log;../../../../../../devices/MKV58F24/utilities;../../../../../../middleware/lwip/port;../../../../../../middleware/lwip/src;../../../../../../middleware/lwip/src/include;../../../../../../middleware/lwip/contrib/apps
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: MKV58F1M0xxx24_flash.scf
  link misc: ../../../../../../middleware/mmcau/asm-cm4-cm7/lib_mmcau.lib 
--remove
  group source
    ../: lwip_httpssrv_wolfssl_freertos.c lwipopts.h user_settings.h certs_buff.h FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h fsl_phy.h fsl_phy.c
  group board-src
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MKV58F24/drivers/: fsl_trng.c fsl_trng.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_uart.h fsl_uart.c fsl_port.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c fsl_sim.h fsl_sim.c fsl_enet.h fsl_enet.c
  group mmcau-mmcau_include
    ../../../../../../middleware/mmcau/: cau_api.h fsl_mmcau.h
  group mmcau-mmcau_source
    ../../../../../../middleware/mmcau/: fsl_mmcau.c
  group startup
    ../../../../../../devices/MKV58F24/: system_MKV58F24.c system_MKV58F24.h
    ../../../../../../devices/MKV58F24/arm/: startup_MKV58F24.s
  group utilities
    ../../../../../../devices/MKV58F24/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../devices/MKV58F24/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../devices/MKV58F24/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MKV58F24/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group wolfssl-wolfssl_include
    ../../../../../../middleware/wolfssl/wolfssl/: callbacks.h certs_test.h crl.h error-ssl.h internal.h ocsp.h options.h sniffer.h sniffer_error.h ssl.h test.h version.h
    ../../../../../../middleware/wolfssl/wolfssl/openssl/: ec.h ssl.h bn.h
    ../../../../../../middleware/wolfssl/wolfssl/wolfcrypt/: aes.h arc4.h asn.h asn_public.h blake2.h blake2-impl.h blake2-int.h camellia.h cmac.h chacha.h chacha20_poly1305.h coding.h compress.h curve25519.h des3.h dh.h dsa.h ecc.h ed25519.h error-crypt.h fe_operations.h fips_test.h ge_operations.h hash.h hc128.h hmac.h integer.h idea.h logging.h md2.h md4.h md5.h mem_track.h memory.h misc.h mpi_class.h mpi_superclass.h pkcs7.h poly1305.h pwdbased.h rabbit.h random.h ripemd.h rsa.h settings.h sha.h sha256.h sha512.h signature.h srp.h tfm.h types.h visibility.h wc_encrypt.h wc_port.h
  group wolfssl-wolfssl_source
    ../../../../../../middleware/wolfssl/wolfcrypt/src/: aes.c arc4.c asm.c asn.c blake2b.c camellia.c cmac.c chacha.c chacha20_poly1305.c coding.c compress.c curve25519.c des3.c dh.c dsa.c ecc.c ecc_fp.c ed25519.c error.c fe_low_mem.c fe_operations.c ge_low_mem.c ge_operations.c hash.c hc128.c hmac.c integer.c idea.c logging.c md2.c md4.c md5.c memory.c misc.c pkcs7.c poly1305.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha512.c signature.c srp.c tfm.c wc_encrypt.c wc_port.c
    ../../../../../../middleware/wolfssl/src/: async.c crl.c internal.c io.c keys.c ocsp.c sniffer.c ssl.c tls.c
  group wolfssl-wolfssl_port
    ../../../../../../middleware/wolfssl/wolfcrypt/src/port/nxp/: ksdk_port.c
    ../../../../../../middleware/wolfssl/wolfssl/wolfcrypt/port/nxp/: ksdk_port.h
  group lwip-src-apps-httpsrv
    ../../../../../../middleware/lwip/src/apps/httpsrv/: httpsrv.c httpsrv.h httpsrv_base64.c httpsrv_base64.h httpsrv_config.h httpsrv_fs.c httpsrv_fs.h httpsrv_fs_data.c httpsrv_port.h httpsrv_prv.h httpsrv_script.c httpsrv_script.h httpsrv_sha1.c httpsrv_sha1.h httpsrv_supp.c httpsrv_supp.h httpsrv_task.c httpsrv_tls.c httpsrv_tls.h httpsrv_utf8.c httpsrv_utf8.h httpsrv_ws.c httpsrv_ws.h httpsrv_ws_api.c httpsrv_ws_prv.h
  group lwip-port
    ../../../../../../middleware/lwip/port/: ethernetif.c ethernetif.h sys_arch.c
  group lwip-port-arch
    ../../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip-src-api
    ../../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-src-core
    ../../../../../../middleware/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip-src-core-ipv4
    ../../../../../../middleware/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip-src-core-ipv6
    ../../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip-src-include-lwip
    ../../../../../../middleware/lwip/src/include/lwip/: api.h arch.h debug.h dhcp.h dns.h errno.h ethip6.h icmp6.h inet.h init.h ip_addr.h ip4_addr.h ip6.h ip6_frag.h memp.h nd6.h netdb.h netifapi.h pbuf.h sio.h sockets.h sys.h tcpip.h udp.h autoip.h def.h dhcp6.h err.h etharp.h icmp.h igmp.h inet_chksum.h ip.h ip4.h ip4_frag.h ip6_addr.h mem.h mld6.h netbuf.h netif.h opt.h raw.h snmp.h stats.h tcp.h timeouts.h
  group lwip-src-include-lwip-priv
    ../../../../../../middleware/lwip/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h nd6_priv.h tcp_priv.h tcpip_priv.h
  group lwip-src-include-lwip-prot
    ../../../../../../middleware/lwip/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h ethernet.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip-src-include-netif
    ../../../../../../middleware/lwip/src/include/netif/: etharp.h ethernet.h lowpan6.h lowpan6_opts.h slipif.h
  group lwip-src-include-netif-ppp
    ../../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap_ms.h chap-md5.h chap-new.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip-src-include-netif-ppp-polarssl
    ../../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip-src-include-posix
    ../../../../../../middleware/lwip/src/include/posix/: errno.h netdb.h
  group lwip-src-include-posix-sys
    ../../../../../../middleware/lwip/src/include/posix/sys/: socket.h
  group lwip-src-netif
    ../../../../../../middleware/lwip/src/netif/: ethernet.c lowpan6.c slipif.c
  group lwip-src-netif-ppp
    ../../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group amazon-freertos-FreeRTOS-portable
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_3.c
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
  group amazon-freertos-license
    ../../../../../../rtos/amazon-freertos/: LICENSE
  group amazon-freertos-include
    ../../../../../../rtos/amazon-freertos/lib/include/: event_groups.h FreeRTOS.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
    ../../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_wrappers.h portable.h projdefs.h stack_macros.h
  group amazon-freertos-FreeRTOS
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos-portable
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F/: fsl_tickless_systick.c fsl_tickless_generic.h
target lwip_httpssrv_wolfssl_freertos release (ARM-ADS)
  device: MKV58F1M0VLQ24 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.3.0
  cpu: CPUTYPE("Cortex-M7") FPU2
  output: lwip_httpssrv_wolfssl_freertos.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKV58F1M0VLQ24, TWR_KV58F220M, TOWER, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, FSL_RTOS_FREE_RTOS, HTTPSRV_CFG_WOLFSSL_ENABLE=1, HTTPSRV_CFG_WEBSOCKET_ENABLED=1
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: MKV58F1M0xxx24_flash.scf
  link misc: as above
