# Keil uVision project cmsis_dspi_edma_b2b_transfer_master.uvprojx, settings and files
target cmsis_dspi_edma_b2b_transfer_master Debug (ARM-ADS)
  device: MKW24D512xxx5 Freescale
  cpu: CPUTYPE("Cortex-M4")
  output: cmsis_dspi_edma_b2b_transfer_master.out +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: DEBUG, CPU_MKW24D512VHA5, TWR_KW24D512, TOWER
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..;../../../../../../../CMSIS/Driver/Include;../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../..;../../../../../../../devices/MKW24D5/drivers;../../../../../../../devices/MKW24D5/cmsis_drivers;../../../../../../../devices/MKW24D5/utilities;../../../../../../../devices/MKW24D5
  asm define: CPU_MK64FN1M0VMD12, DEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: MKW24D512xxx5_flash.scf
  link misc: --remove
  group startup
    ../../../../../../../devices/MKW24D5/arm/: startup_MKW24D5.s
    ../../../../../../../devices/MKW24D5/: system_MKW24D5.c system_MKW24D5.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MKW24D5/drivers/: fsl_port.h fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_dspi.h fsl_dspi.c fsl_dspi_edma.h fsl_dspi_edma.c fsl_common.h fsl_common.c fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
    ../../../../../../../devices/MKW24D5/cmsis_drivers/: fsl_dspi_cmsis.h fsl_dspi_cmsis.c
  group source
    ../: cmsis_dspi_edma_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../../devices/MKW24D5/utilities/: fsl_debug_console.c fsl_debug_console.h
target cmsis_dspi_edma_b2b_transfer_master Release (ARM-ADS)
  device: MKW24D512xxx5 Freescale
  cpu: CPUTYPE("Cortex-M4")
  output: cmsis_dspi_edma_b2b_transfer_master.out +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: NDEBUG, CPU_MKW24D512VHA5, TWR_KW24D512, TOWER
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: MKW24D512xxx5_flash.scf
  link misc: --remove
