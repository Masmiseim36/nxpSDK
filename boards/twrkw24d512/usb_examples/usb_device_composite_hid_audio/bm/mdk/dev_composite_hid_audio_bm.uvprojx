# Keil uVision project dev_composite_hid_audio_bm.uvprojx, settings and files
target dev_composite_hid_audio_bm Debug (ARM-ADS)
  device: MKW24D512xxx5 Freescale
  cpu: CPUTYPE("Cortex-M4")
  output: dev_composite_hid_audio_bm.out +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: _DEBUG=1, CPU_MKW24D512VHA5, USB_STACK_BM, TWR_KW24D512, TOWER
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../platform/drivers;..;../../../../../../middleware/usb_1.6.3;../../../../../../middleware/usb_1.6.3/osa;../../../../../../middleware/usb_1.6.3/include;../../../../../../middleware/usb_1.6.3/device;../../../..;../../../../../../devices/MKW24D5/drivers;../../../../../../devices/MKW24D5/utilities;../../../../../../devices/MKW24D5
  asm define: CPU_MK64FN1M0VMD12, DEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: MKW24D512xxx5_flash.scf
  link misc: --remove
  group startup
    ../../../../../../devices/MKW24D5/arm/: startup_MKW24D5.s
    ../../../../../../devices/MKW24D5/: system_MKW24D5.c system_MKW24D5.h
  group usb-device-source-khci
    ../../../../../../middleware/usb_1.6.3/device/: usb_device_khci.c usb_device_khci.h
    ../../../../../../middleware/usb_1.6.3/include/: usb_khci.h
  group drivers
    ../../../../../../devices/MKW24D5/drivers/: fsl_uart.h fsl_uart.c fsl_port.h fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group osa
    ../../../../../../middleware/usb_1.6.3/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group usb-device-source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb_1.6.3/device/: usb_device_dci.c usb_device_dci.h
  group usb-device-class
    ../: usb_device_class.c usb_device_class.h
  group usb-device-class-audio
    ../: usb_device_audio.c usb_device_audio.h
  group usb-device-class-hid
    ../: usb_device_hid.c usb_device_hid.h
  group sources
    ../: audio_data.c audio_generator.c audio_generator.h composite.c composite.h mouse.c mouse.h usb_device_descriptor.c usb_device_descriptor.h usb_device_config.h usb_audio_config.h
  group utilities
    ../../../../../../devices/MKW24D5/utilities/: fsl_debug_console.c fsl_debug_console.h
  group usb-include
    ../../../../../../middleware/usb_1.6.3/include/: usb.h usb_misc.h usb_spec.h
  group usb-device-include
    ../../../../../../middleware/usb_1.6.3/device/: usb_device.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
target dev_composite_hid_audio_bm Release (ARM-ADS)
  device: MKW24D512xxx5 Freescale
  cpu: CPUTYPE("Cortex-M4")
  output: dev_composite_hid_audio_bm.out +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: _DEBUG=0, CPU_MKW24D512VHA5, USB_STACK_BM, TWR_KW24D512, TOWER
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: MKW24D512xxx5_flash.scf
  link misc: --remove
