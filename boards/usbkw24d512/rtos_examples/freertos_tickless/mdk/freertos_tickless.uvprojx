# Keil uVision project freertos_tickless.uvprojx, settings and files
target freertos_tickless Debug (ARM-ADS)
  device: MKW24D512xxx5 Freescale
  cpu: CPUTYPE("Cortex-M4")
  output: freertos_tickless.out +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: _DEBUG=1, CPU_MKW24D512VHA5, USB_STACK_BM, BOARD_USE_VIRTUALCOM, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../rtos/freertos_9.0.0/Source/portable/RVDS/ARM_CM3;../../../../../rtos/freertos_9.0.0/Source/include;../../../../../CMSIS/Include;../../../../../devices;../../../../../platform/utilities/virtual_com;..;../../..;../../../../../middleware/usb_1.6.3;../../../../../middleware/usb_1.6.3/osa;../../../../../middleware/usb_1.6.3/include;../../../../../middleware/usb_1.6.3/device;../../../../../rtos/freertos_9.0.0/Source;../../../../../devices/MKW24D5/drivers;../../../../../devices/MKW24D5/utilities;../../../../../devices/MKW24D5
  asm define: CPU_MK64FN1M0VMD12, DEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER, DEBUG
  asm include: ..;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: MKW24D512xxx5_flash.scf
  link misc: --remove
  group startup
    ../../../../../devices/MKW24D5/arm/: startup_MKW24D5.s
    ../../../../../devices/MKW24D5/: system_MKW24D5.c system_MKW24D5.h
  group freertos:portable
    ../../../../../rtos/freertos_9.0.0/Source/portable/RVDS/ARM_CM3/: port.c fsl_tickless_systick.c fsl_tickless_generic.h fsl_tickless_lptmr.c portmacro.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKW24D5/drivers/: fsl_uart.h fsl_uart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_lptmr.c fsl_lptmr.h fsl_common.h fsl_common.c fsl_sim.h fsl_sim.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group osa
    ../../../../../middleware/usb_1.6.3/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group usb-device-source-khci
    ../../../../../middleware/usb_1.6.3/device/: usb_device_khci.c usb_device_khci.h
    ../../../../../middleware/usb_1.6.3/include/: usb_khci.h
  group freertos
    ../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
    ../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
    ../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group source
    ../: FreeRTOSConfig.h freertos_tickless.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MKW24D5/utilities/: virtual_com.c virtual_com.h usb_device_descriptor.c usb_device_descriptor.h usb_device_cdc_acm.c usb_device_cdc_acm.h usb_device_ch9.c usb_device_ch9.h usb_device_config.h fsl_debug_console.c fsl_debug_console.h
  group usb-include
    ../../../../../middleware/usb_1.6.3/include/: usb.h usb_misc.h usb_spec.h
  group usb-device-include
    ../../../../../middleware/usb_1.6.3/device/: usb_device.h
  group usb-device-source
    ../../../../../middleware/usb_1.6.3/device/: usb_device_dci.c usb_device_dci.h
target freertos_tickless Release (ARM-ADS)
  device: MKW24D512xxx5 Freescale
  cpu: CPUTYPE("Cortex-M4")
  output: freertos_tickless.out +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: _DEBUG=0, CPU_MKW24D512VHA5, USB_STACK_BM, BOARD_USE_VIRTUALCOM, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm include: ..;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: MKW24D512xxx5_flash.scf
  link misc: --remove
