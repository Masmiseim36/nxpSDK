# IAR project dspi_edma_b2b_transfer_master.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW37Z512xxx4 NXP MKW37Z512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKW37Z512VFT4; usbKW38
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../..; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../platform/drivers; ../../../../../../../devices/MKW37Z4/drivers; ../../../../../../../devices/MKW37Z4/drivers; ../../../../../../../devices/MKW37Z4/drivers; ../../../../../../../devices/MKW37Z4/drivers; ../../../../../../../devices/MKW37Z4/drivers; ../../../../../../../devices/MKW37Z4/drivers; ../../../../../../../devices/MKW37Z4/drivers; ../../../../../../../devices/MKW37Z4; ../../../../../../../devices/MKW37Z4/utilities/str; ../../../../../../../devices/MKW37Z4/utilities/debug_console; ../../../../../../../components/uart; ../../../../../../../components/serial_manager; ../../../../../../../components/serial_manager; ../../../../../../../devices/MKW37Z4/drivers; ../../../../../../../components/lists; ../../../../../../../devices/MKW37Z4/drivers; ../../../../../../../devices/MKW37Z4/drivers; ../../../../../../../devices/MKW37Z4/drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: dspi_edma_b2b_transfer_master.out
  ILINK.IlinkIcfFile: MKW37Z512xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW37Z512VFT4; usbKW38
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: dspi_edma_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MKW37Z4/drivers/: fsl_port.h fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_edma.c fsl_edma.h fsl_dmamux.c fsl_dmamux.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_lptmr.c fsl_lptmr.h fsl_smc.c fsl_smc.h fsl_gpio.c fsl_gpio.h
  group device
    ../../../../../../../devices/MKW37Z4/: MKW37Z4.h MKW37Z4_features.h fsl_device_registers.h system_MKW37Z4.c system_MKW37Z4.h
  group utilities
    ../../../../../../../devices/MKW37Z4/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/MKW37Z4/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MKW37Z4/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../../components/uart/: lpuart_adapter.c uart.h
  group component/serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../../../devices/MKW37Z4/iar/: startup_MKW37Z4.s
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm0plus.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h
