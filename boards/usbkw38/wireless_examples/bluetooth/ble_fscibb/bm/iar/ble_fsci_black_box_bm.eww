<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>ble_fsci_black_box_bm</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>ble_fsci_black_box_bm</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>ble_fsci_black_box_bm</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>ble_fsci_black_box_bm</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/ble_fsci_black_box_bm.ewp</path>
  </project>
</workspace>
