# IAR project hello_world.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 NXP MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; CPU_MK22FN512VLH12; USB_STACK_BM; BOARD_USE_VIRTUALCOM; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; USB_KW41ZK22F; DONGLE
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../platform/utilities/virtual_com; ..; ../../../../../middleware/usb_1.6.3; ../../../../../middleware/usb_1.6.3/osa; ../../../../../middleware/usb_1.6.3/include; ../../../../../middleware/usb_1.6.3/device; ../../..; ../../../../../devices/MK22F51212/drivers; ../../../../../devices/MK22F51212/utilities; ../../../../../devices/MK22F51212
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: MK22FN512xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK22FN512VLH12; USB_STACK_BM; BOARD_USE_VIRTUALCOM; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; USB_KW41ZK22F; DONGLE
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../devices/MK22F51212/iar/: startup_MK22F51212.s
    ../../../../../devices/MK22F51212/: system_MK22F51212.c system_MK22F51212.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK22F51212/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_common.h fsl_common.c fsl_uart.h fsl_uart.c fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group osa
    ../../../../../middleware/usb_1.6.3/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group usb/device/source
    ../../../../../middleware/usb_1.6.3/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/khci
    ../../../../../middleware/usb_1.6.3/device/: usb_device_khci.c usb_device_khci.h
    ../../../../../middleware/usb_1.6.3/include/: usb_khci.h
  group usb/device/include
    ../../../../../middleware/usb_1.6.3/device/: usb_device.h
  group usb/include
    ../../../../../middleware/usb_1.6.3/include/: usb.h usb_misc.h usb_spec.h
  group board
    ../: board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MK22F51212/utilities/: virtual_com.c virtual_com.h usb_device_descriptor.c usb_device_descriptor.h usb_device_cdc_acm.c usb_device_cdc_acm.h usb_device_ch9.c usb_device_ch9.h usb_device_config.h fsl_debug_console.c fsl_debug_console.h
  group source
    ../: hello_world.c
