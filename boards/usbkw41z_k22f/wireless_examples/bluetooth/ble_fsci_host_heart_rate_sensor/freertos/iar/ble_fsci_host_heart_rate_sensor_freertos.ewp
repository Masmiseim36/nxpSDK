# IAR project ble_fsci_host_heart_rate_sensor_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 NXP MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; CPU_MK22FN512VLH12; FSL_RTOS_FREE_RTOS; USB_KW41_K22; SDK_DEBUGCONSOLE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.PreInclude: ../../../../../../../boards/usbkw41z_k22f/wireless_examples/bluetooth/ble_fsci_host_heart_rate_sensor/freertos/app_preinclude.h
  ICCARM.CCIncludePath2: ../../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F; ../../../../../../../rtos/freertos_9.0.0/Source/include; ..; ../../../../../../../rtos/freertos_9.0.0/Source; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../middleware/usb_1.6.3; ../../../../../../../middleware/usb_1.6.3/osa; ../../../../../../../middleware/usb_1.6.3/include; ../../../../../../../middleware/usb_1.6.3/device; ../../../../../../../middleware/wireless/framework_5.3.6/OSAbstraction/Interface; ../../../../../../../middleware/wireless/framework_5.3.6/Flash/Internal; ../../../../../../../middleware/wireless/framework_5.3.6/GPIO; ../../../../../../../middleware/wireless/framework_5.3.6/Keyboard/Interface; ../../../../../../../middleware/wireless/framework_5.3.6/LED/Interface; ../../../../../../../middleware/wireless/framework_5.3.6/SerialManager/Source/SPI_Adapter; ../../../../../../../middleware/wireless/framework_5.3.6/Common; ../../../../../../../middleware/wireless/framework_5.3.6/MemManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.6/FSCI/Interface; ../../../../../../../middleware/wireless/framework_5.3.6/FSCI/Source; ../../../../../../../middleware/wireless/framework_5.3.6/Messaging/Interface; ../../../../../../../middleware/wireless/framework_5.3.6/Panic/Interface; ../../../../../../../middleware/wireless/framework_5.3.6/RNG/Interface; ../../../../../../../middleware/wireless/framework_5.3.6/SerialManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.6/SerialManager/Source; ../../../../../../../middleware/wireless/framework_5.3.6/TimersManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.6/TimersManager/Source; ../../../../../../../middleware/wireless/framework_5.3.6/ModuleInfo; ../../../../../../../middleware/wireless/framework_5.3.6/FunctionLib; ../../../../../../../middleware/wireless/framework_5.3.6/Lists; ../../../../../../../middleware/wireless/framework_5.3.6/SecLib; ../../../../../../../middleware/wireless/bluetooth_1.2.6/host/interface; ../../../../../../../middleware/wireless/bluetooth_1.2.6/host/config; ../../../../../../../middleware/wireless/bluetooth_1.2.6/application/common/fsci_host/host; ../../../../../../../middleware/wireless/bluetooth_1.2.6/application/common/fsci_host/fsci; ../../../../../../../middleware/wireless/bluetooth_1.2.6/application/common; ../../../../../../../middleware/wireless/bluetooth_1.2.6/application/common/gatt_db; ../../../../../../../middleware/wireless/bluetooth_1.2.6/profiles/battery; ../../../../../../../middleware/wireless/bluetooth_1.2.6/profiles/device_info; ../../../../../../../middleware/wireless/bluetooth_1.2.6/profiles/heart_rate; ../../../../../../../middleware/wireless/framework_5.3.6/MWSCoexistence/Interface; ../..; ../../../../../../../devices/MK22F51212/drivers; ../../../../../../../middleware/wireless/framework_5.3.6/SerialManager/Source/USB_VirtualCom; ../../../../../../../devices/MK22F51212; ../../../../../../../devices/MK22F51212/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: ble_fsci_host_heart_rate_sensor_usbkw41z_k22f.bin
  ILINK.IlinkOutputFile: ble_fsci_host_heart_rate_sensor_freertos.out
  ILINK.IlinkIcfFile: MK22FN512xxx12_connectivity.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../middleware/wireless/framework_5.3.6/SecLib/lib_crypto_m4.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK22FN512VLH12; FSL_RTOS_FREE_RTOS; USB_KW41_K22; SDK_DEBUGCONSOLE=1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group freertos
    ../../../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
    ../../../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
    ../../../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group freertos/portable
    ../../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F/: port.c fsl_tickless_systick.c fsl_tickless_generic.h portasm.s portmacro.h
  group startup
    ../../../../../../../devices/MK22F51212/iar/: startup_MK22F51212.s
    ../../../../../../../devices/MK22F51212/: system_MK22F51212.c system_MK22F51212.h
  group osa
    ../../../../../../../middleware/usb_1.6.3/osa/: usb_osa.h usb_osa_freertos.h usb_osa_freertos.c
  group framework/OSAbstraction
    ../../../../../../../middleware/wireless/framework_5.3.6/OSAbstraction/Interface/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h
    ../../../../../../../middleware/wireless/framework_5.3.6/OSAbstraction/Source/: fsl_os_abstraction_free_rtos.c
  group framework/OSAbstraction/Interface
    ../../../../../../../middleware/wireless/framework_5.3.6/OSAbstraction/Interface/: fsl_os_abstraction.h fsl_os_abstraction_config.h
  group framework/Flash/Internal
    ../../../../../../../middleware/wireless/framework_5.3.6/Flash/Internal/: Flash_Adapter.h Flash_Adapter.c
  group framework/GPIO/Interface
    ../../../../../../../middleware/wireless/framework_5.3.6/GPIO/: GPIO_Adapter.h
  group framework/GPIO/Source
    ../../../../../../../middleware/wireless/framework_5.3.6/GPIO/: GPIO_Adapter.c
  group framework/Keyboard/Interface
    ../../../../../../../middleware/wireless/framework_5.3.6/Keyboard/Interface/: Keyboard.h
  group framework/Keyboard/Source
    ../../../../../../../middleware/wireless/framework_5.3.6/Keyboard/Source/: Keyboard.c
  group framework/LED/Interface
    ../../../../../../../middleware/wireless/framework_5.3.6/LED/Interface/: LED.h
  group framework/LED/Source
    ../../../../../../../middleware/wireless/framework_5.3.6/LED/Source/: LED.c
  group framework/Reset/Source
    ../../../../../../../middleware/wireless/framework_5.3.6/Reset/: Reset.c
  group framework/SerialManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.6/SerialManager/Source/: SerialManager.c UART_Adapter.h UART_Adapter.c I2C_Adapter.h I2C_Adapter.c
  group framework/SerialManager/Source/SPI_Adapter
    ../../../../../../../middleware/wireless/framework_5.3.6/SerialManager/Source/SPI_Adapter/: SPI_Adapter.h SPI_Adapter.c
  group framework/SerialManager/Source/USB_VirtualCom/Interface
    ../../../../../../../middleware/wireless/framework_5.3.6/SerialManager/Source/USB_VirtualCom/: VirtualComInterface.h
  group framework/SerialManager/Source/USB_VirtualCom/Source
    ../../../../../../../middleware/wireless/framework_5.3.6/SerialManager/Source/USB_VirtualCom/: usb_device_cdc_acm.h usb_device_cdc_acm.c usb_device_ch9.h usb_device_ch9.c usb_device_class.h usb_device_class.c usb_device_config.h usb_device_descriptor.h usb_device_descriptor.c virtual_com.h virtual_com.c
  group framework/SerialManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.6/SerialManager/Interface/: SerialManager.h
  group framework/Common
    ../../../../../../../middleware/wireless/framework_5.3.6/Common/: EmbeddedTypes.h
  group framework/MemManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.6/MemManager/Interface/: MemManager.h
  group framework/MemManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.6/MemManager/Source/: MemManager.c
  group framework/FSCI/Interface
    ../../../../../../../middleware/wireless/framework_5.3.6/FSCI/Interface/: FsciInterface.h
  group framework/FSCI/Source
    ../../../../../../../middleware/wireless/framework_5.3.6/FSCI/Source/: FsciCommands.c FsciCommands.h FsciCommunication.c FsciCommunication.h FsciLogging.c FsciMain.c
  group framework/Messaging/Interface
    ../../../../../../../middleware/wireless/framework_5.3.6/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    ../../../../../../../middleware/wireless/framework_5.3.6/Messaging/Source/: Messaging.c
  group framework/Panic/Interface
    ../../../../../../../middleware/wireless/framework_5.3.6/Panic/Interface/: Panic.h
  group framework/Panic/Source
    ../../../../../../../middleware/wireless/framework_5.3.6/Panic/Source/: Panic.c
  group framework/RNG/Interface
    ../../../../../../../middleware/wireless/framework_5.3.6/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    ../../../../../../../middleware/wireless/framework_5.3.6/RNG/Source/: RNG.c
  group framework/TimersManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.6/TimersManager/Interface/: TimersManager.h
  group framework/TimersManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.6/TimersManager/Source/: TimersManager.c TimersManagerInternal.h TMR_Adapter.h TMR_Adapter.c
  group framework/ModuleInfo
    ../../../../../../../middleware/wireless/framework_5.3.6/ModuleInfo/: ModuleInfo.h ModuleInfo.c
  group framework/FunctionLib
    ../../../../../../../middleware/wireless/framework_5.3.6/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/Lists
    ../../../../../../../middleware/wireless/framework_5.3.6/Lists/: GenericList.c GenericList.h
  group framework/SecLib
    ../../../../../../../middleware/wireless/framework_5.3.6/SecLib/: SecLib.h SecLib.c
  group framework/MWSCoexistence/Interface
    ../../../../../../../middleware/wireless/framework_5.3.6/MWSCoexistence/Interface/: MWS.h
  group framework/MWSCoexistence/Source
    ../../../../../../../middleware/wireless/framework_5.3.6/MWSCoexistence/Source/: MWS.c
  group source
    ../: app_preinclude.h FreeRTOSConfig.h
    ../../: ble_fsci_host_heart_rate_sensor.c ble_fsci_host_heart_rate_sensor.h app_config.c
  group source/common
    ../../../../../../../middleware/wireless/bluetooth_1.2.6/application/common/: ApplMain.c ApplMain.h ble_conn_manager.c ble_conn_manager.h ble_init.h
  group source/common/gatt_db
    ../../../../../../../middleware/wireless/bluetooth_1.2.6/application/common/gatt_db/: gatt_database.c gatt_database_dynamic.c gatt_database_dynamic.h
  group board
    ../: board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h clock_config.c clock_config.h
  group bluetooth/host/interface
    ../../../../../../../middleware/wireless/bluetooth_1.2.6/host/interface/: att_errors.h att_types.h ble_constants.h ble_general.h ble_sig_defines.h ble_utils.h fsci_ble_interface.h gap_interface.h gap_types.h gatt_client_interface.h gatt_database.h gatt_db_app_interface.h gatt_interface.h gatt_server_interface.h gatt_types.h gatt_db_dynamic.h l2ca_cb_interface.h l2ca_interface.h l2ca_types.h vendor_debug_commands.h
  group bluetooth/host/config
    ../../../../../../../middleware/wireless/bluetooth_1.2.6/host/config/: ble_config.h ble_globals.c
  group bluetooth/host/source
    ../../../../../../../middleware/wireless/bluetooth_1.2.6/application/common/fsci_host/host/: host_ble.c host_ble.h host_gap.c host_gatt.c host_gatt_db.c host_l2cap.c
  group bluetooth/fsci
    ../../../../../../../middleware/wireless/bluetooth_1.2.6/application/common/fsci_host/fsci/: fsci_ble.c fsci_ble.h fsci_ble_types.c fsci_ble_types.h fsci_ble_gap.c fsci_ble_gap.h fsci_ble_gap_types.c fsci_ble_gap_types.h fsci_ble_gatt.c fsci_ble_gatt.h fsci_ble_gatt_types.c fsci_ble_gatt_types.h fsci_ble_gatt_db_app.c fsci_ble_gatt_db_app.h fsci_ble_gatt_db_app_types.c fsci_ble_gatt_db_app_types.h fsci_ble_l2cap.c fsci_ble_l2cap.h fsci_ble_l2cap_types.c fsci_ble_l2cap_types.h
  group bluetooth/profiles/battery
    ../../../../../../../middleware/wireless/bluetooth_1.2.6/profiles/battery/: battery_service.c battery_interface.h
  group bluetooth/profiles/device_info
    ../../../../../../../middleware/wireless/bluetooth_1.2.6/profiles/device_info/: device_info_service.c device_info_interface.h
  group bluetooth/profiles/heart_rate
    ../../../../../../../middleware/wireless/bluetooth_1.2.6/profiles/heart_rate/: heart_rate_service.c heart_rate_interface.h
  group doc
    ../../: readme.txt
  group drivers
    ../../../../../../../devices/MK22F51212/drivers/: fsl_common.h fsl_common.c fsl_rnga.c fsl_rnga.h fsl_flash.c fsl_flash.h fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_ftm.c fsl_ftm.h fsl_dspi.h fsl_dspi.c fsl_i2c.h fsl_i2c.c fsl_lptmr.c fsl_lptmr.h fsl_rtc.c fsl_rtc.h fsl_llwu.h fsl_llwu.c fsl_pmc.h fsl_pmc.c fsl_smc.h fsl_smc.c fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c
  group usb/device/source
    ../../../../../../../middleware/usb_1.6.3/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/khci
    ../../../../../../../middleware/usb_1.6.3/device/: usb_device_khci.c usb_device_khci.h
    ../../../../../../../middleware/usb_1.6.3/include/: usb_khci.h
  group usb/device/include
    ../../../../../../../middleware/usb_1.6.3/device/: usb_device.h
  group usb/include
    ../../../../../../../middleware/usb_1.6.3/include/: usb.h usb_misc.h usb_spec.h
  group utilities
    ../../../../../../../devices/MK22F51212/utilities/: fsl_debug_console.c fsl_debug_console.h
