# IAR project mwa_coordinator_fsci_host_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 NXP MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; CPU_MK22FN512VLH12; USB_KW41_K22; SDK_DEBUGCONSOLE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.PreInclude: ../../../../../../../boards/usbkw41z_k22f/wireless_examples/ieee_802_15_4/mwa_coordinator_fsci_host/bm/app_preinclude.h
  ICCARM.CCIncludePath2: ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../middleware/usb_1.6.3; ../../../../../../../middleware/usb_1.6.3/osa; ../../../../../../../middleware/usb_1.6.3/include; ../../../../../../../middleware/usb_1.6.3/device; ../../../../../../../middleware/wireless/framework_5.3.5/OSAbstraction/Interface; ..; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.5/mac/source/App; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.5/mac/interface; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.5/phy/interface; ../../../../../../../middleware/wireless/framework_5.3.5/GPIO; ../../../../../../../middleware/wireless/framework_5.3.5/Keyboard/Interface; ../../../../../../../middleware/wireless/framework_5.3.5/LED/Interface; ../../../../../../../middleware/wireless/framework_5.3.5/SerialManager/Source/SPI_Adapter; ../../../../../../../middleware/wireless/framework_5.3.5/SerialManager/Source; ../../../../../../../middleware/wireless/framework_5.3.5/FSCI/Interface; ../../../../../../../middleware/wireless/framework_5.3.5/FSCI/Source; ../../../../../../../middleware/wireless/framework_5.3.5/Common; ../../../../../../../middleware/wireless/framework_5.3.5/MemManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.5/Messaging/Interface; ../../../../../../../middleware/wireless/framework_5.3.5/Panic/Interface; ../../../../../../../middleware/wireless/framework_5.3.5/RNG/Interface; ../../../../../../../middleware/wireless/framework_5.3.5/SerialManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.5/SerialManager/Source/USB_VirtualCom; ../../../../../../../middleware/wireless/framework_5.3.5/TimersManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.5/TimersManager/Source; ../../../../../../../middleware/wireless/framework_5.3.5/ModuleInfo; ../../../../../../../middleware/wireless/framework_5.3.5/FunctionLib; ../../../../../../../middleware/wireless/framework_5.3.5/Lists; ../../../../../../../middleware/wireless/framework_5.3.5/SecLib; ../../../../../../../middleware/wireless/framework_5.3.5/Flash/Internal; ../../../../../../../middleware/wireless/framework_5.3.5/MWSCoexistence/Interface; ../..; ../../../../../../../devices/MK22F51212/drivers; ../../../../../../../devices/MK22F51212; ../../../../../../../devices/MK22F51212/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: mwa_coordinator_fsci_host_usbkw41z_k22f.bin
  ILINK.IlinkOutputFile: mwa_coordinator_fsci_host_bm.out
  ILINK.IlinkIcfFile: MK22FN512xxx12_connectivity.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../middleware/wireless/framework_5.3.5/SecLib/lib_crypto_m4.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK22FN512VLH12; USB_KW41_K22; SDK_DEBUGCONSOLE=1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group startup
    ../../../../../../../devices/MK22F51212/iar/: startup_MK22F51212.s
    ../../../../../../../devices/MK22F51212/: system_MK22F51212.c system_MK22F51212.h
  group osa
    ../../../../../../../middleware/usb_1.6.3/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group framework/OSAbstraction/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/OSAbstraction/Interface/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.h
  group framework/OSAbstraction/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/OSAbstraction/Source/: fsl_os_abstraction_bm.c
  group framework/GPIO/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/GPIO/: GPIO_Adapter.h
  group framework/GPIO/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/GPIO/: GPIO_Adapter.c
  group framework/Keyboard/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/Keyboard/Interface/: Keyboard.h
  group framework/Keyboard/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/Keyboard/Source/: Keyboard.c
  group framework/LED/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/LED/Interface/: LED.h
  group framework/LED/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/LED/Source/: LED.c
  group framework/Reset/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/Reset/: Reset.c
  group framework/SerialManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/SerialManager/Source/: UART_Adapter.h UART_Adapter.c I2C_Adapter.h I2C_Adapter.c SerialManager.c
  group framework/SerialManager/Source/SPI_Adapter
    ../../../../../../../middleware/wireless/framework_5.3.5/SerialManager/Source/SPI_Adapter/: SPI_Adapter.h SPI_Adapter.c
  group framework/SerialManager/Source/USB_VirtualCom/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/SerialManager/Source/USB_VirtualCom/: VirtualComInterface.h
  group framework/SerialManager/Source/USB_VirtualCom/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/SerialManager/Source/USB_VirtualCom/: usb_device_cdc_acm.h usb_device_cdc_acm.c usb_device_ch9.h usb_device_ch9.c usb_device_class.h usb_device_class.c usb_device_config.h usb_device_descriptor.h usb_device_descriptor.c virtual_com.h virtual_com.c
  group framework/SerialManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/SerialManager/Interface/: SerialManager.h
  group framework/FSCI/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/FSCI/Interface/: FsciInterface.h
  group framework/FSCI/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/FSCI/Source/: FsciCommands.c FsciCommands.h FsciCommunication.c FsciCommunication.h FsciLogging.c FsciMain.c
  group framework/Common
    ../../../../../../../middleware/wireless/framework_5.3.5/Common/: EmbeddedTypes.h
  group framework/MemManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/MemManager/Interface/: MemManager.h
  group framework/MemManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/MemManager/Source/: MemManager.c
  group framework/Messaging/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/Messaging/Source/: Messaging.c
  group framework/Panic/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/Panic/Interface/: Panic.h
  group framework/Panic/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/Panic/Source/: Panic.c
  group framework/RNG/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/RNG/Source/: RNG.c
  group framework/TimersManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/TimersManager/Interface/: TimersManager.h
  group framework/TimersManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/TimersManager/Source/: TimersManager.c TimersManagerInternal.h TMR_Adapter.h TMR_Adapter.c
  group framework/ModuleInfo
    ../../../../../../../middleware/wireless/framework_5.3.5/ModuleInfo/: ModuleInfo.h ModuleInfo.c
  group framework/FunctionLib
    ../../../../../../../middleware/wireless/framework_5.3.5/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/Lists
    ../../../../../../../middleware/wireless/framework_5.3.5/Lists/: GenericList.c GenericList.h
  group framework/SecLib
    ../../../../../../../middleware/wireless/framework_5.3.5/SecLib/: SecLib.h SecLib.c
  group framework/Flash/Internal
    ../../../../../../../middleware/wireless/framework_5.3.5/Flash/Internal/: Flash_Adapter.h Flash_Adapter.c
  group framework/MWSCoexistence/Interface
    ../../../../../../../middleware/wireless/framework_5.3.5/MWSCoexistence/Interface/: MWS.h
  group framework/MWSCoexistence/Source
    ../../../../../../../middleware/wireless/framework_5.3.5/MWSCoexistence/Source/: MWS.c
  group source
    ../: app_preinclude.h
    ../../: mwa_coordinator_fsci_host.c mwa_coordinator_fsci_host.h
  group board
    ../: board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h clock_config.c clock_config.h
  group ieee_802.15.4/App
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.5/mac/source/App/: FsciAspCommands.h FsciAspCommands.c FsciMacCommands.h FsciMacCommands.c MacGlobals.c MacGlobals.h
  group ieee_802.15.4/mac/interface
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.5/mac/interface/: MacFunctionalityDefines.h MacInterface.h MacMessages.h MacTypes.h
  group ieee_802.15.4/ASP
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.5/phy/interface/: AspInterface.h
  group doc
    ../../: readme.txt
  group drivers
    ../../../../../../../devices/MK22F51212/drivers/: fsl_common.h fsl_common.c fsl_rnga.c fsl_rnga.h fsl_flash.c fsl_flash.h fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_ftm.c fsl_ftm.h fsl_dspi.h fsl_dspi.c fsl_i2c.h fsl_i2c.c fsl_lptmr.c fsl_lptmr.h fsl_rtc.c fsl_rtc.h fsl_llwu.h fsl_llwu.c fsl_pmc.h fsl_pmc.c fsl_smc.h fsl_smc.c fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c
  group usb/device/source
    ../../../../../../../middleware/usb_1.6.3/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/khci
    ../../../../../../../middleware/usb_1.6.3/device/: usb_device_khci.c usb_device_khci.h
    ../../../../../../../middleware/usb_1.6.3/include/: usb_khci.h
  group usb/device/include
    ../../../../../../../middleware/usb_1.6.3/device/: usb_device.h
  group usb/include
    ../../../../../../../middleware/usb_1.6.3/include/: usb.h usb_misc.h usb_spec.h
  group utilities
    ../../../../../../../devices/MK22F51212/utilities/: fsl_debug_console.c fsl_debug_console.h
