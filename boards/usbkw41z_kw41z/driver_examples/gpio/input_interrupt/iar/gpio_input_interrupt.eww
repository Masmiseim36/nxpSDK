<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>gpio_input_interrupt</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>gpio_input_interrupt</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>gpio_input_interrupt</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>gpio_input_interrupt</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/gpio_input_interrupt.ewp</path>
  </project>
</workspace>
