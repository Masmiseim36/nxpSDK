<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>ble_fsci_black_box_freertos</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>ble_fsci_black_box_freertos</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>ble_fsci_black_box_freertos</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>ble_fsci_black_box_freertos</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/ble_fsci_black_box_freertos.ewp</path>
  </project>
</workspace>
