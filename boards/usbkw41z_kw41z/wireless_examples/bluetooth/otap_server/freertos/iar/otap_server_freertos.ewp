# IAR project otap_server_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW41Z512xxx4 NXP MKW41Z512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKW41Z512VHT4; FSL_RTOS_FREE_RTOS; USB_KW41; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.PreInclude: ../../../../../../../boards/usbkw41z_kw41z/wireless_examples/bluetooth/otap_server/freertos/app_preinclude.h
  ICCARM.CCIncludePath2: ../../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM0; ../../../../../../../rtos/freertos_9.0.0/Source/include; ..; ../../../../../../../rtos/freertos_9.0.0/Source; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../middleware/wireless/framework_5.3.8/OSAbstraction/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/Flash/Internal; ../../../../../../../middleware/wireless/framework_5.3.8/Flash/External/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/GPIO; ../../../../../../../middleware/wireless/framework_5.3.8/Keyboard/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/LED/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/SerialManager/Source/SPI_Adapter; ../../../../../../../middleware/wireless/framework_5.3.8/Common; ../../../../../../../middleware/wireless/framework_5.3.8/FSCI/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/FSCI/Source; ../../../../../../../middleware/wireless/framework_5.3.8/MemManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/Messaging/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/LowPower/Interface/MKW41Z; ../../../../../../../middleware/wireless/framework_5.3.8/OtaSupport/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/Panic/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/RNG/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/NVM/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/NVM/Source; ../../../../../../../middleware/wireless/framework_5.3.8/SerialManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/SerialManager/Source; ../../../../../../../middleware/wireless/framework_5.3.8/TimersManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/TimersManager/Source; ../../../../../../../middleware/wireless/framework_5.3.8/ModuleInfo; ../../../../../../../middleware/wireless/framework_5.3.8/FunctionLib; ../../../../../../../middleware/wireless/framework_5.3.8/Lists; ../../../../../../../middleware/wireless/framework_5.3.8/SecLib; ../../../../../../../middleware/wireless/bluetooth_1.2.8/host/interface; ../../../../../../../middleware/wireless/bluetooth_1.2.8/host/config; ../../../../../../../middleware/wireless/bluetooth_1.2.8/application/common; ../../../../../../../middleware/wireless/bluetooth_1.2.8/controller/interface; ../../../../../../../middleware/wireless/bluetooth_1.2.8/hci_transport/interface; ../../../../../../../middleware/wireless/bluetooth_1.2.8/application/common/gatt_db; ../../../../../../../middleware/wireless/bluetooth_1.2.8/application/common/gatt_db/macros; ../../../../../../../middleware/wireless/bluetooth_1.2.8/profiles/battery; ../../../../../../../middleware/wireless/bluetooth_1.2.8/profiles/device_info; ../../../../../../../middleware/wireless/bluetooth_1.2.8/profiles/otap; ../../../../../../../middleware/wireless/framework_5.3.8/MWSCoexistence/Interface; ../..; ../../../../../../../devices/MKW41Z4/drivers; ../../../../../../../middleware/wireless/framework_5.3.8/DCDC/Interface; ../../../../../../../middleware/wireless/framework_5.3.8/XCVR/MKW41Z4; ../../../../../../../devices/MKW41Z4; ../../../../../../../devices/MKW41Z4/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: otap_server_usbkw41z_kw41z.bin
  ILINK.IlinkOutputFile: otap_server_freertos.out
  ILINK.IlinkConfigDefines: gUseNVMLink_d=1; gEraseNVMLink_d=1
  ILINK.IlinkIcfFile: MKW41Z512xxx4_connectivity.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../middleware/wireless/bluetooth_1.2.8/host/lib/lib_ble_4-2_host_central_cm0p.a; ../../../../../../../middleware/wireless/bluetooth_1.2.8/controller/lib/lib_ble_kw41z_controller.a; ../../../../../../../middleware/wireless/framework_5.3.8/SecLib/lib_crypto_m0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW41Z512VHT4; FSL_RTOS_FREE_RTOS; USB_KW41; FREEDOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group freertos
    ../../../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
    ../../../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
    ../../../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group freertos/portable
    ../../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM0/: port.c fsl_tickless_systick.c fsl_tickless_generic.h portasm.s portmacro.h
  group startup
    ../../../../../../../devices/MKW41Z4/iar/: startup_MKW41Z4.s
    ../../../../../../../devices/MKW41Z4/: system_MKW41Z4.c system_MKW41Z4.h
  group framework/OSAbstraction
    ../../../../../../../middleware/wireless/framework_5.3.8/OSAbstraction/Interface/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h
    ../../../../../../../middleware/wireless/framework_5.3.8/OSAbstraction/Source/: fsl_os_abstraction_free_rtos.c
  group framework/OSAbstraction/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/OSAbstraction/Interface/: fsl_os_abstraction.h fsl_os_abstraction_config.h
  group framework/Flash/Internal
    ../../../../../../../middleware/wireless/framework_5.3.8/Flash/Internal/: Flash_Adapter.h Flash_Adapter.c
  group framework/Flash/External/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/Flash/External/Interface/: Eeprom.h
  group framework/Flash/External/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/Flash/External/Source/: Eeprom_AT26DF081A.c Eeprom_AT45DB021E.c Eeprom_AT45DB041E.c Eeprom_AT45DB161E.c Eeprom_InternalFlash.c
  group framework/GPIO/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/GPIO/: GPIO_Adapter.h
  group framework/GPIO/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/GPIO/: GPIO_Adapter.c
  group framework/Keyboard/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/Keyboard/Interface/: Keyboard.h
  group framework/Keyboard/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/Keyboard/Source/: Keyboard.c
  group framework/LED/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/LED/Interface/: LED.h
  group framework/LED/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/LED/Source/: LED.c
  group framework/Reset/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/Reset/: Reset.c
  group framework/SerialManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/SerialManager/Source/: SerialManager.c UART_Adapter.h UART_Adapter.c
  group framework/SerialManager/Source/SPI_Adapter
    ../../../../../../../middleware/wireless/framework_5.3.8/SerialManager/Source/SPI_Adapter/: SPI_Adapter.h SPI_Adapter.c
  group framework/SerialManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/SerialManager/Interface/: SerialManager.h
  group framework/Common
    ../../../../../../../middleware/wireless/framework_5.3.8/Common/: EmbeddedTypes.h
  group framework/FSCI/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/FSCI/Interface/: FsciInterface.h
  group framework/FSCI/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/FSCI/Source/: FsciCommands.c FsciCommands.h FsciCommunication.c FsciCommunication.h FsciLogging.c FsciMain.c
  group framework/MemManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/MemManager/Interface/: MemManager.h
  group framework/MemManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/MemManager/Source/: MemManager.c
  group framework/Messaging/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/Messaging/Source/: Messaging.c
  group framework/LowPower/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/LowPower/Interface/MKW41Z/: PWR_Configuration.h PWR_Interface.h
  group framework/LowPower/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/LowPower/Source/MKW41Z/: PWR.c PWRLib.c PWRLib.h PWR_BLE.c PWR_BLE.h
  group framework/OtaSupport/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/OtaSupport/Interface/: OtaSupport.h
  group framework/OtaSupport/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/OtaSupport/Source/: OtaSupport.c
  group framework/Panic/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/Panic/Interface/: Panic.h
  group framework/Panic/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/Panic/Source/: Panic.c
  group framework/RNG/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/RNG/Source/: RNG.c
  group framework/NVM/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/NVM/Interface/: NVM_Interface.h
  group framework/NVM/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/NVM/Source/: NV_Flash.c NV_Flash.h NV_FsciCommands.c NV_FsciCommands.h
  group framework/TimersManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/TimersManager/Interface/: TimersManager.h
  group framework/TimersManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/TimersManager/Source/: TimersManager.c TimersManagerInternal.h TMR_Adapter.h TMR_Adapter.c
  group framework/ModuleInfo
    ../../../../../../../middleware/wireless/framework_5.3.8/ModuleInfo/: ModuleInfo.h ModuleInfo.c
  group framework/FunctionLib
    ../../../../../../../middleware/wireless/framework_5.3.8/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/Lists
    ../../../../../../../middleware/wireless/framework_5.3.8/Lists/: GenericList.c GenericList.h
  group framework/SecLib
    ../../../../../../../middleware/wireless/framework_5.3.8/SecLib/: SecLib.h SecLib.c
  group framework/MWSCoexistence/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/MWSCoexistence/Interface/: MWS.h
  group framework/MWSCoexistence/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/MWSCoexistence/Source/: MWS.c
  group framework/DCDC/Interface
    ../../../../../../../middleware/wireless/framework_5.3.8/DCDC/Interface/: DCDC.h
  group framework/DCDC/Source
    ../../../../../../../middleware/wireless/framework_5.3.8/DCDC/Source/: DCDC.c
  group framework/XCVR/MKW41Z4
    ../../../../../../../middleware/wireless/framework_5.3.8/XCVR/MKW41Z4/: fsl_xcvr.c fsl_xcvr.h ifr_radio.c ifr_radio.h fsl_xcvr_trim.c fsl_xcvr_trim.h dbg_ram_capture.c dbg_ram_capture.h
    ../../../../../../../middleware/wireless/framework_5.3.8/XCVR/MKW41Z4/cfgs_kw4x_3x_2x/: fsl_xcvr_ble_config.c fsl_xcvr_ant_config.c fsl_xcvr_zgbe_config.c fsl_xcvr_msk_config.c fsl_xcvr_common_config.c fsl_xcvr_mode_datarate_config.c fsl_xcvr_gfsk_bt_0p3_h_0p5_config.c fsl_xcvr_gfsk_bt_0p5_h_0p5_config.c fsl_xcvr_gfsk_bt_0p5_h_0p7_config.c fsl_xcvr_gfsk_bt_0p5_h_0p32_config.c fsl_xcvr_gfsk_bt_0p5_h_1p0_config.c fsl_xcvr_gfsk_bt_0p7_h_0p5_config.c
  group source
    ../: app_preinclude.h FreeRTOSConfig.h
    ../../: otap_server.c otap_server.h app_config.c gatt_db.h gatt_uuid128.h fsci_ble_otap.c fsci_ble_otap.h
  group source/common
    ../../../../../../../middleware/wireless/bluetooth_1.2.8/application/common/: ble_host_tasks.c ble_host_task_config.h ble_conn_manager.c ble_conn_manager.h ble_controller_task.c ble_controller_task_config.h ApplMain.c ApplMain.h ble_init.c ble_init.h ieee11073.h
  group source/common/gatt_db
    ../../../../../../../middleware/wireless/bluetooth_1.2.8/application/common/gatt_db/: gatt_database.c gatt_db_handles.h
  group source/common/gatt_db/macros
    ../../../../../../../middleware/wireless/bluetooth_1.2.8/application/common/gatt_db/macros/: gatt_alloc_x.h gatt_db_macros.h gatt_db_x_macros.h gatt_decl_x.h gatt_enum_x.h gatt_init_x.h gatt_size_x.h gatt_uuid_decl_x.h gatt_uuid_def_x.h
  group board
    ../: board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h clock_config.c clock_config.h
  group bluetooth/host/interface
    ../../../../../../../middleware/wireless/bluetooth_1.2.8/host/interface/: att_callbacks.h att_errors.h att_interface.h att_params.h att_types.h ble_constants.h ble_general.h ble_host_tasks.h ble_sig_defines.h ble_utils.h gap_interface.h gap_types.h gatt_client_interface.h gatt_database.h gatt_db_app_interface.h gatt_db_dynamic.h gatt_interface.h gatt_server_interface.h gatt_types.h hci_interface.h hci_types.h l2ca_cb_interface.h l2ca_interface.h l2ca_types.h vendor_debug_commands.h
  group bluetooth/host/config
    ../../../../../../../middleware/wireless/bluetooth_1.2.8/host/config/: ble_config.h ble_globals.c
  group bluetooth/controller/interface
    ../../../../../../../middleware/wireless/bluetooth_1.2.8/controller/interface/: controller_interface.h
  group bluetooth/hci_transport/interface
    ../../../../../../../middleware/wireless/bluetooth_1.2.8/hci_transport/interface/: hci_transport.h
  group bluetooth/hci_transport/source
    ../../../../../../../middleware/wireless/bluetooth_1.2.8/hci_transport/source/: hcit_serial_interface.c
  group bluetooth/profiles/battery
    ../../../../../../../middleware/wireless/bluetooth_1.2.8/profiles/battery/: battery_service.c battery_interface.h
  group bluetooth/profiles/device_info
    ../../../../../../../middleware/wireless/bluetooth_1.2.8/profiles/device_info/: device_info_service.c device_info_interface.h
  group bluetooth/profiles/otap
    ../../../../../../../middleware/wireless/bluetooth_1.2.8/profiles/otap/: otap_service.c otap_interface.h
  group doc
    ../../: readme.txt
  group drivers
    ../../../../../../../devices/MKW41Z4/drivers/: fsl_common.h fsl_common.c fsl_trng.c fsl_trng.h fsl_flash.c fsl_flash.h fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_tpm.c fsl_tpm.h fsl_dspi.h fsl_dspi.c fsl_i2c.h fsl_i2c.c fsl_lptmr.c fsl_lptmr.h fsl_rtc.c fsl_rtc.h fsl_llwu.h fsl_llwu.c fsl_ltc.h fsl_ltc.c fsl_pmc.h fsl_pmc.c fsl_adc16.c fsl_adc16.h fsl_smc.h fsl_smc.c fsl_clock.h fsl_clock.c
  group utilities
    ../../../../../../../devices/MKW41Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
