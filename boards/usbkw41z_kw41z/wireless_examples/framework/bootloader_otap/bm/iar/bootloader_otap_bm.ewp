# IAR project bootloader_otap_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW41Z512xxx4 NXP MKW41Z512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKW41Z512VHT4; gEepromType_d=gEepromDevice_InternalFlash_c; gUseOTAPBootloader_d=1; USB_KW41; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../../CMSIS/Include; ../../../../../../../devices; ..; ../../src/bootloader; ../../src/eeprom; ../../src/flash; ../../src/spi; ../../src/timer; ../../src/uart; ../../../../../../../devices/MKW41Z4/drivers; ../../../../../../../devices/MKW41Z4; ../../../../../../../middleware/wireless/framework_5.3.5/Common; ../../../../../../../devices/MKW41Z4/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: bootloader_otap_usbkw41z_kw41z.bin
  ILINK.IlinkOutputFile: bootloader_otap_bm.out
  ILINK.IlinkConfigDefines: gRomSize_c=524288; gSectorSize_c=2048
  ILINK.IlinkIcfFile: Bootloader.icf
  ILINK.IlinkProgramEntryLabel: main
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW41Z512VHT4; gEepromType_d=gEepromDevice_InternalFlash_c; gUseOTAPBootloader_d=1; USB_KW41; FREEDOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group source
    ../../src/bootloader/: main.c main.h OtapBootloader.c OtapBootloader.h
  group source/config
    ../: usbkw41z_kw41z_cfg.h
  group source/drivers/eeprom
    ../../src/eeprom/: Eeprom_Boot.h Eeprom_Boot_InternalFlash.c
  group source/drivers/flash
    ../../src/flash/: flash_boot_kinetis.c flash_boot_kinetis.h
  group source/drivers/spi
    ../../src/spi/: SPI.c SPI.h
  group source/drivers/timer
    ../../src/timer/: timer.c timer.h
  group source/drivers/uart
    ../../src/uart/: UART.c UART.h
  group doc
    ../../: readme.txt
  group drivers
    ../../../../../../../devices/MKW41Z4/drivers/: fsl_common.h fsl_common.c fsl_lpuart.h fsl_lpuart.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group framework/Common
    ../../../../../../../middleware/wireless/framework_5.3.5/Common/: EmbeddedTypes.h
  group utilities
    ../../../../../../../devices/MKW41Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
